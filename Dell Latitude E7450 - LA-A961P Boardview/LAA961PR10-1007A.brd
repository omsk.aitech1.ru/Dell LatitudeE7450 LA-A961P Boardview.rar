# Allegro board LAA961PR10-1007A.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
BREATH_LED#: length 78.4
  TOP w0.102: QZ7.4 194.44,125.69 194.48,125.66 RZ34.1 v1(195.01,124.65) v2(195.01,124.07) ; UE2.B57 204.12,88.52 v2(203.68,88.95)
  IN4 w0.084: v2(168.6,133.34) 169.59,133.34 176.73,126.2 177.52,126.2 179.48,124.24 187.14,124.24 187.73,123.65 194.59,123.65 v2(195.01,124.07)
  BOTTOM w0.102: v2(168.6,133.34) 168.4,133.34 167.75,134 167.75,136.54 167.75,136.54 JDOCK1.98 ; v2(203.68,88.95) 203.68,89.24 203.27,89.65 203.27,91.04 202.55,91.75 201.54,91.75 200.6,92.69 200.6,98.31 200.17,98.74 200.17,103.02 199.99,103.2 199.99,108.76 200.01,108.78 200.01,116.64 195.01,121.64 v2(195.01,124.07)
BREATH_LED#_Q: length 2
  TOP w0.102: v1(189.92,125.66) RZ32.1 190.92,125.69 QZ7.3
BREATH_WHITE_LED: length 120.2
  TOP w0.102: v2(185.44,120.87) 185.64,120.87 186.72,121.95 v1(186.73,121.95) 188.19,123.41 190.19,123.41 190.88,124.11 RZ32.2 ; v2(222,60.2) 222,60.15 221.55,59.7 220.7,59.7 JIO1.2
  IN3 w0.122: v2(185.44,120.87) 185.44,119.8 187.4,117.84 201.56,117.84 201.87,117.53 203.14,117.53 203.76,118.15 212.71,118.15 212.82,118.03 214.7,118.03 216.66,120 221.57,120 221.76,119.8 222.65,119.8 223.24,120.4 226.05,120.4 228.86,117.59 228.86,115.37 227.61,114.13 227.61,91.83 229.48,89.97 229.48,80.88 229.81,80.55 229.81,67.58 225.87,63.65 225.87,62.18 223.9,60.2 v2(222,60.2)
BREATH_WHITE_LED#: length 118.8
  TOP w0.102: RZ34.2 195.93,123.71 195.39,123.18 188.75,123.18 185.7,120.13 175.2,120.13 v1(174.07,119) 172.61,117.54 v2(172.61,110.23)
  IN3 w0.122: v2(172.61,110.23) 172.61,110.29 171.05,111.85 163.54,111.85 162.12,113.28 162.12,114.64 162.71,115.24 162.71,118.16 160.4,120.47 143.89,120.47 142.54,119.12 141.05,119.12 137.84,115.91 128.19,115.91 126.59,114.3 118.96,114.3 116.11,117.15 113.49,117.15 111.58,119.05 v2(111.58,119.13)
  BOTTOM w0.102: v2(111.58,119.13) 113.39,120.93 117.21,120.93 118.18,119.96 118.76,119.96 119.21,119.51 JLED1.5
BST_3V:
  vias: v1(43.94,24.74)
BST_3V_C: length 1.2
  TOP w0.102: PC109.2 v1(41.03,27.4)
BST_5V: length 1.2
  TOP w0.102: PR109.1 v1(50.99,23.56)
BST_5V_C: length 1.2
  TOP w0.102: 52.39,24.76 v1(52.39,23.54)
BST_+V1.05SP: length 1.2
  TOP w0.102: PC302.1 v1(192.83,67.43)
  vias: v2(191.65,66.54)
BST_+V1.05SP_C: length 1.2
  TOP w0.102: PR312.1 190.5,67.54 v1(190.46,67.5)
BT_LED#: length 25.5
  IN3 w0.122: v2(170.56,86.16) 169.79,85.38 169.04,85.38 165.6,88.83 161.48,88.83 160.8,89.51 v2(160.8,90.4)
  BOTTOM w0.102: QZ2.4 162.55,94.76 160.8,93.01 v1(160.8,92.46) v2(160.8,90.4) 160.8,89.83 161.04,89.59 RZ15.1 ; v2(170.56,86.16) 171.01,86.6 172.66,86.6 174.05,88 JNGFF1.8
BT_RADIO_DIS#: length 23
  TOP w0.102: RE11.2 174.75,99.32 v2(174.75,100.03) 176,100.03 176.69,99.34 UE1.A13 ; DZ2.1 166.6,90.57 v1(166.6,93.92) 166.45,94.07 v2(166.45,99.32)
  IN1 w0.084: v2(166.45,99.32) 166.49,99.37 174.09,99.37 v2(174.75,100.03)
BT_RADIO_DIS#_R: length 28.4
  TOP w0.102: v2(165.48,93.15) v1(165.48,90.96) 165.48,89.65 167.39,87.75 DZ2.2
  IN3 w0.122: v2(182.13,91.61) 182.06,91.68 180.72,91.68 180.47,91.43 175.07,91.43 173.36,93.15 v2(165.48,93.15)
  BOTTOM w0.102: v2(182.13,91.61) 183.22,91.61 183.55,91.27 JNGFF1.46
CAM_MIC_CBL_DET#: length 80.2
  TOP w0.089: v2(137.17,87.16) 141.01,91.01 141.01,91.92
  TOP w0.102: RPC15.1 143.27,97.82 143.16,97.7 141.36,97.7 141.01,97.35 141.01,91.92
  IN2 w0.122: v2(100.08,115.12) 100.59,115.63 115.97,115.63 117.52,114.08 130.3,114.08 132.92,111.46 132.92,106.41 132.13,105.61 132.13,105.32 131.46,104.66 131.46,101.5 131.98,100.99 132.46,100.99 133.8,99.64 133.8,97.26 135.22,95.85 136.46,95.85 138.37,93.94 138.37,88.37 v2(137.17,87.16)
  BOTTOM w0.089: v2(137.17,87.16) 137.17,87.13 136.87,86.83 UC1.F4
  BOTTOM w0.102: v2(100.08,115.12) 99.97,115.23 JEDP1.14
CD3301_DCIN: length 5.3
  TOP w0.102: v1(15.89,30.28) PR835.2
  TOP w0.254: PR835.2 18.75,30.28 PC813.1 18.91,30.44 PU800.1
CD3301_SDC_IN: length 2.4
  TOP w0.254: PU800.6 21.41,31.22 21.77,30.85 PR847.2
CD_PBATT_OFF: length 2.4
  TOP w0.254: PU800.27 18.91,38.95 18.3,39.55 v1(18.3,39.64) PR843.1
CFG0: length 65.2
  TOP w0.102: JXDP1.9 58.25,48.97 59.09,49.81 63.23,49.81 64.34,50.92 64.8,50.92 65.21,50.51 66.98,50.51 v2(67.33,50.86) ; v2(97.72,77.29) 96.49,76.06 RC183.1
  IN2 w0.089: v2(97.72,77.29) 97.45,77.03
  IN2 w0.122: v2(67.33,50.86) 67.33,51.13 82.66,66.46 82.66,71.04 87.18,75.56 90.96,75.56 92.22,76.83 97.25,76.83 97.45,77.03
  BOTTOM w0.076: v2(97.72,77.29) 98.06,77.64 99.75,77.64 100,77.38 100.38,77.38 100.54,77.55 101.33,77.55 101.37,77.51 101.85,77.51 UC1.AC60
CFG1: length 66.4
  TOP w0.102: JXDP1.11 58.75,47.95 59.19,48.38 v2(59.34,48.38)
  IN2 w0.122: v2(93.54,79.26) 93.34,79.06 89.85,79.06 88.76,77.96 87.12,77.96 80.9,71.75 80.9,67.2 72.84,59.14 69.43,59.14 69.06,58.77 69.06,56.96 68.6,56.49 65.03,56.49 63.7,55.17 63.7,50.36 62.79,49.46 61.59,49.46 60.51,48.38 v2(59.34,48.38)
  BOTTOM w0.076: 97.45,77.73 97.59,77.73 97.66,77.8 99.81,77.8 100.07,77.55 100.31,77.55 100.6,77.84 UC1.AC62
  BOTTOM w0.102: 95.4,78.59 96.27,77.73 97.45,77.73 ; 94.22,78.59 v2(93.54,79.26) 93.35,79.07 v1(92.7,79.07) 92.5,79.07 91.78,78.35 RC184.1
  BOTTOM w0.109: 95.4,78.59 94.22,78.59
CFG2: length 63.2
  TOP w0.102: v2(59.35,49.01) 59.35,48.95 59.75,48.54 JXDP1.15
  IN2 w0.122: v2(94.19,79.26) 93.78,79.68 93.34,79.68 92.97,79.31 89.75,79.31 88.65,78.21 87.01,78.21 80.66,71.86 80.66,67.3 72.74,59.38 69.33,59.38 68.82,58.87 68.82,57.06 68.5,56.74 64.89,56.74 63.45,55.3 63.45,50.47 62.76,49.77 60.11,49.77 v2(59.35,49.01)
  BOTTOM w0.076: 97.45,77.96 97.46,77.97 100.06,77.97 UC1.AC63
  BOTTOM w0.102: 97.45,77.96 96.37,77.96 95.5,78.83 94.63,78.83 v2(94.19,79.26)
CFG3: length 62.9
  TOP w0.102: JXDP1.17 60.25,48.37 59.76,48.86 59.76,49.29 60.05,49.58 63.32,49.58 64.26,50.51 v2(64.63,50.51) ; RC305.1 96.55,78.89 v2(96.8,79.14) ; v2(69.73,58.47) v1(70.3,57.9) 70.74,57.46 RC113.2
  IN2 w0.122: v2(64.63,50.51) 64.63,51.11 69.73,56.2 v2(69.73,58.47) 72.88,58.47 81.41,67.01 81.41,71.56 87,77.14 88.64,77.14 90.04,78.55 96.21,78.55 v2(96.8,79.14)
  BOTTOM w0.076: 97.45,78.67 98.18,78.67 98.38,78.47 100.07,78.47 UC1.AA63
  BOTTOM w0.102: v2(96.8,79.14) 97.26,78.67 97.45,78.67
CFG3_R: length 3.4
  TOP w0.102: JXDP1.60 v1(70.75,54.6) 70.75,55.19 70.74,55.2 RC113.1
CFG4: length 57.8
  TOP w0.102: JXDP1.27 62.75,48.65 64.2,50.09 66.03,50.09 v2(66.47,49.65)
  TOP w0.109: v2(91.7,77.24) v1(92.1,77.65) 92.3,77.84 98.48,77.84 RC191.1 99.27,78.63 101.42,78.63 v2(101.84,78.21)
  IN2 w0.122: v2(66.47,49.65) 66.66,49.84 66.66,51.17 82.16,66.67 82.16,71.25 87.14,76.23 90.68,76.23 v2(91.7,77.24)
  BOTTOM w0.076: v2(101.84,78.21) 102.14,78.51 UC1.AA60
CFG5: length 55.5
  TOP w0.102: JXDP1.29 63.25,48.83 64.03,49.6 v2(65.25,49.6)
  IN2 w0.089: 97.45,78.01 97.62,78.01 v2(98.75,79.14)
  IN2 w0.122: 97.45,78.01 90.24,78.01 88.87,76.65 87.21,76.65 81.91,71.35 81.91,66.77 66.41,51.27 66.41,50.76 v2(65.25,49.6)
  BOTTOM w0.076: v2(98.75,79.14) 98.75,79.07 99.01,78.8 99.75,78.8 100,79.05 100.31,79.05 100.6,79.34 UC1.Y62
CFG6: length 57.2
  TOP w0.102: v2(64.01,48.95) 64.39,48.57 64.39,48.12 64.25,47.98 JXDP1.33
  IN2 w0.089: v2(101.19,79.71) 99.24,77.76 97.45,77.76
  IN2 w0.122: 97.45,77.76 92.81,77.76 90.86,75.81 87.08,75.81 82.41,71.15 82.41,66.56 66.91,51.07 66.91,49.45 65.43,47.96 65,47.96 v2(64.01,48.95)
  BOTTOM w0.076: v2(101.19,79.71) 101.49,79.41 UC1.Y61
CFG7: length 56.3
  TOP w0.102: JXDP1.35 64.75,48.87 64.9,49.01 v2(65.22,49.01)
  IN2 w0.089: v2(98.1,79.14) 97.45,78.49
  IN2 w0.122: v2(65.22,49.01) 64.84,49.39 64.84,50.01 65.82,51 65.82,51.03 81.66,66.87 81.66,71.46 87.1,76.89 88.74,76.89 90.13,78.28 97.24,78.28 97.45,78.49
  BOTTOM w0.076: UC1.Y60 101.85,79.01 101.37,79.01 101.33,79.05 100.54,79.05 100.38,78.88 100.07,78.88 99.82,78.64 98.53,78.64 98.1,79.07 v2(98.1,79.14)
CFG8: length 64.3
  TOP w0.102: v1(61.66,55.07) 61.66,55.08 ; 61.66,55.08 61.5,55.24 58.87,55.24 58.25,54.62 JXDP1.10 ; 61.66,55.08 v2(62.12,54.62)
  TOP w0.109: RC190.1 93.07,78.91 93.07,79.51 93.31,79.75 94.06,79.75 v2(94.8,80.49)
  IN2 w0.122: v2(62.12,54.62) 62.12,56.61 63.53,58.02 64.64,58.02 67,60.38 72.32,60.38 79.66,67.71 79.66,72.27 86.6,79.21 88.23,79.21 90.29,81.27 94.03,81.27 v2(94.8,80.49)
  BOTTOM w0.076: 97.64,79.56 100,79.56 100.07,79.63 100.38,79.63 UC1.V62
  BOTTOM w0.102: 97.64,79.56 96.31,79.56 96.06,79.81 95.48,79.81 v2(94.8,80.49)
CFG9: length 66.9
  TOP w0.102: v2(96.09,80.49) 96.09,80.35 RC189.1 ; JXDP1.12 58.75,51.35 60.07,50.03 61.76,50.03 v2(62.24,50.51)
  IN2 w0.122: v2(96.09,80.49) 95.06,81.51 90.19,81.51 88.13,79.46 86.5,79.46 79.41,72.37 79.41,67.82 72.22,60.63 66.9,60.63 64.54,58.27 63.43,58.27 61.7,56.54 61.7,53.85 62.64,52.91 62.64,50.91 v2(62.24,50.51)
  BOTTOM w0.076: UC1.V61 101.24,80.38 100.72,80.38 100.48,80.14 100.48,79.97 100.31,79.79 99.82,79.79 99.75,79.73 97.92,79.73 97.83,79.81
  BOTTOM w0.102: v2(96.09,80.49) 96.77,79.81 97.83,79.81
CFG10: length 68.7
  TOP w0.102: JXDP1.16 59.75,54.29 v2(59.31,54.73)
  IN1 w0.084: v2(101.84,79.71) 101.84,79.85 100.34,81.35 100.34,83.9 98.83,85.41 94.86,85.41 v2(94.34,84.89)
  IN2 w0.122: v2(94.34,84.89) 93.8,84.89 91.92,83.01 87.94,83.01 84.24,79.31 83.04,79.31 81.53,77.8 81.53,76.6 77.92,72.99 77.92,68.44 71.6,62.12 62.98,62.12 61.13,60.27 61.13,59.15 59.59,57.61 59.59,55.01 v2(59.31,54.73)
  BOTTOM w0.076: v2(101.84,79.71) 102.14,80.01 UC1.V60
  BOTTOM w0.102: RC188.1 94.08,84.89 v2(94.34,84.89)
CFG11: length 60
  TOP w0.102: v2(61.2,54.83) 60.57,54.83 v1(60.38,54.64) 60.25,54.51 JXDP1.18
  IN2 w0.122: v2(61.2,54.83) 61.2,56.4 63.33,58.52 64.43,58.52 66.8,60.88 72.12,60.88 79.16,67.92 79.16,72.47 86.39,79.71 88.03,79.71 90.08,81.76 95.4,81.76 v2(96.68,80.49)
  BOTTOM w0.076: UC1.U60 101.85,80.51 101.37,80.51 101.33,80.54 100.54,80.54 100.38,80.38 100,80.38 99.79,80.59 99.47,80.59 98.78,79.91 97.99,79.91 97.83,80.06
  BOTTOM w0.102: v2(96.68,80.49) 97.1,80.06 97.83,80.06
CFG12: length 61.7
  TOP w0.102: v2(62.22,51.09) 62.53,51.09 62.75,51.31 JXDP1.28
  IN2 w0.122: v2(93.89,82.62) 93.28,82.01 89.98,82.01 87.92,79.95 86.29,79.95 78.91,72.58 78.91,68.02 72.02,61.13 66.69,61.13 64.33,58.77 63.22,58.77 60.79,56.33 60.79,53.18 62.22,51.74 v2(62.22,51.09)
  BOTTOM w0.076: 97.45,81.4 99.1,81.4 99.28,81.59 UC1.T63
  BOTTOM w0.102: v2(93.89,82.62) 93.89,81.91 94.25,81.55 ; 94.25,81.55 94.4,81.4 97.45,81.4 ; 94.25,81.55 v1(94.25,81.55)
CFG13: length 56.1
  TOP w0.102: JXDP1.30 63.25,54.38 v2(62.97,54.66)
  IN2 w0.122: v2(94.15,80.49) 93.63,81.02 90.39,81.02 88.34,78.96 86.7,78.96 79.91,72.16 79.91,67.61 72.43,60.13 67.1,60.13 64.74,57.77 63.64,57.77 62.55,56.69 62.55,55.08 v2(62.97,54.66)
  BOTTOM w0.076: UC1.T62 100.39,81.14 100.39,81.14 100.38,81.13 99.3,81.13 99.1,80.93 97.46,80.93
  BOTTOM w0.102: 97.46,80.93 97.45,80.92 94.59,80.92 v2(94.15,80.49)
CFG14: length 56.8
  TOP w0.102: JXDP1.34 64.25,53.83 64.52,54.1 64.52,55.23 63.41,56.35 v2(63.12,56.35)
  IN2 w0.122: v2(92.85,80.55) 92.46,80.16 89.88,80.16 88.44,78.71 86.81,78.71 80.16,72.06 80.16,67.51 72.53,59.88 67.21,59.88 64.85,57.52 63.74,57.52 63.12,56.9 v2(63.12,56.35)
  BOTTOM w0.076: UC1.T61 101.24,81.88 100.72,81.88 100.48,81.64 100.48,81.46 100.31,81.29 99.23,81.29 99.1,81.16 97.45,81.16
  BOTTOM w0.102: 97.45,81.16 93.47,81.16 v2(92.85,80.55)
CFG15: length 63.2
  TOP w0.102: v2(61.79,59.04) 61.79,58.28 v1(62.94,57.14) 64.75,55.32 JXDP1.36
  IN2 w0.122: v2(61.79,59.04) 62.44,59.04 65.27,61.87 71.71,61.87 78.17,68.33 78.17,72.89 81.78,76.5 81.78,77.7 82.97,78.89 84.17,78.89 88.04,82.76 92.02,82.76 93.31,84.05 97.42,84.05 99.83,81.64 101.41,81.64 v2(101.84,81.21)
  BOTTOM w0.076: v2(101.84,81.21) 102.14,81.51 UC1.T60
CFG16: length 59.9
  TOP w0.102: v2(62.97,55.26) 62.74,55.49 58.24,55.49 v1(57.25,54.51) JXDP1.6
  IN2 w0.122: v2(95.5,79.26) 94.83,79.93 93.02,79.93 92.65,79.56 89.65,79.56 88.55,78.46 86.91,78.46 80.41,71.96 80.41,67.41 72.63,59.63 67.31,59.63 62.97,55.29 v2(62.97,55.26)
  BOTTOM w0.076: 97.45,78.2 98.07,78.2 98.14,78.13 100.38,78.13 100.78,78.53 100.78,78.53 100.78,78.53 UC1.AA62
  BOTTOM w0.102: v2(95.5,79.26) 95.5,79.21 96.51,78.2 97.45,78.2
CFG17: length 62.4
  TOP w0.102: v2(64.12,54.99) 63.39,55.72 v1(57.99,55.72) 57.47,55.72 56.75,55 JXDP1.4
  IN2 w0.122: v2(64.12,54.99) 65.37,56.24 68.7,56.24 69.31,56.86 69.31,58.66 69.54,58.89 72.94,58.89 81.17,67.11 81.17,71.66 86.9,77.39 88.54,77.39 89.96,78.81 95.82,78.81 v2(96.15,79.14)
  BOTTOM w0.076: UC1.AA61 101.24,78.88 100.72,78.88 100.55,78.71 100.55,78.53 100.31,78.3 98.26,78.3 98.12,78.43 97.45,78.43
  BOTTOM w0.102: v2(96.15,79.14) 96.15,78.89 96.6,78.43 97.45,78.43
CFG18: length 65.7
  TOP w0.102: v2(61.27,50.44) 61.75,50.93 JXDP1.24
  IN2 w0.122: v2(98.55,80.49) 98.55,82.64 97.38,83.81 93.42,83.81 92.12,82.51 88.14,82.51 78.41,72.78 78.41,68.23 71.81,61.62 65.38,61.62 60.17,56.41 60.17,51.52 61.25,50.44 v2(61.27,50.44)
  BOTTOM w0.076: v2(98.55,80.49) 98.9,80.49 99.33,80.92 100.1,80.92 UC1.U63
CFG19: length 64.8
  TOP w0.102: v2(61.25,51.06) JXDP1.22
  IN2 w0.122: v2(97.97,80.49) 97.97,82.91 97.33,83.56 93.52,83.56 92.22,82.26 89.88,82.26 87.82,80.2 86.19,80.2 78.66,72.68 78.66,68.13 71.91,61.38 65.48,61.38 60.42,56.31 60.42,51.89 v2(61.25,51.06)
  BOTTOM w0.076: v2(97.97,80.49) 98.39,80.07 98.72,80.07 99.4,80.76 99.86,80.76 100.07,80.54 100.31,80.54 100.6,80.84 UC1.U62
CFG_RCOMP: length 11.8
  IN1 w0.305: v2(99.61,80.17) 99.34,79.9 92.57,79.9 92.23,80.25 v2(92.23,80.58)
  BOTTOM w0.305: v2(92.23,80.58) 92.23,80.17 91.42,79.37 90.5,79.37 90.2,79.67 RC185.1 ; UC1.V63 99.69,80.09 v2(99.61,80.17)
CHAGER_SRC:
  vias: v1(40.63,50.18) v2(40.1,48.91) v4(34.69,48.39) v4(34.69,47.76) v4(35.32,48.39) v4(35.32,47.76) v4(35.96,48.39) v4(35.96,47.76) v4(36.59,48.39) v4(36.59,47.76) v4(40.11,55.15) v4(40.11,54.51) v4(40.11,53.88) v4(40.11,53.24) v4(40.11,52.61) v4(40.74,55.15) v4(40.74,54.51) v4(40.74,53.88) v4(40.74,53.24) v4(40.74,52.61) v4(41.39,53.23) v4(41.39,52.57)
CHARGER_CELL_PIN: length 5.2
  TOP w0.102: v1(36.27,37.37) 36.49,37.58 36.49,38.09 PR729.1
  TOP w0.254: PR725.2 34.74,39.51 v2(34.83,39.43) 34.86,39.43 35.26,39.03 PR729.1
  BOTTOM w0.203: v2(34.83,39.43) 34.83,39.87 35.25,40.29 PU700.16
CHARGER_SMBCLK: length 260.4
  TOP w0.102: v2(201.69,88.48) 201.66,88.51 201.02,88.51 UE2.B50 ; PT2.1 190.19,89.98 v2(189.6,89.4) 189.79,89.21 189.79,89.09 189.68,88.97 189.39,88.97 189.1,89.27 RPE6.3
  IN1 w0.084: v2(189.6,89.4) 190,89.8 190.98,89.8 191.46,89.32 198.58,89.32 198.64,89.27 200.42,89.27 200.69,89 200.69,88.86 200.69,88.79 201,88.48 v2(201.69,88.48)
  IN4 w0.084: v2(37.42,37.98) 37.61,37.79 37.61,37.54 37.86,37.3 39.92,37.3 40.76,36.46 40.76,34.2 43.83,31.14 49.06,31.14 56.18,24.01 97.07,24.01 98.12,22.97 110.87,22.97 111.33,23.43 119.45,23.43 120.09,24.06 126.39,24.06 130.75,19.71 144.78,19.71 145.52,18.97 156.33,18.97 156.8,19.43 160.46,19.43 160.92,18.97 164.67,18.97 166.25,20.54 188.41,20.54 191.16,23.3 195.13,23.3 197.4,25.57 198.27,25.57 200.71,28 200.71,40.65 202.39,42.34 202.39,53.16 202.92,53.68 202.92,54.48 201.84,55.55 201.84,57.24 202.36,57.76 202.36,60.31 201.82,60.85 201.82,61.88 201.2,62.49 201.2,74.43 199.76,75.88 199.76,76.45 199.39,76.82 199.39,79.9 198.61,80.67 198.61,82.86 200.66,84.91 200.66,88.26 200.89,88.48 v2(201.69,88.48)
  BOTTOM w0.102: v2(37.42,37.98) 37.42,38.59 37.32,38.69 PU700.12
CHARGER_SMBDAT: length 259.6
  TOP w0.102: v2(199.47,88.64) 199.58,88.75 UE2.A47 ; PT1.1 190.74,89.51 190.63,89.63 190.41,89.63 v2(190.19,89.4) 189.99,89.21 189.99,89 189.76,88.77 RPE6.2
  IN1 w0.084: v2(190.19,89.4) 190.4,89.61 190.9,89.61 191.38,89.14 198.5,89.14 198.56,89.08 200.35,89.08 200.5,88.93 200.5,88.78 200.28,88.56 199.54,88.56 v2(199.47,88.64)
  IN4 w0.084: v2(199.47,88.64) 200.24,88.64 200.47,88.41 200.47,88.34 200.48,88.33 200.48,84.98 198.43,82.93 198.43,80.6 199.2,79.82 199.2,76.74 199.57,76.37 199.57,75.8 201.02,74.35 201.02,62.42 201.63,61.8 201.63,60.77 202.18,60.23 202.18,57.84 201.66,57.32 201.66,55.48 202.73,54.4 202.73,53.76 202.21,53.23 202.21,42.42 200.52,40.73 200.52,28.08 198.19,25.76 197.32,25.76 195.05,23.48 191.08,23.48 188.33,20.73 166.17,20.73 164.59,19.15 161,19.15 160.54,19.62 156.72,19.62 156.25,19.15 145.6,19.15 144.86,19.89 130.83,19.89 126.47,24.25 120.01,24.25 119.37,23.61 111.25,23.61 110.79,23.15 98.2,23.15 97.15,24.2 56.26,24.2 49.13,31.32 43.9,31.32 40.94,34.28 40.94,36.53 39.99,37.48 37.93,37.48 37.82,37.59 37.82,37.8 v2(38,37.98)
  BOTTOM w0.102: PU700.11 37.72,38.26 v2(38,37.98)
CHG_BTS:
  vias: v1(37.79,44.53)
CHG_BTS_C: length 2.8
  BOTTOM w0.102: PC712.1 40.01,46.1 40.86,45.25 v1(40.86,44.33)
CHG_LGATE: length 14.4
  IN3 w1.016: 37.68,52.77 33.9,52.77 33.29,52.16 33.29,46.74 34.41,45.62 35.91,45.62 36.38,45.15
  BOTTOM w0.102: v1(35.42,44.49) 35.52,44.39 v4(35.99,44.39)
  vias: v2(38.09,54.16) v2(38.09,53.57) v4(36.5,44.01)
CHG_SNUB: length 1.7
  TOP w0.102: PR726.1 v1(30.51,56.05)
CHG_SW: length 1.6
  TOP w0.102: PR726.2 v1(33.17,55.96)
  vias: v2(32.3,54.32) v2(32.3,53.67) v2(40.17,45.22) v2(40.17,44.63) v4(38.06,50.64) v4(38.06,50)
CHG_UGATE:
  vias: v2(38.42,44.86) v2(38.43,44.28) v2(38.72,46.97) v2(39.17,47.4)
CLK_27M_IN: length 11.8
  BOTTOM w0.102: YV2.1 141.76,104.73 141.89,104.85 144.54,104.85 CV115.1 145.47,103.93 RV80.1 146.27,104.71 146.27,105.95 146.85,106.53 v1(147.96,106.53) 148.24,106.53 148.73,107.02
  BOTTOM w0.109: UV8.K1 148.73,107.02
CLK_27M_OUT: length 6.8
  BOTTOM w0.102: UV8.L1 149.22,107.89 148.28,106.94 146.78,106.94 v1(146.44,106.6) 146.04,106.19 146.04,105.01 145.87,104.84 RV80.2 RV81.2
CLK_BIASREF: length 7.7
  BOTTOM w0.089: UC1.C26 123.54,88.87 123.87,89.2 123.87,89.42 123.8,89.48 123.8,89.84 123.7,89.94 123.7,90.43 124.22,90.95
  BOTTOM w0.305: 124.22,90.95 124.25,90.98 v1(124.25,93.25) 124.25,94.61 RC69.1
CLK_DDC2_DOCK: length 46.1
  IN4 w0.084: v2(141.56,108.41) 141.37,108.59 141.37,109.14 139.53,110.98 139.53,111.64 141.15,113.27 141.15,115.74 141.73,116.32 141.73,122.81 147.49,128.56 150.54,128.56 152.79,130.8 152.79,133.43 v2(152.99,133.63)
  BOTTOM w0.102: UV8.L4 148.91,109.8 148.34,109.8 147.62,109.08 145.86,109.08 145.62,109.32 141.66,109.32 141.37,109.03 141.37,108.6 v2(141.56,108.41) ; JDOCK1.48 153.25,135.97 153.1,135.82 153.1,135.61 152.81,135.32 152.81,133.81 v2(152.99,133.63)
CLK_KBD: length 80.1
  TOP w0.102: UE2.A38 199.77,93.25 199.73,93.3 199.11,93.3 198.87,93.54 v2(198.87,93.81) 198.73,93.95 198.73,94.8 198.95,95.02 198.95,95.28 197.85,96.37 RPE2.8
  IN4 w0.084: v2(192.05,124.05) 190.24,125.87 182.99,125.87 179.96,128.9 174.63,128.9 169.5,134.02 167.66,134.02 167.58,134.11 162.24,134.11 161.66,134.69 v2(161.44,134.69)
  BOTTOM w0.102: JDOCK1.78 161.75,135.82 161.95,135.61 161.95,135.2 v2(161.44,134.69) ; v2(198.87,93.81) 198.87,93.83 199.27,94.22 199.9,94.22 200.14,94.47 200.14,98.12 199.72,98.55 199.72,102.83 199.53,103.02 199.53,108 198.96,108.58 198.96,116.88 198,117.85 193.05,117.85 192.6,118.3 v1(192.6,122.44) 192.6,123.83 192.37,124.05 v2(192.05,124.05)
CLK_MSE: length 76
  TOP w0.102: RPE2.6 198.27,95.37 v2(198.45,95.19) 198.45,93.77 198.47,93.75 198.47,93.62 199.02,93.07 199.62,93.07 199.94,92.75 UE2.A39 ; v2(161.23,131.63) v1(160.48,131.63)
  IN2 w0.122: v2(161.23,131.63) 161.29,131.63 162.57,130.35 164.4,130.35 164.63,130.58 171.13,130.58 173.28,128.43 173.28,116.14 183,106.42 189.06,106.42 190.09,105.39 190.09,96.73 190.8,96.02 v2(190.8,94.46)
  IN3 w0.122: v2(198.45,95.19) 197.59,95.19 196.17,96.61 194.88,96.61 193.58,95.31 191.65,95.31 v2(190.8,94.46)
  BOTTOM w0.102: v2(161.23,131.63) 160.25,130.65 JDOCK1.71
CLK_PCI_DOCK: length 98.8
  TOP w0.102: v2(165.72,56.43) 165.32,56.43 CC15.2 RC70.2
  IN2 w0.122: v2(160.23,60.35) 160.23,60.46 160.64,60.87 160.64,62.07 161.26,62.68 161.26,65.27 163.54,67.55 163.54,68.31 166.16,70.93 166.16,71.6 169.14,74.58 169.14,76.02 172.33,79.21 172.33,89.93 174.45,92.05 176.13,92.05 177.12,93.04 177.82,93.04 178.23,93.46 178.23,94.16 177.65,94.75 177.65,98.7 176.15,100.19 176.15,102.41 175.7,102.87 175.7,107.74 174.13,109.3 174.13,111.26 169.32,116.07 169.32,123.7 v2(169.17,123.85)
  BOTTOM w0.102: v2(165.72,56.43) 163.73,58.43 163.73,59.36 162.8,60.29 161.9,60.29 161.84,60.35 v2(160.23,60.35) ; JDOCK1.121 173.75,127.51 175.23,126.03 175.23,125.61 R273.1 175.95,124.9 175.95,123.68 175.45,123.18 169.84,123.18 v2(169.17,123.85)
CLK_PCI_LPDEBUG: length 38.7
  TOP w0.102: v2(166.89,56.43) 166.89,56.85 v1(166.7,57.04) 166.46,57.28 163.95,57.28 163.35,56.68 RC67.2 162.98,56.68 162.78,56.89 161.79,56.89 CC14.2
  BOTTOM w0.102: v2(166.89,56.43) 166.45,55.98 164.92,55.98 162.99,57.91 162.99,59.2 162.78,59.41 161.85,59.41 161.56,59.71 156.9,59.71 156.25,60.35 156.25,66.79 156.63,67.17 159.41,67.17 159.72,66.87 161.15,66.87 161.95,67.67 161.95,69.74 160.75,70.95 160.75,73.16 JLPDE1.10
CLK_PCI_MEC: length 80
  TOP w0.102: RC74.2 165.98,58.89 166.66,59.58 CC13.2 166.66,61.97 v1(166.65,61.98) 166.65,63.52 v2(166.07,64.1) ; v2(201.81,99.89) 202.38,99.32 RE66.1 203.01,99.19 203.01,98.16 203.37,97.81 UE2.A29
  IN4 w0.084: v2(166.07,64.1) 165.19,64.1 165.01,64.28 164.37,64.28 163.47,65.17 161.2,65.17 159.83,66.54 159.83,67.87 160.38,68.42 160.38,69.8 161.11,70.53 162.58,70.53 165.44,73.39 167.04,73.39 170.94,77.29 171.97,77.29 174.99,80.31 177.23,80.31 179.97,83.05 180.46,83.05 181.83,84.42 181.83,87.54 182.84,88.55 182.84,92.67 184.15,93.98 184.15,95.11 184.53,95.49 187.06,95.49 188.29,96.72 193.11,96.72 193.92,97.52 196.86,97.52 197.85,98.52 199.27,98.52 200.65,99.9 201.8,99.9 v2(201.81,99.89)
CLK_PCI_SIO: length 58.6
  TOP w0.102: v2(165.7,62.5) 166,62.2 v1(166,60.51) 166,59.78 165.65,59.43 164.57,59.43 RC72.2 CC12.2 ; UE1.A28 184.19,95.23 183.41,94.45 183.38,94.45 v2(183.01,94.08) RE27.1
  IN4 w0.084: v2(165.7,62.5) 165.03,63.17 162.36,63.17 159.24,66.29 159.24,68.12 159.79,68.67 159.79,70.05 160.87,71.12 162.33,71.12 165.19,73.98 166.8,73.98 170.7,77.88 171.73,77.88 174.75,80.9 176.98,80.9 178.18,82.1 178.18,85.13 181,87.95 181,91.66 183.01,93.67 v2(183.01,94.08)
CLK_PCIE_LAN: length 119.4
  TOP w0.102: UL1.44 204.88,114.64 204.82,114.58 203.89,114.58 203.72,114.4 203.54,114.4 v2(203.35,114.6)
  IN1 w0.084: v2(127.55,111.94) 127.82,111.67 127.97,111.67 128.53,111.12 128.53,110.6 128.92,110.21 129.43,110.21 130.46,109.19 131.61,109.19 131.92,109.49 136.44,109.49 137.36,110.41 139.13,110.41 139.36,110.65 139.36,111.72 139.75,112.11 143.66,112.11 147.83,107.94 155.96,107.94 156.53,108.51 158.57,108.51 159.21,109.15 162.46,109.15 165.06,111.75 180.62,111.75 182.25,113.38 182.25,113.55 183.04,114.34 203.09,114.34 v2(203.35,114.6)
  IN4 w0.084: v2(127.55,111.94) 127.31,111.71 127.07,111.71 126.85,111.48 121.1,111.48 120.65,111.03 118.16,111.03 117.22,110.1 117.22,96.88 113.55,93.22 113.55,91.68 v2(113.36,91.49)
  BOTTOM w0.089: UC1.B42 113.51,91.35 v2(113.36,91.49)
CLK_PCIE_LAN#: length 119.5
  TOP w0.102: UL1.45 204.87,114.24 204.8,114.31 204,114.31 203.83,114.14 203.47,114.14 v2(203.35,114.01)
  IN1 w0.084: v2(127.55,111.36) 127.69,111.5 127.9,111.5 128.35,111.04 128.35,110.53 128.85,110.04 129.36,110.04 130.38,109.01 131.69,109.01 131.99,109.32 136.51,109.32 137.43,110.24 139.2,110.24 139.53,110.57 139.53,111.64 139.82,111.93 143.59,111.93 147.76,107.77 156.03,107.77 156.6,108.34 158.64,108.34 159.28,108.97 162.53,108.97 165.13,111.58 180.69,111.58 182.43,113.31 182.43,113.48 183.11,114.17 203.19,114.17 v2(203.35,114.01)
  IN4 w0.084: v2(127.55,111.36) 127.37,111.53 127.14,111.53 126.92,111.31 121.17,111.31 120.72,110.86 118.23,110.86 117.39,110.02 117.39,96.81 113.73,93.15 113.73,91.72 v2(113.95,91.49)
  BOTTOM w0.089: UC1.C41 114.07,89.17 113.76,89.48 113.76,91.31 v2(113.95,91.49)
CLK_PCIE_MMI: length 146
  TOP w0.102: v2(23.59,22.98) 23.76,22.81 23.76,22.58 23.69,22.52 UR1.3
  IN1 w0.084: v2(112.7,90.75) 112.29,90.34 112.29,90.28 112.07,90.06 111.34,90.06 111.22,90.18 106.1,90.18 104.9,91.38 99.24,91.38 96.47,94.16 86.13,94.16 77.33,85.36 77.33,82.52 75.84,81.04 70.44,81.04 56.49,67.09 56.49,59.73 57.04,59.18 57.04,48.76 53.34,45.06 53.34,41.31 49.39,37.35 42.61,37.35 40.43,35.17 33.99,35.17 30.3,31.49 27.47,31.49 27.05,31.91 25.83,31.91 23.46,29.54 23.46,28.2 22.84,27.57 22.84,23.01 23.4,22.44 23.68,22.44 23.78,22.55 23.78,22.78 v2(23.59,22.98)
  BOTTOM w0.076: UC1.C42 113.24,89.08 113.07,89.26 112.89,89.26 112.68,89.46 112.65,89.57 112.65,89.7 112.66,89.7 ; 112.66,89.7 112.66,89.7 112.66,89.7 ; 112.66,89.7 112.68,89.76 112.68,89.76 112.69,89.77 112.71,89.85 112.71,90.07 112.65,90.19 112.65,90.7 v2(112.7,90.75)
CLK_PCIE_MMI#: length 146
  TOP w0.102: UR1.2 24.09,22.52 24.02,22.58 24.02,22.83 v2(24.17,22.98)
  IN1 w0.084: v2(112.12,90.75) 112.12,90.35 112,90.24 111.41,90.24 111.3,90.35 106.17,90.35 104.97,91.56 99.32,91.56 96.54,94.33 86.06,94.33 77.16,85.43 77.16,82.59 75.77,81.21 70.37,81.21 56.32,67.16 56.32,59.66 56.87,59.11 56.87,48.83 53.17,45.13 53.17,41.38 49.32,37.52 42.54,37.52 40.36,35.35 33.92,35.35 30.23,31.66 27.54,31.66 27.12,32.08 25.76,32.08 23.29,29.62 23.29,28.27 22.66,27.65 22.66,22.94 23.33,22.27 23.75,22.27 23.95,22.47 23.95,22.76 v2(24.17,22.98)
  BOTTOM w0.076: UC1.C43 112.56,89.35 112.53,89.39 112.49,89.54 112.49,89.73 112.5,89.76 112.52,89.81 112.52,89.82 112.55,89.88 112.55,89.99 112.49,90.16 112.49,90.38 v2(112.12,90.75)
CLK_PCIE_SATA: length 185.5
  IN1 w0.084: v2(116.63,91.36) 116.81,91.18 118.09,91.18 118.47,90.8 122.93,90.8 124.23,92.09 124.23,94.5 125.96,96.23 127.78,96.23 127.97,96.42 127.97,96.92 129.47,98.42 129.47,98.86 129.82,99.22 129.82,100.66 130.88,101.72 135.96,101.72 137.62,100.06 139.39,100.06 139.6,99.85 145.06,99.85 146.51,101.31 163.83,101.31 164.58,102.06 168.37,102.06 169.74,103.43 169.74,103.88 172.73,106.87 176.23,106.87 178.11,108.75 187.13,108.75 189.27,110.89 195.29,110.89 196.92,109.26 200.18,109.26 200.42,109.5 203.08,109.5 203.3,109.73 214.05,109.73 214.95,108.83 214.95,106.98 216.66,105.27 216.66,101.4 215.89,100.63 215.89,97.72 216.01,97.6 216.01,94.07 215.14,93.2 215.14,89.45 216,88.59 218.74,88.59 220.1,89.94 226.51,89.94 227.48,88.97 227.48,87.38 227.42,87.32 227.42,79.14 225.84,77.57 225.84,74.76 225.31,74.23 225.31,69.08 220.8,64.57 219.69,64.57 219.41,64.29 219.41,63.3 219.26,63.15 219,63.15 v2(218.77,62.92)
  BOTTOM w0.089: UC1.A37 116.21,90.64 116.21,90.94 v2(116.63,91.36)
  BOTTOM w0.102: JNGFF2.47 217.7,59.91 217.11,60.5 217.11,62.34 217.87,63.1 218.59,63.1 v2(218.77,62.92)
CLK_PCIE_SATA#: length 185.5
  IN1 w0.084: v2(116.63,90.77) 116.86,91 118.02,91 118.4,90.62 123,90.62 124.4,92.02 124.4,94.42 126.03,96.06 127.85,96.06 128.14,96.35 128.14,96.85 129.64,98.35 129.64,98.79 130,99.14 130,100.59 130.95,101.54 135.88,101.54 137.54,99.88 139.32,99.88 139.53,99.68 145.13,99.68 146.59,101.14 163.91,101.14 164.66,101.89 168.44,101.89 169.91,103.36 169.91,103.8 172.8,106.7 176.3,106.7 178.18,108.58 187.2,108.58 189.34,110.71 195.22,110.71 196.85,109.08 200.25,109.08 200.49,109.33 203.15,109.33 203.38,109.55 213.98,109.55 214.78,108.76 214.78,106.91 216.49,105.2 216.49,101.48 215.71,100.7 215.71,97.65 215.84,97.53 215.84,94.14 214.97,93.27 214.97,89.38 215.93,88.41 218.82,88.41 220.17,89.77 226.44,89.77 227.31,88.9 227.31,87.46 227.24,87.39 227.24,79.21 225.67,77.64 225.67,74.83 225.14,74.3 225.14,69.15 220.73,64.74 219.62,64.74 219.24,64.36 219.24,63.37 219.18,63.32 218.96,63.32 v2(218.77,63.5)
  BOTTOM w0.089: v2(116.63,90.77) 116.92,90.48 116.92,90.15 116.58,89.81 UC1.B37
  BOTTOM w0.102: JNGFF2.45 217.2,58.96 217.43,59.2 217.43,59.8 216.84,60.39 216.84,62.45 217.76,63.36 218.63,63.36 v2(218.77,63.5)
CLK_PCIE_WIGIG: length 115
  IN1 w0.084: v2(115.06,91.21) 115.06,91.21 115.27,91.42 115.45,91.42 115.7,91.67 115.7,92 116.07,92.38 117.85,92.38 118.76,93.29 118.76,95.4 122.91,99.55 122.91,102.84 123.26,103.18 123.26,104.19 123.7,104.64 125.18,104.64 126.25,103.57 129.11,103.57 133,107.46 136.48,107.46 136.63,107.31 142.04,107.31 142.63,107.89 143.94,107.89 146.86,104.97 162.38,104.97 162.95,105.55 164.14,105.55 164.85,106.26 168.3,106.26 v2(168.56,106)
  BOTTOM w0.089: v2(115.06,91.21) 115.12,91.15 115.12,90.02 115.45,89.68 UC1.B39
  BOTTOM w0.102: v2(168.56,106) 168.7,106.14 169.16,106.14 170.06,105.24 170.06,93.11 167.81,90.86 v4(167.81,88.28) 167.81,87.59 168.43,86.96 168.43,85.93 169.08,85.28 180.8,85.28 181.09,85.58 186.65,85.58 187.92,84.31 187.92,82.21 187.8,82.1 JNGFF1.63
CLK_PCIE_WIGIG#: length 115.4
  IN1 w0.084: v2(168.56,106.58) 168.4,106.43 164.78,106.43 164.07,105.72 162.88,105.72 162.31,105.15 146.93,105.15 144.01,108.07 142.56,108.07 141.97,107.48 136.7,107.48 136.55,107.63 132.93,107.63 129.04,103.74 126.32,103.74 125.25,104.81 123.63,104.81 123.08,104.27 123.08,103.25 122.74,102.91 122.74,99.62 118.59,95.47 118.59,93.36 117.78,92.55 116,92.55 115.53,92.07 115.53,91.74 115.38,91.6 115.26,91.6 v2(115.06,91.79)
  BOTTOM w0.089: UC1.A39 115.37,90.35 115.37,90.94 115.45,91.02 115.45,91.4 v2(115.06,91.79)
  BOTTOM w0.102: v2(168.56,106.58) 168.73,106.4 169.27,106.4 170.32,105.35 170.32,93 168.07,90.75 168.07,87.7 168.7,87.07 168.7,86.04 169.19,85.55 180.69,85.55 180.98,85.84 186.76,85.84 188.18,84.42 188.18,82.21 188.3,82.1 JNGFF1.65
CLK_PCIE_WLAN: length 116.1
  IN1 w0.084: v2(115.08,92.98) 115.28,92.77 115.39,92.77 115.78,93.17 117.66,93.17 117.88,93.38 117.88,96.58 121.24,99.95 121.24,103.64 124.35,106.75 124.35,107.13 126.67,109.45 129.29,109.45 130.46,108.28 136.24,108.28 137.6,109.64 143.66,109.64 147.51,105.78 158.56,105.78 159.29,106.51 163.96,106.51 165.05,107.6 168.35,107.6 v2(168.56,107.8)
  BOTTOM w0.102: v2(168.56,107.8) 167.63,107.8 166.83,107 166.83,105.3 168.79,103.34 168.79,94.22 166.93,92.37 166.93,87.22 167.46,86.69 167.46,85.11 168.17,84.41 176,84.41 176.43,83.98 181.38,83.98 181.8,83.56 JNGFF1.39 ; v2(115.08,92.98) 115.26,92.8 115.49,92.8 115.76,92.53 115.76,91.71 115.99,91.49 115.99,90.26 116.25,90.01 116.25,89.5 116.58,89.17 UC1.C37
CLK_PCIE_WLAN#: length 115.5
  IN1 w0.084: v2(168.56,107.22) 168.35,107.42 165.12,107.42 164.04,106.34 159.37,106.34 158.63,105.61 147.44,105.61 143.59,109.46 137.67,109.46 136.31,108.11 130.39,108.11 129.22,109.27 126.74,109.27 124.53,107.06 124.53,106.68 121.42,103.57 121.42,99.88 118.05,96.51 118.05,93.31 117.73,92.99 115.85,92.99 115.46,92.6 115.28,92.6 v2(115.08,92.4)
  BOTTOM w0.102: UC1.B38 115.87,89.29 115.76,89.4 115.76,89.6 115.81,89.65 115.94,89.65 116.02,89.73 116.02,89.91 115.76,90.17 115.76,91.39 115.53,91.62 115.53,92.43 115.39,92.57 115.26,92.57 v2(115.08,92.4) ; JNGFF1.41 182.3,82.1 182.24,82.16 182.14,82.16 182.07,82.22 182.07,83.67 181.49,84.24 176.55,84.24 176.11,84.67 168.28,84.67 167.73,85.22 167.73,86.8 167.2,87.33 167.2,92.26 169.05,94.11 169.05,103.45 167.1,105.41 167.1,106.89 167.74,107.54 168.24,107.54 v2(168.56,107.22)
CLK_TP_SIO: length 58.9
  TOP w0.102: UE2.A37 199.47,93.75 v2(199.45,93.77) ; RZ19.2 CZ31.1 204.05,57.27 204.05,56.02 203.85,55.82 JKBTP1.14 203.85,53.5 202.71,52.35 197.39,52.35 196.79,52.96 196.79,55.52 197.2,55.92 v1(197.2,56.89) 197.2,57.81 197.64,58.25 197.64,61.04 198.22,61.62 198.22,62.94 v2(197.78,63.39)
  BOTTOM w0.102: v2(197.78,63.39) 197.78,64.02 198.29,64.53 198.34,64.53 198.67,64.86 198.67,64.86 198.91,65.1 198.95,65.1 200.33,66.47 200.33,66.48 201.25,67.4 201.25,73.89 201.7,74.35 201.7,76.41 202.99,77.7 202.99,79.31 201.79,80.51 201.79,82.73 201.74,82.78 201.74,83.91 201.89,84.06 201.89,87.37 201.05,88.21 201.05,91.36 200.12,92.29 200.12,93.11 v2(199.45,93.77)
CLKRUN#: length 97.9
  TOP w0.089: 136.64,80.31 v2(136.36,80.59)
  TOP w0.102: UE1.B20 179.44,97.31 179.63,97.5 179.63,97.99 v2(180.03,98.39) ; RPC17.8 151.21,79 150.8,78.59 140.35,78.59 138.88,80.06 136.89,80.06 136.64,80.31 ; UE2.A32 201.87,97.75 201.49,98.12 201.49,98.31 v2(201.16,98.64) 201.28,98.77 v1(202.06,98.77)
  IN1 w0.084: v2(201.16,98.64) 200.73,99.07 190.34,99.07 190.06,99.35 184.51,99.35 184.19,99.03 180.66,99.03 v2(180.03,98.39)
  IN3 w0.122: v2(180.03,98.39) 180.03,98.85 179.79,99.09 178.15,99.09 176.98,100.26 175.57,100.26 174.93,99.61 170.4,99.61 v2(169.61,98.82)
  IN4 w0.084: v2(169.61,98.82) 170.06,98.38 170.06,97.98 169,96.93 166.71,96.93 164.61,94.84 156.74,86.97 155.49,86.97 152.17,83.65 152.17,82.27 151.66,81.76 149.72,81.76 148.6,80.64 139.95,80.64 139.63,80.96 138.14,80.96 137.77,80.59 v2(136.36,80.59)
  BOTTOM w0.076: UC1.V5 136.18,80.41 v2(136.36,80.59)
CMPIN: length 6
  BOTTOM w0.102: PR737.2 39.87,36.21 v1(40.25,35.83)
  BOTTOM w0.203: PU700.13 36.92,37.8 37.5,37.22 PR738.1
  BOTTOM w0.254: PR738.1 37.53,37.22 PC737.1 38.42,36.21 PR745.1 39.31,36.2 PR737.2
CMPOUT: length 5.5
  BOTTOM w0.102: v1(35.71,35.42) 35.79,35.49 PR740.1
  BOTTOM w0.203: PR738.2 36.52,37.33 PU700.14
  BOTTOM w0.254: PC741.2 35.93,36.21 PR740.1 35.79,37.22 PR743.1 35.79,37.22 PR738.2
CONTACTLESS_DET#: length 147.5
  TOP w0.089: v2(135.78,82.47) 136.18,82.86 136.65,82.86 137.27,83.49 137.95,83.49 138.39,83.92 138.39,84.46 140.31,86.38 140.31,86.97 144.38,91.04 144.38,91.92
  TOP w0.102: v2(209.53,53.66) 209.7,53.66 210.38,52.99 v1(210.38,51.03) 210.38,44.53 210.39,44.52 v2(210.39,43.9) ; RPC4.5 144.38,91.92 ; v2(221.16,43.27) 221.31,43.12 223.84,43.12 224.3,43.58 JUSH1.4
  IN1 w0.084: v2(135.78,82.47) 135.78,82.23 135.64,82.08 134.08,82.08 133.72,81.73 133.72,80.48 134.19,80.01 136.93,80.01 137.11,80.19 138.15,80.19 138.37,79.97 139.63,79.97 140.67,81 149.35,81 149.44,80.92 151.16,80.92 151.38,81.13 154.26,81.13 157.56,84.43 161.37,84.43 161.68,84.74 165.53,84.74 165.91,84.36 166.54,84.36 167.68,83.22 168.85,83.22 170.24,81.83 171.25,81.83 174.44,78.64 176.55,78.64 179.38,75.81 187.96,75.81 190.47,73.29 194.67,73.29 195.14,72.82 196.04,72.82 199.88,68.98 199.88,62.44 199.35,61.92 199.35,60.21 200.21,59.35 202.08,59.35 202.96,58.47 205.52,58.47 208.92,55.08 208.92,53.97 209.22,53.66 v2(209.53,53.66) ; v2(221.16,43.27) 221.21,43.27 221.42,43.48 221.42,44.06 221.16,44.32 220.48,44.32 220.37,44.21 217.26,44.21 216.49,43.45 210.83,43.45 v2(210.39,43.9)
  BOTTOM w0.076: UC1.U6 135.53,81.6 135.82,81.89 135.82,82.43 v2(135.78,82.47)
CORE_BOOT: length 1
  BOTTOM w0.102: PC504.2 v1(94.25,113.4)
CORE_SNUB: length 1.6
  TOP w0.102: PR522.2 v1(103.88,108.26)
CORE_SW: length 1.5
  TOP w0.102: PR522.1 v1(103.85,110.93)
  vias: v2(101.67,111.89) v2(102.28,111.89)
CPPE#: length 31.2
  TOP w0.102: RC160.2 160.14,81.82 161.31,82.99 v1(161.31,84.69) 160.87,85.12 160.87,86.26 v2(160.09,87.05)
  IN1 w0.084: v2(160.09,87.05) 159.45,86.42 157.36,86.42 153.71,82.77 151.3,82.77 151.09,82.55 149.38,82.55 147.49,84.45 141.76,84.45 v2(141.26,84.95)
  BOTTOM w0.076: v2(141.26,84.95) 140.89,85.31 138.84,85.31 UC1.J1
CPU_DPB_AUX: length 58.1
  TOP w0.102: v2(135.59,124.52) 135.36,124.76 135.36,124.95 134.9,125.4 130.18,125.4 129.58,126 v4(126.66,126) 125.63,126 123.95,124.32 123.17,124.32 122.72,123.88 122.72,123.54 CV79.1
  IN4 w0.091: v2(135.59,124.52) 135.59,123.93 136.55,122.97 136.55,121.63 138.31,119.88 138.31,116.03 136.29,114.02 136.29,110.84 137.21,109.93 137.21,107.45 137.92,106.73 137.92,101.17 137.21,100.46 137.21,99.56 137.78,98.99 137.78,97.7 137.21,97.13 137.21,96.62 138.66,95.16 138.66,94.12 138.85,93.93 139.15,93.93 v2(139.32,94.1)
  BOTTOM w0.076: UC1.B5 135.77,89.71 135.77,90.63 136.33,91.19 136.38,91.19 136.4,91.2 136.4,91.2
  BOTTOM w0.102: RPC20.2 139.25,94.91 139.54,94.63 139.54,94.32 v2(139.32,94.1) 139.14,93.93 138.84,93.93 138.37,93.45 138.37,92.92 136.66,91.2 136.4,91.2
CPU_DPB_AUX#: length 58.7
  TOP w0.102: CV80.1 122.94,123.61 122.94,123.79 123.26,124.11 124.04,124.11 125.72,125.78 126.38,125.78 126.39,125.77 126.93,125.77 126.94,125.78 129.49,125.78 130.09,125.19 134.81,125.19 135.14,124.86 135.14,124.66 v2(135.01,124.52)
  IN4 w0.091: v2(139.32,93.52) 139.08,93.76 138.78,93.76 138.49,94.05 138.49,95.09 137.04,96.55 137.04,97.2 137.61,97.77 137.61,98.92 137.04,99.49 137.04,100.53 137.75,101.24 137.75,106.66 137.04,107.38 137.04,109.86 136.12,110.77 136.12,114.09 138.13,116.1 138.13,119.81 136.38,121.56 136.38,122.9 135.42,123.86 135.42,124.11 v2(135.01,124.52)
  BOTTOM w0.076: UC1.C5 135.97,89.14 135.97,89.74 135.93,89.78 135.93,90.52 136.39,90.99 136.4,90.99
  BOTTOM w0.089: 139.48,93.68 v2(139.32,93.52)
  BOTTOM w0.102: 139.48,93.68 139.75,93.95 RPC20.1 ; v2(139.32,93.52) 139.13,93.71 138.93,93.71 138.59,93.37 138.59,92.83 136.75,90.99 136.4,90.99
CPU_DPB_AUX#_C: length 2.1
  TOP w0.102: CV80.2 122.93,121.94 122.93,121.72 122.73,121.53 UV7.51
CPU_DPB_AUX_C: length 2.1
  TOP w0.102: CV79.2 122.7,122.05 122.7,121.82 122.51,121.63 122.51,121.19 122.33,121.01 UV7.52
CPU_DPB_CTRLCLK: length 56.6
  TOP w0.089: RPC2.1 138.25,94.77 138.4,94.63 138.4,94.52 138.29,94.42 138.08,94.42 137.92,94.57 137.92,94.85 137.51,95.27 136.06,95.27 v2(135.87,95.45)
  TOP w0.102: UV7.50 123.13,121.18 v2(123.28,121.33)
  IN1 w0.091: v2(135.71,122.54) 135.3,122.13 133.69,122.13 132.85,121.29 131.69,121.29 130.49,120.09 124.17,120.09 123.49,120.77 123.49,121.12 v2(123.28,121.33)
  IN4 w0.091: v2(135.87,95.45) 135.65,95.24 134.99,95.24 134.79,95.44 134.79,97.52 135.32,98.04 135.32,99.18 135.8,99.66 135.8,100.87 136.53,101.6 136.53,106.05 135.74,106.83 135.74,108.83 135,109.57 135,114.8 135.46,115.25 135.46,116.57 134.93,117.1 134.93,120.37 135.49,120.94 135.49,122.32 v2(135.71,122.54)
  BOTTOM w0.076: UC1.B9 133.22,89.62 133.66,90.06 133.66,90.73 134.02,91.1 134.03,91.1 134.2,91.27 134.75,91.82 134.75,93.94 135.26,94.44 135.26,95 135.48,95.23 135.64,95.23 v2(135.87,95.45)
CPU_DPB_CTRLDAT: length 56.5
  TOP w0.089: v2(135.87,94.84) 136.09,95.06 v4(136.74,95.06) 137.42,95.06 137.72,94.76 137.72,94.48 137.99,94.21 138.38,94.21 138.61,94.44 138.61,94.63 138.75,94.77 RPC2.2
  TOP w0.102: UV7.49 123.53,121 v2(123.87,121.33)
  IN1 w0.091: v2(135.13,122.54) 135.13,122.46 134.98,122.3 133.62,122.3 132.78,121.46 131.62,121.46 130.42,120.26 124.24,120.26 123.66,120.84 123.66,121.12 v2(123.87,121.33)
  IN4 w0.091: v2(135.13,122.54) 135.32,122.35 135.32,121.01 134.75,120.45 134.75,117.03 135.29,116.49 135.29,115.32 134.83,114.87 134.83,109.5 135.57,108.76 135.57,106.76 136.35,105.97 136.35,101.67 135.63,100.95 135.63,99.73 135.15,99.25 135.15,98.12 134.62,97.59 134.62,95.37 134.92,95.06 135.65,95.06 v2(135.87,94.84)
  BOTTOM w0.076: UC1.C9 133.47,89.6 133.82,89.95 133.82,90.63 134.1,90.91 134.1,90.91 134.33,91.13 134.94,91.75 134.94,93.86 135.45,94.36 135.45,94.92 135.56,95.04 135.67,95.04 v2(135.87,94.84)
CPU_DPC_AUX: length 137.3
  TOP w0.102: v2(232.73,118.78) 232.88,118.63 233.37,118.63 CV512.2
  IN1 w0.091: v2(136.32,117.81) 135.98,117.46 135.98,117.38 136.08,117.28 139.73,117.28 140.04,117.59 142.06,117.59 142.37,117.28 146.96,117.28 147.59,117.91 151.08,117.91 152.54,119.37 181.45,119.37 182.78,118.04 186.12,118.04 186.7,118.61 192.34,118.61 192.76,119.03 216.77,119.03 218.41,120.67 221.2,120.67 221.35,120.82 222.46,120.82 222.58,120.7 226.22,120.7 228.37,118.55 232.5,118.55 v2(232.73,118.78)
  IN4 w0.091: v2(136.32,117.81) 135.91,117.4 135.91,117.08 136.13,116.87 136.13,114.77 135.65,114.29 135.65,109.89 136.49,109.05 136.49,107 137.23,106.26 137.23,101.39 136.45,100.61 136.45,99.41 136.97,98.88 136.97,97.72 136.45,97.19 136.45,96.28 136.75,95.97 136.75,94.23 136.91,94.08 137.11,94.08 137.34,94.31 v2(137.34,94.42)
  BOTTOM w0.076: UC1.A6 135.07,90.01 134.97,89.91 134.83,89.91 134.74,90.01 134.74,90.49 134.92,90.67 135.01,90.67 136.42,92.08 136.42,94 136.74,94.33 137.25,94.33 v2(137.34,94.42)
  BOTTOM w0.089: v2(137.34,94.42) 137.55,94.21 138.08,94.21 138.4,94.53 138.4,94.63 138.25,94.78 RPC20.4
CPU_DPC_AUX#: length 137.6
  TOP w0.102: v2(232.73,118.2) 232.95,118.42 233.3,118.42 CV513.2
  IN1 w0.091: v2(135.74,117.81) 135.8,117.75 135.8,117.39 135.8,117.39 135.8,117.31 136,117.11 139.8,117.11 140.11,117.42 141.99,117.42 142.3,117.11 147.03,117.11 147.66,117.74 151.15,117.74 152.61,119.2 181.38,119.2 182.71,117.86 186.19,117.86 186.77,118.44 192.41,118.44 192.83,118.86 216.84,118.86 218.48,120.5 221.27,120.5 221.42,120.64 222.39,120.64 222.5,120.53 226.15,120.53 228.29,118.38 232.55,118.38 v2(232.73,118.2)
  IN4 w0.091: v2(135.74,117.81) 135.74,117.01 135.96,116.8 135.96,114.84 135.48,114.36 135.48,109.81 136.32,108.97 136.32,106.92 137.05,106.19 137.05,101.46 136.27,100.68 136.27,99.34 136.8,98.81 136.8,97.79 136.27,97.26 136.27,96.21 136.58,95.9 136.58,94.16 136.83,93.91 137.2,93.91 v2(137.34,93.76)
  BOTTOM w0.076: UC1.B6 134.79,89.72 135.04,89.72 135.33,90 135.4,90.07 135.4,90.79 136.61,92 136.61,93.92 136.82,94.14 136.97,94.14 v2(137.34,93.76)
  BOTTOM w0.089: v2(137.34,93.76) 137.58,94.01 138.17,94.01 138.61,94.44 138.61,94.63 138.75,94.78 RPC20.3
CPU_DPC_CTRLCLK: length 164.7
  TOP w0.102: UV502.12 237.84,124.04 v2(237.91,123.97) ; RPC2.4 139.75,94.99 139.61,94.85 139.61,94.71 139.99,94.34 v4(139.99,93.7) 139.99,93.19 139.39,92.59 137.98,92.59 133.77,88.38 133.37,88.38 v2(132.96,87.97)
  IN1 w0.091: v2(130.64,123.03) 130.44,122.82 130.44,122.66 130.58,122.53 130.8,122.53 131.75,123.47 133.73,123.47 133.9,123.31 136.45,123.31 136.67,123.1 138.73,123.1 138.98,123.34 153.98,123.34 154.59,122.74 164.42,122.74 165.06,123.38 206.78,123.38 207.02,123.62 211.78,123.62 213.75,125.59 218.61,125.59 219.65,124.56 224.15,124.56 224.57,124.14 229.42,124.14 230.18,123.38 238.2,123.38 238.36,123.54 238.36,123.78 238.23,123.91 237.97,123.91 v2(237.91,123.97)
  IN4 w0.091: v2(130.64,123.03) 130.44,122.82 130.44,122.67 130.81,122.3 130.81,114.59 132,113.4 132,108.51 132.22,108.29 132.22,104.68 130.57,103.03 130.57,96 130.9,95.67 130.9,92.01 133.63,89.28 133.63,88.55 133.35,88.28 133.1,88.28 132.96,88.14 v2(132.96,87.97)
  BOTTOM w0.089: v2(132.96,87.97) 133.08,87.97 133.59,88.48 UC1.D9
CPU_DPC_CTRLDAT: length 166
  TOP w0.102: UV502.9 239.79,124.26 v2(239.88,124.17) ; RPC2.3 139.25,94.99 139.4,94.85 139.4,94.62 139.77,94.25 139.77,93.98 139.74,93.95 139.74,93.46 139.77,93.43 139.77,93.28 139.3,92.8 137.89,92.8 133.68,88.6 133.35,88.6 v2(132.96,88.99)
  IN1 w0.091: v2(239.88,124.17) 239.88,123.47 239.49,123.08 238.48,123.08 238.35,123.21 230.11,123.21 229.35,123.96 224.5,123.96 224.08,124.38 219.58,124.38 218.54,125.42 213.82,125.42 211.85,123.45 207.09,123.45 206.85,123.21 165.14,123.21 164.49,122.57 154.52,122.57 153.91,123.17 139.05,123.17 138.8,122.92 136.59,122.92 136.38,123.13 133.82,123.13 133.66,123.3 131.82,123.3 130.88,122.36 130.5,122.36 130.27,122.59 130.27,122.82 v2(130.06,123.03)
  IN4 w0.091: v2(130.06,123.03) 130.27,122.82 130.27,122.6 130.63,122.23 130.63,114.52 131.83,113.33 131.83,108.44 132.05,108.22 132.05,104.76 130.4,103.1 130.4,95.93 130.72,95.6 130.72,91.94 133.46,89.21 133.46,88.62 133.28,88.45 133.14,88.45 132.96,88.62 v2(132.96,88.99)
  BOTTOM w0.089: UC1.D11 133.3,88.48 133.36,88.54 133.36,88.75 133.13,88.99 v2(132.96,88.99)
CPU_PWR_DEBUG#: length 84.9
  TOP w0.102: v2(61.98,41.66) 62.01,41.63 62.14,41.63 v1(62.72,41.06) 62.87,40.91 64.06,40.91 RC198.1 65.34,41.41 67.25,43.31 JXDP1.45 ; v2(64.02,56.96) 64.52,56.96 RC197.2
  IN1 w0.084: v2(61.98,41.66) 61.71,41.93 61.71,42.77 63.06,44.12 63.06,49.97 64.71,51.62 64.71,56.28 v2(64.02,56.96) 66.15,59.09 66.15,65.4 v2(66.99,66.23)
  IN2 w0.122: v2(66.99,66.23) 67.25,66.49 67.25,69.27 73.47,75.49 76.77,75.49 84.79,83.51 89.58,83.51 91.63,85.56 95.63,85.56 v2(96.53,86.46)
  BOTTOM w0.076: 97.45,86.89 98.55,86.89 98.72,86.72 99.23,86.72 99.58,86.37 100.48,86.37 100.65,86.54 101.32,86.54 101.44,86.41 102.5,86.41 UC1.H59
  BOTTOM w0.109: 97.45,86.89 96.96,86.89 v2(96.53,86.46)
CPU_XDP_PRDY#: length 77.4
  TOP w0.102: v2(62.28,44.89) 61.79,44.89 61.55,44.65 v1(61.19,44.65) 57.93,44.65 57.25,45.33 JXDP1.5
  IN1 w0.084: v2(96.25,84.95) 95.55,84.26 92.82,84.26 91.34,82.78 85.54,82.78 81.94,79.18 80.51,79.18 79.86,78.52 77.49,78.52 74.87,75.9 71.14,75.9 66.22,70.99 66.22,66.78 65.22,65.78 65.22,59.67 60.64,55.08 60.64,52.9 60.22,52.48 60.22,50.81 61.01,50.03 61.01,47.49 61.79,46.71 61.79,45.38 v2(62.28,44.89)
  BOTTOM w0.076: UC1.J62 100.6,85.33 100.31,85.04 99.81,85.04 99.81,85.04 99.47,85.04 99.27,85.24 99.27,85.24 98.98,85.53 98.98,85.53 98.92,85.59 97.71,85.59
  BOTTOM w0.109: v2(96.25,84.95) 96.88,85.59 97.71,85.59
CPU_XDP_PREQ#: length 70.8
  TOP w0.102: JXDP1.3 56.75,48.04 57.05,48.33 v2(57.82,48.33)
  IN2 w0.122: v2(57.82,48.33) 57.98,48.49 57.98,53.98 59.34,55.35 59.34,57.72 60.88,59.26 60.88,60.38 62.88,62.37 71.5,62.37 77.67,68.54 77.67,73.09 81.28,76.71 81.28,77.91 82.94,79.56 84.14,79.56 87.83,83.26 89.68,83.26 91.73,85.31 94.62,85.31 v2(95.04,84.89)
  BOTTOM w0.076: UC1.K62 100.39,84.14 100.39,84.14 100.38,84.13 99.89,84.13 99.63,84.38 96.83,84.38 96.69,84.52 v1(96.55,84.52) 95.41,84.52 v2(95.04,84.89)
  BOTTOM w0.102: v2(95.04,84.89) 95.04,85.38 RC126.2
CPU_XDP_TCLK: length 75.1
  TOP w0.102: v2(69.01,69.75) 68.56,69.75 68.34,69.54 RC119.1 ; RC119.1 RC112.1 ; RC119.1 68.82,68.63 68.83,68.63 70.16,67.3 v3(70.16,62.35) 70.16,58.73 71.31,57.57 71.31,50.09 70.25,49.03 JXDP1.57
  IN1 w0.084: v2(69.01,69.75) 68.98,69.79 68.98,70.36 72.3,73.68 75.9,73.68 77.27,75.05 78.74,75.05 v2(79,75.3) ; v2(101.8,88.04) 100.71,89.13 92.98,89.13 89.03,85.18 82.6,85.18 v2(81.79,84.37)
  BOTTOM w0.076: v2(101.8,88.04) 102.14,87.7 UC1.E60
  BOTTOM w0.102: v2(79,75.3) 79.31,74.98 79.91,74.98 81.63,76.7 81.63,84.2 v2(81.79,84.37) 81.83,84.41 83.1,84.41 RC128.2
CPU_XDP_TDI: length 46.6
  TOP w0.102: v3(65.73,71.17) 65.34,70.79 65.34,70.16 65.47,70.03 v2(65.47,69.61) UC7.6
  IN2 w0.122: v2(65.47,69.61) 66.36,70.49 66.36,71.44 73.7,78.78 76.19,78.78 79.11,81.7 80.15,81.7 82.98,84.53 89.65,84.53 92.19,87.07 94.12,87.07 94.55,87.51 v2(94.57,87.51)
  BOTTOM w0.102: UC1.F63 99.87,86.83 99.48,87.22 98.79,87.22 98.64,87.37 94.71,87.37 v2(94.57,87.51) 93.88,88.19 RC125.2
CPU_XDP_TDO: length 49.1
  TOP w0.102: v3(95,86.99) 95.26,86.73 v2(95.26,86.46) ; v2(65.66,67.92) 65.48,68.11 UC7.3
  IN2 w0.122: v2(65.66,67.92) 66.09,67.92 66.74,68.57 66.74,71.47 73.8,78.53 76.29,78.53 79.21,81.45 80.25,81.45 83.09,84.29 89.75,84.29 92.29,86.83 94.89,86.83 v2(95.26,86.46)
  BOTTOM w0.076: 97.58,87.13 98.62,87.13 98.87,86.89 99.3,86.89 99.65,86.54 100.42,86.54 100.71,86.83 UC1.F62
  BOTTOM w0.102: 97.58,87.13 95.93,87.13 v2(95.26,86.46) 94.82,86.9 94.25,86.9 RC127.2
CPU_XDP_TMS: length 53
  TOP w0.102: UC7.8 63.1,70.88 v2(62.97,71.01) 62.97,71.15 v3(63.38,71.56)
  IN1 w0.084: v2(62.97,71.01) 62.97,71.54 68.89,77.46 74.46,77.46 77.69,80.69 81.48,80.69 85.3,84.5 89.31,84.5 93.24,88.44 97.24,88.44 v2(97.72,87.96)
  BOTTOM w0.076: UC1.E61 101.22,87.89 100.39,87.89 100.33,87.96 99.57,87.96 99.2,88.33 98.08,88.33 v2(97.72,87.96)
  BOTTOM w0.102: v2(97.72,87.96) 97.36,87.6 95.32,87.6 RC124.2
CPU_XDP_TRST#: length 55.1
  TOP w0.102: v3(81.66,82.27) v2(82.31,82.27) RC129.2 ; UC7.11 61.5,68.61 v2(60.89,69.22) 60.33,68.65 RC109.1
  IN1 w0.084: v2(102.44,88.03) 102.09,87.67 100.44,87.67 99.46,88.65 93.16,88.65 89.22,84.71 84.75,84.71 v2(82.31,82.27) 80.94,80.9 77.6,80.9 74.37,77.67 68.8,77.67 61.67,70.54 61.67,69.45 61.45,69.22 v2(60.89,69.22)
  BOTTOM w0.076: v2(102.44,88.03) 102.79,87.68 UC1.E59
CPUSB#: length 17.1
  TOP w0.089: v2(137.82,84.17) 137.82,84.4 139.95,86.53 139.95,87.39 v1(140.45,87.88) 143.64,91.08 143.64,91.92
  TOP w0.102: RPC15.3 144.27,97.6 143.64,96.97 143.64,91.92
  BOTTOM w0.076: v2(137.82,84.17) 137.52,84.47 UC1.K3
CS_1.35V: length 3.1
  BOTTOM w0.102: PR201.2 v1(78.32,20.54)
  BOTTOM w0.254: PU200.13 77.35,20.4 PR201.2
CSN1: length 37.5
  TOP w0.254: v2(92.23,96.17) 93.21,97.15 94.28,97.15 95.33,98.2 96.93,98.2 97.96,99.23 97.96,104.88 98.67,105.59 v1(108.75,105.59) 109.11,105.59 110.4,106.89 110.4,107.65 109.65,108.4 PR515.2 PR514.2 108.08,108.46 v2(108.08,109.01)
  BOTTOM w0.203: PC502.1 89.78,96 89.77,96 89.66,96.11 89.66,96.75 89.84,96.92 89.84,97.33 89.75,97.42 PU500.18
  BOTTOM w0.254: v2(92.23,96.17) 91.78,96.17 91.16,95.55 PC513.1 PC502.1 ; PL500.2 108.31,108.78 v2(108.08,109.01)
CSP1: length 28.8
  TOP w0.254: v2(92.01,96.76) v1(92.45,97.2) 92.78,97.53 94.12,97.53 95.18,98.58 96.77,98.58 97.58,99.39 97.58,105.07 98.55,106.04 107.56,106.04 PH501.1 108.13,107.47 PR514.1 PR512.1
  BOTTOM w0.203: PC502.2 90.24,97.44 90.15,97.53 PU500.17
  BOTTOM w0.254: v2(92.01,96.76) 91.77,96.76 91.47,96.46 PC513.2 PC502.2
CSS_GC: length 38.3
  TOP w0.102: PR702.1 v1(50.51,42.14)
  TOP w0.254: v2(51.16,42.82) 51.5,42.47 PR702.1 ; PU800.10 24.38,33.54 24.51,33.4 24.51,32.88 24.25,32.62 v2(23.51,32.62)
  IN3 w0.254: v2(51.16,42.82) 51.04,42.7 51.04,38.96 49.31,37.23 43.96,37.23 43.07,36.34 35.88,36.34 34.76,35.22 29.76,35.22 27.16,32.62 v2(23.51,32.62)
CSSN_1: length 27.2
  TOP w0.254: PQ701.3 51.23,37.76 v2(50.55,37.07) ; PR705.1 43.5,42.84 PR703.1 44.87,42.31 45.93,42.31 v1(46.04,42.42) 46.15,42.54 v2(47.12,42.54) ; PQ703.2 58.16,42.35 57.9,42.09 56.42,42.09 PR707.1 55.15,43.36 v2(54.87,43.36)
  IN1 w0.254: v2(50.55,37.07) 51.69,37.07 54.55,39.93 54.55,42.28 54.36,42.47 54.36,43.04 54.68,43.36 v2(54.87,43.36)
  IN2 w0.254: v2(47.12,42.54) 47.12,42.6 48.07,43.55 54.68,43.55 v2(54.87,43.36)
CSSP_1: length 29.7
  TOP w0.254: PQ703.5 58.16,41.46 57.9,41.71 56.49,41.71 PR706.1 v1(55.04,42.07) 54.87,42.24 v2(54.87,42.73) ; PQ702.3 51.31,33.77 v2(50.61,34.47) ; PR704.1 44.33,41.93 PR703.2 47.4,41.93 47.75,42.28 v2(47.75,42.54)
  IN1 w0.254: v2(50.61,34.47) 50.61,35.46 54.93,39.77 54.93,42.66 v2(54.87,42.73)
  IN2 w0.254: v2(54.87,42.73) 54.61,42.73 54.17,43.17 52.55,43.17 51.71,42.33 50.96,42.33 50.12,43.17 48.23,43.17 47.75,42.7 v2(47.75,42.54)
D_CLKRUN#: length 44.3
  TOP w0.102: v2(170.94,127.5) 170.94,128.04 v1(170.72,128.27) ; UE1.A19 179.69,95.63 179.8,95.52 179.8,94.91 v2(179.35,94.47) 179.53,94.28 RPE8.4
  IN2 w0.122: v2(179.35,94.47) 178.91,94.91 178.91,96.98 178.67,97.22 178.67,98.93 177.03,100.56 177.03,103.21 176.57,103.67 176.57,110.06 170.2,116.43 170.2,126.75 v2(170.94,127.5)
  BOTTOM w0.102: JDOCK1.111 171.25,127.8 v2(170.94,127.5)
D_DLDRQ1#: length 46.4
  TOP w0.102: v2(181.72,98.39) 181.3,97.96 181.3,97.48 181.44,97.34 UE1.B24 ; v2(172.21,127.32) v1(172.21,128.21) ; v2(180.83,93.49) 180.53,93.2 RPE8.2
  IN1 w0.084: v2(180.83,93.49) 180.37,93.95 180.37,94.63 181.3,95.56 181.3,97.96 v2(181.72,98.39)
  IN2 w0.122: v2(181.72,98.39) 181.72,99.26 180.28,100.71 178.51,100.71 177.78,101.44 177.78,103.52 177.32,103.98 177.32,110.69 171.82,116.19 171.82,119.63 171.55,119.91 171.55,126.77 172.1,127.32 v2(172.21,127.32)
  BOTTOM w0.102: JDOCK1.117 172.75,127.86 v2(172.21,127.32)
