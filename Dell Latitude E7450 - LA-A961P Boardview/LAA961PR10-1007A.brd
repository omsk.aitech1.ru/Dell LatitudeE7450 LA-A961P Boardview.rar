# Allegro board LAA961PR10-1007A.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
LPC_LAD3: length 100.2
  TOP w0.102: v2(201.81,95.97) 202.12,96.28 UE2.B33 ; UE1.B25 181.94,97.39 181.72,97.61 v2(181.72,97.78)
  IN1 w0.084: v2(201.81,95.97) 201.13,96.65 198.26,96.65 197.74,96.13 196.04,96.13 195.52,96.65 194.64,96.65 193.86,95.86 188.27,95.86 188.09,95.68 184.57,95.68 184.08,95.19 184.08,94.85 183.72,94.5 182.94,94.5 181.81,95.62 181.81,97.69 v2(181.72,97.78)
  IN4 w0.084: v2(132.95,66.45) 133.41,66.45 134.63,65.23 152.77,65.23 155.37,67.83 155.37,69.81 156.29,70.73 156.53,70.73 157.24,71.44 157.24,72.05 159.04,73.85 160.6,73.85 161.55,74.79 v2(161.57,74.79) 161.89,75.11 161.89,75.52 163.24,76.87 165.15,76.87 167.08,78.8 167.49,78.8 168.54,79.85 168.54,79.82 168.85,80.13 171.87,80.13 174.09,82.34 174.09,83.76 173.99,83.85 173.99,88.31 176.68,90.99 176.68,92.68 177.43,93.43 178.06,93.43 178.65,94.02 178.65,95.71 179.8,96.86 180.8,96.86 v2(181.72,97.78)
  BOTTOM w0.076: UC1.AW11 132.15,67.99 132.15,66.57 132.27,66.45 v2(132.95,66.45)
  BOTTOM w0.102: JLPDE1.6 160.86,75.41 161.47,74.79 v2(161.57,74.79)
LPC_LDRQ1#: length 4.7
  TOP w0.102: RPE8.1 181.03,92.05 181.4,92.41 181.4,94.95 v1(181.3,95.05) 181.19,95.16 UE1.A22
LPC_LFRAME#: length 104.1
  TOP w0.102: UE2.B31 203.12,95.66 v2(202.35,94.9) ; v1(180.44,93.88) 180.98,94.42 v2(180.98,94.58) 180.69,94.87 UE1.A21
  IN1 w0.084: v2(202.35,94.9) 202.1,94.64 200.05,94.64 199.67,95.03 199.05,95.03 198.76,94.73 196.03,94.73 195.46,94.16 194.39,94.16 192.98,95.58 188.39,95.58 188.21,95.39 184.68,95.39 184.36,95.07 184.36,94.73 184.11,94.48 184.11,93.9 183.89,93.68 181.51,93.68 180.98,94.21 v2(180.98,94.58)
  IN4 w0.084: v2(134.42,64.25) 134.47,64.2 152.96,64.2 156.79,68.03 157.49,68.03 158.48,69.03 158.48,70.06 158.83,70.4 159.26,70.4 161.35,72.49 v2(161.39,72.49) 162.61,73.71 163.21,73.71 163.82,74.32 163.82,75.43 164.23,75.84 165.51,75.84 167.26,77.59 168.07,77.59 169.19,78.71 171.67,78.71 174.49,81.53 176.02,81.53 176.72,82.23 176.72,85.56 177.82,86.66 177.82,88.12 180.36,90.67 180.36,93.78 180.98,94.39 v2(180.98,94.58)
  BOTTOM w0.076: UC1.AV12 131.4,68.68 131.4,67.51 131.66,67.26 131.66,66.14 133.55,64.25 v2(134.42,64.25)
  BOTTOM w0.102: JLPDE1.7 160.85,74.91 161.13,74.63 161.13,74.32 161.72,73.73 161.72,72.94 161.39,72.61 v2(161.39,72.49)
M_CLK_DDR0: length 62.4
  IN1 w0.091: v2(89.93,29.34) 89.73,29.14 89.6,29.14 89.26,29.48 89.26,30.14 89.62,30.5 90.14,30.5 90.41,30.77 90.41,33.02 90.53,33.15 91.05,33.15 91.29,33.38 91.29,34.79 94.23,37.73 98.53,37.73 115.56,54.76 115.56,61.09 116.33,61.86 116.93,61.86 117.39,62.32 117.39,63.69 117.16,63.92 117.1,63.92 116.98,64.04 116.98,64.28 117.1,64.4 117.23,64.4 117.43,64.6 117.43,65.51 v2(117,65.93)
  BOTTOM w0.076: v2(117,65.93) 116.55,65.49 116.48,65.49 116.39,65.57 116.39,66.14 116.1,66.43 116.1,69.03 116.2,69.13 116.33,69.13 116.39,69.06 UC1.AV37
  BOTTOM w0.102: v2(89.93,29.34) 89.93,29.15 90.17,28.91 90.27,28.91 90.36,29 90.36,30.55 90,30.91 89.67,30.91 89.55,31.03 JDIMM1.101
M_CLK_DDR1: length 61.5
  IN1 w0.091: v2(90.68,27.03) 90.68,26.85 90.87,26.66 91.33,26.66 91.51,26.85 91.51,27.41 91.33,27.59 90.93,27.59 90.57,27.95 90.57,28.7 91.01,29.14 91.01,32.26 91.88,33.14 91.88,34.54 94.48,37.13 98.78,37.13 116.16,54.52 116.16,60.8 117.57,62.2 117.57,62.78 117.61,62.82 117.61,67.44 117.41,67.64 117.01,67.64 116.82,67.45 v2(116.82,67.31)
  BOTTOM w0.076: UC1.AY36 117.22,67.42 117.11,67.31 v2(116.82,67.31)
  BOTTOM w0.102: JDIMM1.102 89.85,23.94 89.85,24.93 89.97,25.05 89.97,25.32 89.83,25.46 89.83,26.31 89.84,26.32 89.84,26.33 90.32,26.81 90.46,26.81 v2(90.68,27.03)
M_CLK_DDR2: length 98.7
  IN4 w0.091: v2(115.79,71.72) 115.79,71.84 115.62,72.01 115.38,72.01 115.29,71.92 115.29,71.63 115.42,71.5 115.42,70.18 115.81,69.79 115.81,61.85 115.15,61.2 115.15,52.46 129.29,38.32 135.2,38.32 135.4,38.13 135.4,37.37 135.52,37.25 135.87,37.25 136,37.37 136,38.13 136.19,38.32 136.75,38.32 136.94,38.13 136.94,36.81 137.07,36.68 137.41,36.68 137.54,36.81 137.54,38.13 137.73,38.32 138.29,38.32 138.49,38.13 138.49,36.81 138.61,36.68 138.96,36.68 139.09,36.81 139.09,38.13 139.28,38.32 139.84,38.32 140.03,38.13 140.03,36.81 140.16,36.68 140.5,36.68 140.63,36.81 140.63,38.09 140.86,38.32 141.35,38.32 141.57,38.09 141.57,36.81 141.7,36.68 148.42,36.68 149.01,36.09 160.7,36.09 165.43,31.36 165.95,31.36 166.41,30.9 166.41,29.39 166.22,29.2 166.04,29.2 v2(165.84,29)
  BOTTOM w0.076: UC1.AN38 116.18,71.86 116.05,71.72 v2(115.79,71.72)
  BOTTOM w0.102: JDIMM2.101 165.55,31.16 165.12,30.73 165.12,29.5 165.38,29.24 165.6,29.24 v2(165.84,29)
M_CLK_DDR3: length 99
  IN4 w0.091: v2(115.74,72.98) 115.74,73.19 115.53,73.4 114.96,73.4 114.73,73.16 114.73,72.81 114.92,72.62 114.92,71.32 115.06,71.17 115.06,69.88 114.8,69.61 114.8,61.54 114.34,61.09 114.34,53.72 114.34,53.72 114.34,52.06 128.93,37.47 134.2,37.47 135.77,35.91 148.1,35.91 148.69,35.32 160.38,35.32 165.24,30.46 165.24,28.09 165.51,27.82 165.51,25.55 165.31,25.35 164.34,25.35 164.24,25.25 164.24,24.65 164.33,24.56 164.61,24.56 164.8,24.36 164.8,23.9 164.61,23.71 164.33,23.71 164.24,23.62 164.24,21.5 164.34,21.4 164.64,21.4 164.74,21.5 v2(164.74,21.77)
  BOTTOM w0.076: UC1.AL38 116.33,73.2 116.33,73.04 116.27,72.99 115.75,72.99 v2(115.74,72.98)
  BOTTOM w0.102: v2(164.74,21.77) 165,21.52 165.33,21.52 166.04,22.23 166.04,22.8 165.85,22.99 JDIMM2.102
M_CLK_DDR#0: length 62.4
  IN1 w0.091: v2(89.93,28.58) 89.93,28.83 89.79,28.96 89.53,28.96 89.09,29.41 89.09,30.21 89.55,30.68 90.07,30.68 90.23,30.84 90.23,33.09 90.46,33.32 90.98,33.32 91.11,33.46 91.11,34.86 94.16,37.9 98.46,37.9 115.39,54.84 115.39,61.16 116.26,62.03 116.86,62.03 117.21,62.39 117.21,63.62 117.09,63.74 117.03,63.74 116.8,63.97 116.8,64.35 117.03,64.58 117.15,64.58 117.25,64.67 117.25,65.21 117.16,65.3 v2(117,65.3)
  BOTTOM w0.076: v2(117,65.3) 116.4,65.3 116.2,65.49 116.2,66.08 115.94,66.35 115.94,69.11 116.34,69.52 UC1.AU37
  BOTTOM w0.102: v2(89.93,28.58) 90.04,28.69 90.36,28.69 90.58,28.91 90.58,30.64 90.15,31.06 JDIMM1.103
M_CLK_DDR#1: length 61.5
  IN1 w0.091: v2(90.68,26.26) 90.9,26.49 91.4,26.49 91.69,26.78 91.69,27.49 91.41,27.77 91,27.77 90.74,28.02 90.74,28.63 91.18,29.06 91.18,32.18 92.06,33.06 92.06,34.47 94.55,36.96 98.85,36.96 116.33,54.44 116.33,60.73 117.74,62.13 117.74,62.71 117.78,62.75 117.78,67.51 117.48,67.81 116.97,67.81 v2(116.82,67.96)
  BOTTOM w0.089: UC1.AW36 116.89,67.96 v2(116.82,67.96)
  BOTTOM w0.102: v2(90.68,26.26) 90.68,26.47 90.56,26.59 90.41,26.59 90.06,26.24 90.06,25.56 90.2,25.42 90.2,25.19 90.45,24.94 90.45,23.94 JDIMM1.104
M_CLK_DDR#2: length 98.8
  IN4 w0.091: v2(115.79,72.37) 115.6,72.19 115.31,72.19 115.12,72 115.12,71.56 115.24,71.43 115.24,70.11 115.63,69.72 115.63,61.92 114.98,61.27 114.98,52.38 129.22,38.15 135.13,38.15 135.22,38.05 135.22,37.3 135.45,37.07 135.94,37.07 136.17,37.3 136.17,38.05 136.26,38.15 136.68,38.15 136.77,38.05 136.77,36.74 137,36.51 137.49,36.51 137.71,36.74 137.71,38.05 137.8,38.15 138.22,38.15 138.31,38.05 138.31,36.74 138.54,36.51 139.03,36.51 139.26,36.74 139.26,38.05 139.35,38.15 139.77,38.15 139.86,38.05 139.86,36.74 140.09,36.51 140.57,36.51 140.8,36.74 140.8,38.02 140.93,38.15 141.27,38.15 141.4,38.02 141.4,36.74 141.63,36.51 148.35,36.51 148.94,35.92 160.62,35.92 165.36,31.19 165.88,31.19 166.24,30.83 166.24,29.46 166.15,29.37 165.98,29.37 165.84,29.52 v2(165.84,29.76)
  BOTTOM w0.076: UC1.AM38 115.86,72.37 v2(115.79,72.37)
  BOTTOM w0.102: v2(165.84,29.76) 165.84,29.57 165.74,29.47 165.7,29.47 165.69,29.45 165.47,29.45 165.33,29.59 165.33,30.64 165.63,30.94 165.89,30.94 166.15,31.2 JDIMM2.103
M_CLK_DDR#3: length 99.1
  IN4 w0.091: v2(115.79,73.67) 115.69,73.57 114.89,73.57 114.55,73.24 114.55,72.74 114.74,72.55 114.74,71.25 114.89,71.1 114.89,69.95 114.62,69.68 114.62,61.61 114.17,61.16 114.17,54.32 114.17,54.32 114.17,51.99 128.86,37.3 134.13,37.3 135.7,35.74 148.03,35.74 148.62,35.15 160.3,35.15 165.07,30.38 165.07,28.02 165.34,27.75 165.34,25.62 165.24,25.52 164.27,25.52 164.07,25.32 164.07,24.58 164.26,24.38 164.53,24.38 164.63,24.29 164.63,23.98 164.53,23.88 164.26,23.88 164.07,23.69 164.07,21.43 164.27,21.22 164.53,21.22 v2(164.74,21.01)
  BOTTOM w0.076: v2(115.79,73.67) 116.12,74 UC1.AK38
  BOTTOM w0.102: JDIMM2.104 166.45,22.97 166.26,22.77 166.26,22.14 165.42,21.3 165.03,21.3 v2(164.74,21.01)
M_ODT0: length 3.1
  TOP w0.17: RD10.2 94.05,21.82 v2(93.92,21.95)
  BOTTOM w0.17: v2(93.92,21.95) 93.92,22.47 94.05,22.6 JDIMM1.116
M_ODT1: length 3.1
  TOP w0.17: v2(95.38,21.95) 95.19,21.76 RD11.2
  BOTTOM w0.17: v2(95.38,21.95) 95.25,22.08 95.25,23.94 JDIMM1.120
M_ODT2: length 3.5
  TOP w0.17: v2(170.63,21.91) 170.63,21.49 RD12.2
  BOTTOM w0.17: v2(170.63,21.91) 170.54,21.91 170.05,22.4 JDIMM2.116
M_ODT3: length 3.6
  TOP w0.17: v2(172.03,21.89) 172.03,21.75 RD13.2
  BOTTOM w0.17: v2(172.03,21.89) 171.25,22.66 JDIMM2.120
MASK_BASE_LEDS#: length 21.7
  TOP w0.102: QZ7.5 QZ7.2 191.15,126.34 v2(190.06,127.44) ; v2(191.52,119.25) 191.29,119.48 QZ5.2 ; v2(191.52,119.25) 192.01,119.25 192.24,119.48 QZ5.5 QZ14.2 ; v2(191.52,119.25) 191.52,118.68 191.2,118.35 v1(189.08,118.35) 187.77,118.35 187.6,118.18 UZ10.4
  BOTTOM w0.102: v2(191.52,119.25) 191.52,119.75 189.74,121.53 189.74,127.12 v2(190.06,127.44)
MASK_SATA_LED#: length 25.9
  TOP w0.102: v2(188.85,114.86) 189.12,115.13 QZ3.5 ; UE1.B9 178.96,101.59 179.33,101.22 v2(179.33,101.13)
  BOTTOM w0.102: v1(188.85,115.37) v2(188.85,114.86) 189.09,114.62 189.09,108.96 187.01,106.88 187.01,103.53 186.34,102.86 184.28,102.86 183.39,103.75 180.22,103.75 179.83,103.37 179.83,102.23 179.33,101.72 v2(179.33,101.13)
MCARD_PCIE#_SATA: length 103.8
  TOP w0.089: v2(143.25,79.65) 143.25,79.4 v1(143.45,79.2) 143.6,79.05 145.48,79.05 145.8,79.37 146.46,79.37
  TOP w0.102: UE2.B8 210.05,91.5 209.74,91.82 209.3,91.82 208.99,92.13 v2(208.99,92.22) ; 146.46,79.37 148.4,79.37 148.53,79.5 RPC9.7
  IN3 w0.089: v2(143.25,79.65) 143.25,79.87 146.46,83.09
  IN3 w0.122: v2(208.99,92.22) 209.4,92.64 209.69,92.64 210.22,93.17 210.22,96.26 209.46,97.01 198.43,97.01 197.07,98.38 197.07,100.31 196.77,100.61 196.43,100.61 196.18,100.37 196.18,99.67 193.06,96.55 190.87,96.55 189.49,95.18 185.66,95.18 185.03,94.54 185.03,94.21 184.49,93.67 181.74,93.67 181.25,94.16 180.34,94.16 180.17,93.99 178.98,93.99 176.33,96.63 175.21,96.63 174.36,95.78 173.37,95.78 172.48,94.89 162.42,94.89 159.37,91.85 159.37,88.81 155.37,84.81 148.18,84.81 146.46,83.09
  BOTTOM w0.089: v2(143.25,79.65) 143.54,79.36 143.54,77.75 143.32,77.54 140.68,77.54 140.5,77.71 140.5,78.14 140.35,78.3 140,78.3 139.42,77.71 138.9,77.71 UC1.AC1
MCP_TESTLOW1: length 8.2
  TOP w0.109: v2(116.76,91.99) 116.76,92.32 115.95,93.13 115.95,93.49 115.51,93.94 115.51,94.79 RC240.1
  BOTTOM w0.076: UC1.C35 117.64,89.24 117.55,89.39 117.5,89.54 117.5,89.73 117.52,89.76 117.56,89.88 117.56,89.99 117.5,90.16 117.46,90.2 117.46,91.09 116.76,91.79
  BOTTOM w0.089: 116.76,91.79 v2(116.76,91.99) 116.34,92.41 v1(116.31,92.41)
MCP_TESTLOW2: length 9.3
  TOP w0.109: RC241.1 115.74,94.81 115.74,94.03 116.19,93.59 116.19,93.21 117.34,92.06 v2(117.34,91.96)
  BOTTOM w0.076: v2(117.34,91.96) 117.19,91.81 117.19,91.59 117.65,91.13 117.65,90.25 117.73,90.02 117.73,89.85 117.7,89.77 117.69,89.76 117.67,89.7 117.67,89.57 117.7,89.46 117.91,89.26 118.08,89.26 118.25,89.08 UC1.C34
  BOTTOM w0.089: v1(117.45,93.02) 117.34,92.9 v2(117.34,91.96)
MCP_TESTLOW3: length 36.8
  TOP w0.102: v2(134.11,73.5) 134.98,72.63 134.98,70.44 135.28,70.13 137.65,70.13 143.15,64.64 143.15,61.06 143.36,60.85 147.65,60.85 v1(148.26,61.45) 148.45,61.65 155.06,61.65 157.18,63.76 157.18,64.56 v2(157.42,64.8)
  BOTTOM w0.076: v2(134.11,73.5) 134.2,73.5 UC1.AK8
  BOTTOM w0.102: RC242.1 157.57,66.55 157.42,66.4 v2(157.42,64.8)
MCP_TESTLOW4: length 35.5
  TOP w0.102: v2(158,64.8) 158,64.27 v1(157.76,64.02) 155.16,61.42 148.69,61.42 147.89,60.62 143.26,60.62 142.92,60.96 142.92,64.54 137.56,69.9 135.19,69.9 134.75,70.34 134.75,72.21 v2(134.12,72.84)
  BOTTOM w0.076: v2(134.12,72.84) 134.44,73.12 134.48,73.16 UC1.AL8
  BOTTOM w0.102: v2(158,64.8) RC243.1
MDP_AUX#_C: length 25.7
  TOP w0.102: UV502.6 239.79,120.91 240.44,121.56 UV502.8 240.44,126.32 240.88,126.76 240.88,128.44 240.65,128.67 240.41,128.67 240.27,128.81 240.27,129.21 240.4,129.34 240.92,129.34 244.63,125.63 v4(246.93,125.63) 249.76,125.63 250.09,125.96 250.09,126.04 v2(250.64,126.59)
  BOTTOM w0.102: JMDP1.18 250.65,127.36 250.46,127.17 250.46,126.77 v2(250.64,126.59) 250.51,126.46 250.51,126.28 RV501.2
MDP_AUX_C: length 25.6
  TOP w0.102: UV502.3 237.84,121.07 238.27,121.5 238.27,123.69 238.34,123.76 238.34,124.44 238.49,124.58 UV502.11 238.49,127.75 v1(239.28,128.53) 240.3,129.56 241.01,129.56 244.72,125.85 246.65,125.85 246.66,125.86 247.19,125.86 247.21,125.85 249.67,125.85 249.88,126.05 249.88,126.13 250.06,126.31 v2(250.06,126.59)
  BOTTOM w0.102: JMDP1.16 250.05,127.29 250.24,127.1 250.24,126.77 v2(250.06,126.59) 250.19,126.46 250.19,126.23 RV502.2
MDP_CA_DET: length 28
  TOP w0.102: v2(246.67,126.59) 246.67,126.83 v1(246.2,127.3) ; UV502.4 238.49,120.75 238.89,121.15 v2(238.89,123.49) ; UV502.1 236.54,123.01 v2(235.59,123.96) 235.34,124.21 234.43,124.21 233.86,123.64 QV502.2
  IN2 w0.122: v2(238.89,123.49) 238.94,123.43 240.54,123.43 242.95,125.85 245.92,125.85 v2(246.67,126.59)
  IN3 w0.122: v2(238.89,123.49) 238.7,123.68 238.6,123.68 238.11,123.19 236.15,123.19 235.77,123.57 235.77,123.78 v2(235.59,123.96)
  BOTTOM w0.102: JMDP1.4 246.45,127.18 246.67,126.96 v2(246.67,126.59) 247.31,125.95 RV504.1
MDP_CA_DET#: length 13.7
  TOP w0.102: v2(239.15,124.15) 239.18,124.15 239.14,124.18 UV502.10 239.14,127.11 RV507.2 ; v1(232.74,125.15) QV502.1 234.51,124.64 234.66,124.49 235.64,124.49 v2(236.17,123.96) 236.94,123.96 237.19,124.21 UV502.13
  IN3 w0.122: v2(239.15,124.15) 239.18,124.15 238.96,123.92 238.49,123.92 238.03,123.46 236.2,123.46 236.02,123.65 236.02,123.8 v2(236.17,123.96)
MDP_HPD: length 11.7
  TOP w0.102: v2(245.94,126.65) 244.78,126.65 v1(243.94,127.49) 242.19,129.24 242.19,131.88 241.81,132.26 QV501.1
  BOTTOM w0.102: JMDP1.2 245.85,126.74 v2(245.94,126.65) 245.94,126.44 RV505.2
MDP_LANE_N0_C: length 8.9
  BOTTOM w0.102: JMDP1.5 246.37,131.26 244.94,131.26 244.45,130.77 244.45,127.87 244.11,127.53 243.3,127.53 242.89,127.12 CV508.1
MDP_LANE_N1_C: length 8.8
  BOTTOM w0.102: JMDP1.11 248.68,131.47 248.68,130.63 247.77,129.72 245.7,129.72 245.47,129.49 245.47,128.04 245.24,127.82 245.24,126.26 CV506.1
MDP_LANE_N2_C: length 7.8
  BOTTOM w0.102: JMDP1.17 250.65,130.89 250.79,131.03 251.1,131.03 251.97,130.17 251.97,128.97 253.69,127.26 253.69,125.65 253.65,125.62 253.57,125.62 253.23,125.96 CV504.1
MDP_LANE_N3_C: length 7.8
  BOTTOM w0.102: CV502.1 250.27,123.12 250.15,123 249.91,123 249.66,123.26 249.19,123.26 249.07,123.37 249.07,123.78 249.29,123.99 249.29,124.78 249.07,125 249.07,125.43 249.29,125.64 249.29,126.11 248.97,126.43 248.97,127.07 248.55,127.49 248.55,127.68 248.62,127.74 248.77,127.74 248.85,127.82 JMDP1.12
MDP_LANE_P0_C: length 8.8
  BOTTOM w0.102: JMDP1.3 246.57,130.76 246.57,130.91 246.44,131.04 245.02,131.04 244.67,130.68 244.67,127.78 244.2,127.31 243.39,127.31 243.1,127.03 243.1,126.54 243.2,126.44 243.66,126.44 243.78,126.32 CV507.1
MDP_LANE_P1_C: length 8.9
  BOTTOM w0.102: CV505.1 245.02,126.31 245.02,127.91 245.25,128.13 245.25,129.58 245.61,129.94 247.68,129.94 248.46,130.72 248.46,131.43 JMDP1.9
MDP_LANE_P2_C: length 7.8
  BOTTOM w0.102: CV503.1 253.9,126.21 253.9,127.35 252.19,129.06 252.19,130.26 251.19,131.25 250.74,131.25 JMDP1.15
MDP_LANE_P3_C: length 7.7
  BOTTOM w0.102: CV501.1 250.03,122.79 249.82,122.79 249.57,123.04 249.1,123.04 248.86,123.28 248.86,123.87 249.06,124.07 v4(249.06,124.37) 249.06,124.7 248.86,124.91 248.86,125.52 249.07,125.73 249.07,126.02 248.76,126.34 248.76,126.98 248.34,127.4 248.34,127.74 248.25,127.83 JMDP1.10
ME_FWP: length 131.8
  TOP w0.102: v2(129.38,13.73) v1(129.38,14.57)
  IN1 w0.084: v2(129.38,13.73) 129.38,14.27 129.58,14.47 143.39,14.47 144.34,15.42 148.15,15.42 150.22,17.5 155.1,17.5 156.09,16.5 174.25,16.5 176.45,18.7 176.45,37.1 163.13,50.41 155.88,50.41 v2(153.84,48.36)
  BOTTOM w0.102: RC11.1 133.01,60.39 134.66,58.74 139.09,58.74 141.3,56.53 148.82,56.53 153.86,51.49 153.86,48.34 v2(153.84,48.36) ; SW1.3 126.99,13.13 127.23,12.89 127.85,12.89 RC301.2 129.15,13.5 v2(129.38,13.73)
ME_FWP_EC: length 174
  TOP w0.102: v2(202.27,90.15) 202.01,90.41 201.48,90.41 201.39,90.5 UE2.B46 ; v2(193.73,88.15) v1(193.73,87)
  IN1 w0.084: v2(186.01,45.95) 185.56,45.95 179.95,40.34 179.95,25.06 180.67,24.33 180.67,20.83 173.63,13.79 171.47,13.79 171.47,13.78 130.08,13.78 v2(130.06,13.76)
  IN2 w0.122: v2(193.73,88.15) 193.73,83.94 193.05,83.26 193.05,79.47 190.66,77.09 190.66,75.02 187.58,71.94 185.42,71.94 184.77,72.58 177.95,72.58 176.35,70.99 173.99,70.99 172.85,69.85 172.85,50.95 177.85,45.95 v2(186.01,45.95)
  IN3 w0.122: v2(193.73,88.15) 194.45,87.43 195.06,87.43 196.26,88.62 198.69,88.62 199.28,89.21 199.56,89.21 200.77,90.42 202.01,90.42 v2(202.27,90.15)
  BOTTOM w0.102: SW1.1 122.99,15.89 123.26,16.16 124.17,16.16 124.5,16.49 127.69,16.49 128.46,15.71 RC301.1 129.4,14.42 v2(130.06,13.76)
ME_RESET#: length 9
  TOP w0.102: v2(167.07,83.07) 167.22,82.92 RC95.2 ; v2(163.07,83.7) v1(163.07,84.36)
  IN1 w0.084: v2(163.07,83.7) 163.07,84.05 163.34,84.32 165.36,84.32 166.6,83.07 v2(167.07,83.07)
  BOTTOM w0.102: UC4.2 163.25,84.89 RC80.1 163.5,84.5 163.07,84.07 v2(163.07,83.7)
ME_SUS_PWR_ACK: length 134.8
  TOP w0.102: v2(211.78,91.81) 211.72,91.75 UE2.A8
  IN2 w0.122: v2(211.78,91.81) 211.16,91.2 211.16,86.93 211.64,86.46 211.64,85.36 210.92,84.64 210.92,80.89 210.38,80.35 210.38,78.24 208.64,76.5 203.81,76.5 203.53,76.22 203.53,74.15 203.66,74.02 203.66,65.53 205.18,64.01 205.18,62.65 205.47,62.37 205.47,59.33 204.03,57.89 204.03,54.85 197.48,48.3 190.04,48.3 186.52,44.78 158.05,44.78 v2(154.47,48.36)
  BOTTOM w0.076: 140.11,66.03 140.04,66.03 139.15,66.92 138.16,66.92 137.77,67.31 137.41,67.31 137.22,67.5 137.22,68.11 137.17,68.16 137.17,68.63 UC1.AV4
  BOTTOM w0.102: v2(154.47,48.36) 154.13,48.71 154.13,60.72 RC79.2 152.96,61.03 151.58,62.41 148.2,62.41
  BOTTOM w0.109: 140.11,66.03 v1(144.1,66.03) 144.58,66.03 148.2,62.41
MEC_XTAL1: length 3.8
  TOP w0.102: UE2.A61 207.87,86.24 208.09,86.02 208.09,84.65 CE28.1 208.36,83.93 YE1.1
MEC_XTAL2: length 3.6
  TOP w0.102: RE61.2 CE29.1 208.78,82.16 208.78,81.61 207.88,80.72 YE1.2
MEC_XTAL2_R: length 2.6
  TOP w0.102: UE2.A62 208.37,85.45 v1(208.44,85.37) 208.44,85.11 209.16,84.39 RE61.1
MEDIACARD_IRQ#: length 172.4
  TOP w0.102: v2(135.71,78.69) 136.15,78.24 136.65,78.24 137.11,77.78 139,77.78 139.27,77.51 v1(143.68,77.51) 147.96,77.51 148,77.55 RPC10.5 ; v2(18.42,19.84) UR1.16
  IN2 w0.089: v2(135.71,78.69) 135.71,78.48 135.34,78.11 134.89,78.11 132.4,75.62 131.51,75.62 131,75.11 131,74.62 130.66,74.28 130.66,70.03 131.05,69.64 131.05,68.44 130.56,67.95 130.56,58.32
  IN2 w0.122: 130.56,58.32 130.56,54.46 129.63,53.53 87.58,53.53 86.93,52.88 85.75,52.88 85.24,53.38 78.89,53.38 69.32,43.82 65.85,43.82 63.63,46.03 60.58,46.03 56.61,42.06 54.04,42.06 53.68,42.41 52.59,42.41 51.94,41.76 50.73,41.76 50.17,42.33 48.79,42.33 46.23,39.77 44.2,39.77 40.01,35.59 35.23,35.59 35,35.36 34.02,35.36 28.65,29.99 28.65,29.49 26.49,27.32 26.33,27.32 21.44,22.43 20.77,22.43 19.45,21.11 19.45,20.87 v2(18.42,19.84)
  BOTTOM w0.076: v2(135.71,78.69) 135.53,78.51 UC1.AB6
MEDIACARD_PWREN: length 3.9
  TOP w0.102: RR15.2 16.51,20.84 16.73,20.63 v1(16.89,20.63) 17.11,20.63 17.59,21.11 18.3,21.11 18.77,20.64 UR1.14
MEDIACARD_RST#: length 15.3
  TOP w0.102: RPC10.6 147.97,77.05 146.07,75.15 v1(145.01,75.15) 144.44,75.72 139.83,75.72 139.6,75.95 138.43,75.95 138.22,75.73 137.15,75.73 136.67,76.21 136.09,76.21 v2(135.71,75.83)
  BOTTOM w0.076: UC1.AG6 135.53,75.66 135.71,75.84 135.71,75.83 v2(135.71,75.83)
MEM_SMBCLK: length 33.7
  TOP w0.102: v2(156.71,69.76) 156.95,69.99 156.95,70.24 157.25,70.54 160.31,70.54 160.57,70.8 161.53,70.8 161.67,70.95 RPC14.1
  IN1 w0.084: v2(142.43,70.79) 142.86,71.22 147.24,71.22 149.04,73.02 152.47,73.02 156.28,69.21 156.66,69.21 156.9,69.45 156.9,69.57 v2(156.71,69.76)
  BOTTOM w0.076: UC1.AP2 138.4,71.05 138.7,71.35 138.94,71.35 139.12,71.16 139.76,71.16 140.57,70.35 141.99,70.35 v2(142.43,70.79)
  BOTTOM w0.102: QC1.6 159.63,68.43 159.01,67.81 157.19,67.81 156.71,68.28 v2(156.71,69.76)
MEM_SMBDATA: length 31.2
  TOP w0.102: RPC14.2 161.67,70.45 161.53,70.59 160.65,70.59 160.39,70.34 157.33,70.34 157.15,70.16 157.15,69.91 v2(157.3,69.76)
  IN1 w0.084: v2(145.94,70.77) 145.98,70.77 146.24,71.03 147.32,71.03 149.11,72.83 152.39,72.83 156.2,69.02 156.74,69.02 157.09,69.37 157.09,69.54 v2(157.3,69.76)
  BOTTOM w0.076: v2(145.94,70.77) 145.94,72.69 145.41,73.21 143.69,73.21 143.09,73.81 143.09,74.53 142.56,75.06 140.01,75.06 139.75,74.8 UC1.AH1
  BOTTOM w0.102: QC1.3 157.33,69.73 v2(157.3,69.76)
MIC1_L: length 1.8
  TOP w0.203: CA43.1 206.68,66.42 UA1.19
MIC1_R: length 1.9
  TOP w0.203: UA1.20 207.08,66.5 CA44.1
MMICLK_REQ#: length 180.3
  TOP w0.102: v2(17.83,19.84) 17.83,19.57 18.04,19.37 18.56,19.37 18.63,19.44 UR1.17
  IN2 w0.089: 130.28,58.32 130.28,67.67 129.35,68.6 129.35,74.22 130.47,75.34 130.66,75.34 131.82,76.5 131.82,78.71 134.25,81.14 136.51,81.14 137.51,82.13 142.08,82.13 v2(142.84,81.37)
  IN2 w0.122: 130.28,58.32 130.28,54.54 129.52,53.78 87.69,53.78 87.48,53.78 86.83,53.12 85.85,53.12 85.35,53.63 78.79,53.63 69.22,44.06 65.95,44.06 63.74,46.28 60.47,46.28 56.51,42.31 54.14,42.31 53.79,42.66 52.49,42.66 51.84,42.01 50.84,42.01 50.27,42.57 48.68,42.57 46.13,40.02 44.09,40.02 43.77,39.7 42.82,39.7 42.03,38.91 42.03,37.96 39.91,35.84 35.13,35.84 34.89,35.61 33.92,35.61 28.32,30 28.32,29.51 26.53,27.71 26.37,27.71 21.34,22.68 20.67,22.68 17.83,19.84 v2(17.83,19.84)
  BOTTOM w0.076: v2(142.84,81.37) 142.36,80.9 141.53,80.9 141.32,81.12 141.32,81.55 141.1,81.77 140.01,81.77 139.58,81.34 139.03,81.34 138.94,81.25 138.62,81.25 138.61,81.24 UC1.U2
  BOTTOM w0.089: RPC6.5 v1(144.15,80.53) 143.68,80.53 v2(142.84,81.37)
MPCIE_RST#: length 14.4
  TOP w0.089: 146.46,80.29 145.38,80.29 145.2,80.47 v1(142.53,80.47) 141.19,80.47 140.98,80.25 139.74,80.25 v2(139.55,80.45)
  TOP w0.102: RPC17.6 151.33,80 151.2,80.13 151.2,80.76 150.99,80.97 148.6,80.97 147.93,80.29 146.46,80.29
  BOTTOM w0.089: v2(139.55,80.45) 139.16,80.05 UC1.V1
MPHYP_PWR_EN: length 40.1
  TOP w0.102: QZ10.2 165,80.29 166.39,81.68 166.39,83.23 167.08,83.92 RC155.1 RC171.1 166.44,84.93 166.31,84.8 v1(166.31,84.55) 166.31,84.03 v2(166.43,83.92)
  IN1 w0.084: v2(166.43,83.92) 166.06,83.92 165.44,84.53 161.76,84.53 161.45,84.22 157.65,84.22 154.35,80.92 151.46,80.92 151.25,80.71 149.35,80.71 149.26,80.79 143.13,80.79 v2(142.03,79.69)
  BOTTOM w0.076: UC1.Y2 138.62,79.75 139.41,79.75 140,80.35 141.36,80.35 v2(142.03,79.69)
MPHYP_PWR_EN#: length 2.6
  TOP w0.102: v1(166.06,82.97) RZ16.2 165,82.84 QZ10.5 QZ10.6
MSATA_DEVSLP: length 106.1
  TOP w0.102: v2(208.26,57.14) v1(208.93,57.14)
  IN1 w0.084: v2(208.26,57.14) 207.15,57.14 205.73,58.56 205.52,58.77 202.96,58.77 200.09,61.64 200.09,70.14 198.67,71.56 197.6,71.56 196.13,73.03 195.23,73.03 193.73,74.53 189.53,74.53 187.96,76.1 179.94,76.1 179.44,76.6 179.44,76.97 178.98,77.42 178.71,77.42 177.07,79.06 174.61,79.06 171.42,82.25 170.41,82.25 169.03,83.64 168.06,83.64 165.95,85.76 164.2,85.76 163.71,85.27 161.61,85.27 161.19,84.85 157.39,84.85 154.08,81.55 151.2,81.55 150.99,81.34 149.71,81.34 147.23,83.81 142,83.81 v2(141.42,83.24)
  BOTTOM w0.076: 139.49,82.96 139.16,82.96 138.96,82.75 138.62,82.75 UC1.P2
  BOTTOM w0.089: v2(141.42,83.24) 141.06,83.61 140.56,83.61 139.91,82.96 139.49,82.96
  BOTTOM w0.102: RZ39.2 208.79,55.93 208.79,56.61 v2(208.26,57.14) 208.6,57.48 208.6,59.01 209.24,59.65 209.24,61.38 209.84,61.98 213.26,61.98 213.68,62.4 213.68,64.7 213.45,64.93 JNGFF2.30
MSCLK: length 35.8
  TOP w0.102: JDEG1.6 186.25,80.98 185.37,81.86 RE72.2 185.37,82.34 184.84,82.87 184.84,83.67 185.09,83.92 v1(185.09,86.35) 185.09,86.87 185.2,86.98 185.2,90.36 v2(185.76,90.92) ; v2(201.8,92.36) 201.45,92 UE2.B43
  IN1 w0.084: v2(201.8,92.36) 201.7,92.26 196.28,92.26 195.93,91.9 194.69,91.9 193.99,92.61 192.82,92.61 192.28,93.15 192.28,94.73 191.78,95.24 188.53,95.24 188.22,94.92 185.74,94.92 185.44,94.63 185.44,94.03 186.26,93.21 186.26,91.42 v2(185.76,90.92)
MSDATA: length 31.5
  TOP w0.102: v2(187.96,79.05) 187.96,79.39 187.73,79.62 187.07,79.62 186.75,79.94 JDEG1.7 186.75,81.13 186.26,81.63 RE75.2 ; UE2.A40 199.54,92.25 199.46,92.17 RE86.2 198.33,92.7 v1(196.34,92.7) 195.14,92.7 v2(194.87,92.97)
  IN4 w0.084: v2(187.96,79.05) 185.74,81.27 185.74,84.83 186.18,85.27 186.18,89.08 189.05,91.94 190.69,91.94 191.2,92.45 191.94,92.45 192.1,92.29 194.19,92.29 v2(194.87,92.97)
NB_LAN_TX0+: length 25.6
  IN4 w0.241: v2(274.01,124.16) 273.89,124.04 273.89,123.71 274.52,123.08 290.35,123.08 290.92,123.65 290.92,126.54 290.83,126.63 JLOM1.1
  BOTTOM w0.279: v2(274.01,124.16) 273.92,124.07 273.92,123.73 274.62,123.03 TL1.19
NB_LAN_TX0-: length 25.7
  IN4 w0.241: v2(273.42,124.16) 273.52,124.05 273.52,123.56 274.37,122.71 290.51,122.71 291.29,123.5 291.29,127.37 JLOM1.2
  BOTTOM w0.279: TL1.20 273.35,123.33 273.51,123.5 273.51,124.07 v2(273.42,124.16)
NB_LAN_TX1+: length 35.8
  IN4 w0.241: JLOM1.3 292.87,129.03 292.87,125.14 294.12,123.89 294.12,123.26 292.63,121.76 270.37,121.76 268.93,123.2 268.93,123.99 v2(269.04,124.1)
  BOTTOM w0.279: TL1.23 269.54,122.93 268.95,123.51 268.95,124.01 v2(269.04,124.1)
NB_LAN_TX1-: length 35.8
  IN4 w0.241: JLOM1.6 295.93,125.53 295.93,125.53 294.49,124.09 294.49,123.1 292.78,121.39 270.21,121.39 268.56,123.04 268.56,123.99 v2(268.46,124.1)
  BOTTOM w0.279: TL1.24 268.27,123.19 268.54,123.47 268.54,124.01 v2(268.46,124.1)
NB_LAN_TX2+: length 21.4
  IN1 w0.241: JLOM1.4 293.89,127.68 294.77,126.8 294.77,124.39 293.47,123.08 287.09,123.08 286.02,124.16 281.31,124.16 v2(281.21,124.27)
  BOTTOM w0.279: v2(281.21,124.27) 281.94,124.27 282.24,123.97 TL1.13
NB_LAN_TX2-: length 21.5
  IN1 w0.241: JLOM1.5 294.91,129.03 294.91,127.18 295.14,126.95 295.14,124.23 293.62,122.71 286.94,122.71 285.87,123.79 281.31,123.79 v2(281.21,123.68)
  BOTTOM w0.279: TL1.14 280.97,123.44 v2(281.21,123.68)
NB_LAN_TX3+: length 30.2
  IN1 w0.241: v2(276.61,124.07) 276.5,123.96 276.5,123.2 277.94,121.76 294.68,121.76 297.18,124.26 297.18,124.72 296.95,124.95 296.95,129.03 JLOM1.7
  BOTTOM w0.279: v2(276.61,124.07) 276.52,123.98 276.52,123.64 277.16,123 TL1.17
NB_LAN_TX3-: length 30.2
  IN1 w0.241: JLOM1.8 297.55,127.51 297.55,124.11 294.84,121.39 277.79,121.39 276.13,123.05 276.13,123.96 v2(276.02,124.07)
  BOTTOM w0.279: v2(276.02,124.07) 276.11,123.98 276.11,123.65 275.89,123.42 TL1.18
NB_PSID: length 2.1
  TOP w0.508: v2(78.78,115.99) v1(78.27,115.48) 77.83,115.04 PL3.2
NB_PSID_TS5A63157: length 4.8
  TOP w0.102: v1(71.25,118.99) PR8.1
  TOP w0.254: PR9.2 71.25,118 PR8.1 70.65,118.04 69.96,117.34 PU1.3
NFC_IRQ: length 32.3
  IN1 w0.084: v2(162.51,64.75) 161.43,65.83 155.31,65.83 153.85,64.36 148.72,64.36 146.35,66.73 146.35,69 145.05,70.31 144.07,70.31 v2(143.61,70.77)
  BOTTOM w0.076: UC1.AN3 137.77,71.51 138.29,71.51 138.52,71.75 138.52,71.93 138.58,71.98 138.7,72.1 138.94,72.1 139.15,71.89 139.42,71.89 139.57,71.74 140.79,71.74 141.33,71.2 v1(142.15,71.2) 143.18,71.2 v2(143.61,70.77)
  BOTTOM w0.102: RC175.1 161.78,65.48 v2(162.51,64.75)
NGFF_CONFIG_0: length 128.7
  TOP w0.102: RPE4.1 174.63,95.7 v2(174.92,95.41) ; v2(178.63,100.26) 178.46,100.09 UE1.B12
  IN1 w0.084: v2(178.63,100.26) 178.25,100.26 174.75,96.76 174.75,95.57 v2(174.92,95.41)
  IN2 w0.122: v2(174.92,95.41) 171.09,95.41 167.27,91.58 167.27,85.53 168.4,84.4 168.4,79.12 166.06,76.78 166.06,74.1 164.11,72.15 164.11,71.08 162.51,69.48 162.51,67.76 160.38,65.63 160.38,63.13 159.62,62.37 159.62,61.1 159.14,60.61 159.14,51.73 v2(161.09,49.77)
  BOTTOM w0.102: v2(161.09,49.77) 162.04,50.73 168.79,50.73 177.37,42.14 193.94,42.14 200.11,48.31 205.02,48.31 205.76,49.05 v1(207.06,49.05) 207.43,49.05 210.16,51.79 210.16,56.59 209.55,57.2 209.36,57.2 209.2,57.36 JNGFF2.13
NGFF_CONFIG_1: length 137.5
  TOP w0.102: RPE4.2 174.7,96.2 175.49,95.41 v2(175.53,95.41) ; v2(177.71,93.96) 178.17,94.42 178.17,94.83 179.19,95.85 UE1.A18
  IN1 w0.084: v2(177.71,93.96) 177.34,93.96 175.88,95.42 175.54,95.42 v2(175.53,95.41)
  IN2 w0.122: v2(177.71,93.96) 176.96,93.96 176.02,93.01 170.6,93.01 167.52,89.93 167.52,85.64 168.72,84.44 168.72,79.02 166.31,76.61 166.31,74 164.36,72.05 164.36,70.98 162.76,69.37 162.76,67.66 160.63,65.53 160.63,63.03 159.87,62.26 159.87,60.99 159.39,60.51 159.39,52.19 161.67,49.9 v2(161.67,49.77)
  BOTTOM w0.102: v2(161.67,49.77) 162.4,50.5 167.71,50.5 176.62,41.58 194.31,41.58 200.59,47.86 207.41,47.86 209.43,49.88 209.43,50.41 210.73,51.71 210.73,52.35 211.57,53.19 213.25,53.19 213.62,52.82 215.14,52.82 215.48,53.17 216.5,53.17 v1(217.63,54.3) 218.44,55.11 220.47,55.11 221.2,55.83 JNGFF2.61
NGFF_CONFIG_2: length 116.8
  TOP w0.102: v2(188.63,103.89) 188.63,103.59 188.38,103.34 UE1.A44 ; v2(173.61,97.65) 173.55,97.59 173.55,96.96 173.81,96.7 RPE4.3
  IN1 w0.084: v2(188.63,103.89) 188.48,103.73 175.96,103.73 174.86,102.63 174.86,101.58 175.15,101.29 175.15,98.11 174.69,97.65 v2(173.61,97.65)
  IN3 w0.122: v2(188.63,103.89) 188.63,104.54 189.04,104.96 198.91,104.96 200.68,106.73 206.33,106.73 207.2,107.6 213.9,107.6 217.27,104.23 217.27,101.87 219.33,99.81 219.33,94.48 221.43,92.38 224.57,92.38 227.69,89.26 227.69,87.3 227.18,86.8 227.18,79.6 227.97,78.81 227.97,75.5 v2(227.79,75.31)
  BOTTOM w0.102: JNGFF2.67 222.7,57.2 223.21,56.69 227.39,56.69 v1(227.9,57.2) 229.36,58.66 229.36,73.74 v2(227.79,75.31)
NGFF_CONFIG_3: length 128.6
  TOP w0.102: v2(188.66,94.37) 188.66,95.49 187.16,97 UE1.B34 ; RPE4.4 174.76,97.2 175.33,96.63 v2(175.33,96.16)
  IN2 w0.122: v2(188.66,94.37) 188.66,94.17 187.28,92.79 187.28,91.89 186.93,91.54 186.93,89.75 185.51,88.33 185.51,78.25 182.7,75.44 178.33,75.44 177.87,74.98 175.64,74.98 175.38,74.72 172.99,74.72 168.82,70.55 168.82,67.26 167.99,66.42 167.99,63.22 168.58,62.63 170.51,62.63 170.96,62.18 170.96,48.87 171.23,48.6 171.86,48.6 v2(171.93,48.67)
  IN3 w0.122: v2(188.66,94.37) 188.25,93.96 185.36,93.96 184.81,93.42 181.63,93.42 181.14,93.91 180.44,93.91 180.27,93.74 178.88,93.74 176.81,95.8 175.69,95.8 v2(175.33,96.16)
  BOTTOM w0.102: v2(171.93,48.67) 171.93,48.23 176.74,43.42 185.8,43.42 187.49,45.12 187.49,46.97 189.14,48.62 195.95,48.62 197.68,50.35 200.24,50.35 201.36,51.46 202.48,51.46 203.55,52.53 v1(203.55,52.7) 203.55,56.09 203.93,56.47 203.93,56.96 204.2,57.23 JNGFF2.1
O-USR: length 5
  TOP w0.203: v2(92.08,102.75) 91.94,102.61 PR509.2
  BOTTOM w0.102: v1(92.89,104.12) PR504.1
  BOTTOM w0.203: PU500.9 91.25,101.5 91.38,101.63 91.38,102.05 v2(92.08,102.75) 92.51,103.18 PR504.1
OCP-I: length 7.3
  TOP w0.254: PR506.2 91.7,99.94 v2(91.89,100.13) 92.09,100.13 PR501.1 93.14,99.38 94.04,98.49 94.54,98.49 95.05,98.99 PR524.2
  BOTTOM w0.102: v2(91.89,100.13) 91.96,100.13 v1(92.29,100.46)
  BOTTOM w0.203: v2(91.89,100.13) 91.72,100.3 PU500.12
OUT1_CA_DET: length 1.7
  TOP w0.102: UV600.43 144.63,117.91 144.72,117.82 RV606.2
OUT2_CA_DET: length 3.8
  TOP w0.102: UV600.33 145.08,113.91 RV607.2 145.3,113.69 145.3,113.55 146.14,112.72 v1(146.14,112.11)
P33ALW: length 3.4
  TOP w0.254: PU800.18 24.29,37.54 25.03,38.28 v1(25.03,38.61) 25.03,38.93 25.75,39.64 PR859.1
P33ALW2: length 2.7
  TOP w0.254: PR855.2 24.15,30.72 v1(23.43,31.44) 23.33,31.44 22.91,31.86 PU800.9
PANEL_BKEN_EC: length 110.6
  TOP w0.102: v2(185.92,98.74) 186.28,99.09 UE1.B38 ; DV2.2 104.21,114.84 104.21,114.23 105.22,113.22 v2(105.22,112.96) v1(105.22,112.39)
  IN2 w0.122: v2(105.22,112.96) 106.31,114.05 116.14,114.05 117.1,113.09 127.96,113.09 129.38,111.66 130.51,111.66 131.13,111.04 131.13,105.79 129.99,104.65 129.99,99.18 130.62,98.54 131.79,98.54 132.3,98.03 132.3,97.58 133.95,95.92 133.95,92.86 134.37,92.45 137.1,92.45 137.53,92.88 v2(137.53,93.22)
  IN3 w0.122: v2(137.53,93.22) 137.67,93.08 142.85,93.08 146.38,96.6 155.02,96.6 156.1,97.68 169.78,97.68 171.22,99.11 175.13,99.11 175.78,99.76 176.66,99.76 179.06,97.36 183.91,97.36 184.22,97.67 184.22,98.21 184.76,98.75 185.91,98.75 v2(185.92,98.74)
PANEL_BKLEN: length 55.6
  TOP w0.102: v2(104.52,112.96) 104.52,113.59 103.24,114.87 DV2.3
  IN2 w0.122: v2(134.34,93.15) 134.2,93.29 134.2,95.97 132.55,97.63 132.55,98.14 131.89,98.79 130.73,98.79 130.24,99.28 130.24,104.55 131.38,105.69 131.38,111.15 130.62,111.91 129.49,111.91 128.06,113.34 117.21,113.34 116.25,114.3 105.86,114.3 v2(104.52,112.96)
  BOTTOM w0.076: v2(134.34,93.15) v1(134.34,92.48) 134.34,91.66 133.36,90.68 UC1.A9
PANEL_HDD_LED#: length 104
  TOP w0.102: v2(189.11,107.75) v1(189.11,110.32) 189.11,111.85 189.26,112 QZ4.3
  IN3 w0.122: v2(112.17,119.13) 112.17,119.03 112.98,118.21 115.4,118.21 119.06,114.55 126.48,114.55 128.74,116.81 138.38,116.81 142.3,120.72 160.5,120.72 162.96,118.26 162.96,115.13 162.36,114.54 162.36,113.38 163.64,112.1 171.32,112.1 172.73,110.7 175.62,110.7 176.33,109.98 178.61,109.98 180.01,108.57 186.15,108.57 187.06,107.66 189.02,107.66 v2(189.11,107.75)
  BOTTOM w0.102: JLED1.4 118.41,119.41 117.11,120.7 113.74,120.7 v2(112.17,119.13)
PBAT_PRES#: length 370.3
  TOP w0.102: UE2.A49 201.87,86.26 201.75,86.15 201.39,86.15 v2(201.22,86.32)
  TOP w0.254: v2(7.75,38.87) PU804.1 ; v2(36.01,37.96) 35.63,37.58 v1(33.9,37.58) 33.72,37.58 33.23,38.08 PR728.1
  IN1 w0.084: v2(221.26,54.47) 219.28,54.47 215.5,58.26 215.5,61.45 216.83,62.78 216.83,63.08 219.34,65.59 219.61,65.59 224.38,70.35 224.38,77.52 226.53,79.68 226.53,87.01 225.76,87.79 223.7,87.79 223.14,87.23 221.35,87.23 218.79,84.67 217.51,84.67 217.37,84.53 216.03,84.53 215.08,85.49 212.31,85.49 211.65,84.83 210.87,84.83 210.03,85.67 210.03,86.33 209.52,86.84 201.74,86.84 v2(201.22,86.32)
  IN2 w0.122: v2(221.26,54.47) 221.26,52.16 223.68,49.74 223.68,37.88 216.61,30.81 211.29,30.81 210.7,30.22 210.7,25.96 212.92,23.74 212.92,15.87 209.63,12.58 201.37,12.58 198.04,9.24 180.86,9.24 177.79,12.31 163.24,12.31 161.8,13.74 153.66,13.74 151.62,11.7 v2(151.62,8.64)
  IN3 w0.254: v2(151.65,16.73) 152,16.73 153.15,17.88 v2(157.42,17.88) ; v2(36.01,37.96) 35.64,37.6 34.27,37.6 33.56,38.31 31.5,38.31 30.38,39.42 28.65,39.42 28.43,39.65 27.06,39.65 26.26,38.85 13.55,38.85 12.48,39.92 10.34,39.92 9.29,38.87 v2(7.75,38.87)
  IN4 w0.254: v2(151.65,16.73) 151.65,18.09 151.2,18.55 145.34,18.55 144.61,19.28 130.57,19.28 126.22,23.64 120.26,23.64 119.63,23 111.79,23 110.75,21.96 98.95,21.96 98.36,22.54 97.95,22.54 96.9,23.59 56,23.59 53.95,25.64 52.9,25.64 49.34,29.2 49.34,29.7 48.33,30.71 43.65,30.71 40.34,34.03 40.34,35.79 39.37,36.76 36.64,36.76 36.01,37.39 v2(36.01,37.96)
  BOTTOM w0.254: v2(151.62,8.64) 151.62,14.1 150.73,14.99 PD4.1 150.73,16.69 PR2.2 151.41,16.97 v2(151.65,16.73) ; v2(157.42,17.88) 157.42,18.33 157.02,18.73 PRP2.3
PBAT_PRES#_C: length 21.1
  IN2 w0.254: v2(153.25,12.3) 160.5,5.05 PBATT1.5
  BOTTOM w0.254: PRP2.6 154.16,18.73 153.56,18.13 v1(153.56,17.36) 153.56,13.7 PD2.2 153.25,13.38 v2(153.25,12.3)
PBAT_SMBCLK: length 115.2
  TOP w0.102: RE43.2 203.9,83.32 v2(203.45,82.87) ; UE2.A56 205.37,86.21 205.67,85.9 v2(205.67,85.84)
  IN4 w0.084: v2(158.61,17.86) 158.42,18.06 158.42,18.27 158.47,18.32 164.76,18.32 166.31,19.87 188.55,19.87 190.45,21.78 194.52,21.78 197.79,25.05 198.54,25.05 201.23,27.74 201.23,32.75 202.44,33.96 202.44,36.24 202.92,36.72 202.92,52.73 203.57,53.38 203.57,54.88 202.89,55.56 202.89,58.65 203.32,59.09 203.32,61.4 201.73,62.99 201.73,74.51 202.22,75.01 202.22,77.14 203.29,78.22 203.29,82.71 v2(203.45,82.87)
  BOTTOM w0.102: v2(158.61,17.86) 158.41,18.06 v4(158.41,18.86) 158.41,19.12 157.95,19.58 157.18,19.58 157.03,19.73 PRP2.1 ; v2(203.45,82.87) 203.27,83.06 203.27,83.18 203.39,83.3 204.77,83.3 205.27,83.8 205.27,85.43 v2(205.67,85.84)
PBAT_SMBCLK_C: length 24.4
  TOP w0.254: v2(155.21,12.56) v1(154.76,13.01) 153.82,13.95 153.82,18.65 v2(155.41,20.23)
  IN2 w0.254: PBATT1.3 164.5,3.27 v2(155.21,12.56)
  BOTTOM w0.254: v2(155.21,12.56) 155.24,12.59 PD1.2 ; PRP2.8 155.41,19.73 v2(155.41,20.23)
PBAT_SMBDAT: length 119.3
  TOP w0.102: v2(204.54,88.89) 204.66,88.89 205.12,88.44 UE2.B59 ; RE37.2 203.33,82.41 v2(202.87,82.87)
  IN4 w0.084: v2(202.87,82.87) 203.11,82.63 203.11,78.29 202.03,77.22 202.03,75.09 201.54,74.59 201.54,62.92 203.14,61.32 203.14,59.17 202.7,58.73 202.7,55.48 203.39,54.8 203.39,53.46 202.73,52.8 202.73,36.79 202.25,36.31 202.25,34.03 201.04,32.83 201.04,27.81 198.46,25.23 197.71,25.23 194.44,21.96 190.38,21.96 188.47,20.06 166.24,20.06 164.68,18.5 158.39,18.5 158.23,18.34 158.23,18.06 v2(158.03,17.86)
  BOTTOM w0.102: v2(158.03,17.86) 158.21,18.04 158.21,18.53 158.18,18.56 158.18,19.06 157.87,19.37 157.18,19.37 157.03,19.23 PRP2.2 ; v2(204.54,88.89) 204.09,88.45 204.09,87.94 205.06,86.97 205.06,83.89 204.68,83.51 203.31,83.51 203.06,83.26 203.06,83.06 v2(202.87,82.87)
PBAT_SMBDAT_C: length 25.6
  TOP w0.254: v2(154.7,20.22) 153.33,18.85 153.33,13.47 v2(154.22,12.58)
  IN2 w0.254: PBATT1.4 162.5,4.29 v2(154.22,12.58)
  BOTTOM w0.102: v1(155.25,20.91) 154.7,20.36 v2(154.7,20.22)
  BOTTOM w0.254: v2(154.22,12.58) 154.24,12.6 PD1.3 ; PRP2.7 154.94,19.23 154.7,19.47 v2(154.7,20.22)
PBATT+_C:
  vias: v1(161.28,12.51) v2(156.5,12.73) v2(156.48,12.13) v2(157.14,12.73) v2(157.11,12.13) v2(157.84,12.72) v2(157.79,12.13) v2(158.47,12.72) v2(158.42,12.13) v2(159.06,12.13) v2(159.11,12.72) v2(166.27,3.61) v2(166.28,4.23) v2(166.92,4.23) v2(166.91,3.61) v2(167.59,4.23) v2(167.58,3.61) v2(168.23,4.23) v2(168.21,3.61) v2(168.86,4.23) v2(168.85,3.61)
PCH_ALW_ON: length 101.1
  TOP w0.102: v2(165.55,94.23) v1(165.55,97.09) 165.55,99.1 v2(166.45,100) ; UE2.A34 199.75,95.25 199.11,95.89 199.11,96.64 198.77,96.98 197.53,96.98 v2(197.36,97.15) ; RPE10.4 206.37,103.76 206.19,103.94 204.6,103.94 204.41,104.13 204.41,104.77 v2(203.9,105.27)
  TOP w0.203: v2(131.3,96.93) 131.38,96.93 131.57,97.11 UZ7.5
  IN2 w0.122: v2(197.36,97.15) 197.36,102.31 v2(199.13,104.08)
  IN3 w0.122: v2(197.36,97.15) 197.14,97.36 194.57,97.36 193.27,96.06 191.11,96.06 189.89,94.83 189.89,94.4 188.88,93.39 185.49,93.39 184.93,92.83 181.28,92.83 181.27,92.83 179.85,92.83 179.65,93.04 176.35,93.04 174.22,95.17 173.51,95.17 172.57,94.23 v2(165.55,94.23) ; v2(199.13,104.08) 200.07,105.02 201.87,105.02 202.12,105.27 v2(203.9,105.27) ; v2(166.45,100) 165.64,99.2 158.09,99.2 157.35,99.94 151.32,99.94 151.19,100.06 147.1,100.06 143.04,96 137.04,96 136.4,96.64 131.59,96.64 v2(131.3,96.93)
PCH_AZ_BITCLK: length 6.7
  BOTTOM w0.089: UC1.AW8 133.61,67.96 133.61,66.82 135.49,64.94 v1(135.49,64.48) 135.49,63.57 135.81,63.25 RC23.2
PCH_AZ_CODEC_BITCLK: length 93.4
  TOP w0.102: UA1.6 202.11,70.97 RA17.1 201.3,70.87 199.7,70.87 199.37,70.54 v1(197.07,70.54) v2(196.31,70.54)
  IN1 w0.084: v2(149.07,61.01) 149.07,59.9 151.03,57.94 163.49,57.94 165.76,55.68 167.23,55.68 169.77,53.14 183.04,53.14 183.54,53.64 193.35,53.64 v2(193.49,53.78)
  IN2 w0.122: v2(196.31,70.54) 197.64,69.21 197.64,68 197.27,67.63 197.27,60.02 198.52,58.78 198.52,57.39 198.03,56.91 196.62,56.91 v2(193.49,53.78)
  BOTTOM w0.102: v2(149.07,61.01) 146.38,58.32 141.74,58.32 139.75,60.32 136.37,60.32 CC5.1 135.86,61.65 RC23.1
PCH_AZ_CODEC_RST#: length 84.7
  TOP w0.102: UA1.11 203.03,68.97 202.76,68.7 202.76,68.13 202.48,67.85 201.72,67.85 201.62,67.95 198.2,67.95 197.64,67.39 197.64,65.78 196.56,64.7 196.56,58.88 194.89,57.21 v1(194.89,56.48) 194.89,55.87 194.33,55.31 194.05,55.31 193.42,54.67 v2(193.42,54.54)
  IN1 w0.084: v2(193.42,54.54) 193.11,54.23 190.25,54.23 190.05,54.43 183.5,54.43 183.22,54.16 179.76,54.16 179.33,53.73 170.42,53.73 167.13,57.02 165.3,57.02 162.77,59.54 151.09,59.54 v2(149.68,60.95)
  BOTTOM w0.102: RC22.1 137.08,61.32 139.61,61.32 141.99,58.93 146.13,58.93 148.85,61.65 149.51,61.65 149.68,61.47 v2(149.68,60.95)
PCH_AZ_CODEC_SDIN0: length 91.4
  TOP w0.102: v2(192.79,54.66) 192.91,54.66 193.73,55.49 193.73,57.13 195.85,59.25 195.85,64.99 196.93,66.07 v1(196.93,67.26) 196.93,67.87 198.53,69.47 200.59,69.47 RA9.1
  IN1 w0.084: v2(150.89,60.95) 151.96,59.88 162.91,59.88 165.44,57.36 167.27,57.36 170.56,54.07 179.19,54.07 179.62,54.5 183.08,54.5 183.36,54.77 190.41,54.77 190.7,55.06 192.39,55.06 v2(192.79,54.66)
  BOTTOM w0.089: 135.13,64.94 135.13,65.05 133.19,66.99 UC1.AY10
  BOTTOM w0.102: v2(150.89,60.95) 147.65,57.71 141.49,57.71 139.49,59.71 136.23,59.71 135.31,60.62 135.31,63.08 135.13,63.26 135.13,64.94
PCH_AZ_CODEC_SDOUT: length 100.5
  TOP w0.102: v2(193.27,55.6) 193.27,57.24 195.14,59.11 v1(195.14,60.77) 195.14,70.73 195.91,71.5 198.39,71.5 198.82,71.94 201.23,71.94 201.36,71.81 202.22,71.81 202.66,71.37 UA1.5
  IN1 w0.084: v2(151.48,60.93) 151.48,61.46 151.33,61.61 148.31,61.61 148.19,61.73 148.19,62.78 148.31,62.9 161,62.9 161.13,62.78 161.13,60.38 161.25,60.25 163.02,60.25 165.58,57.69 167.41,57.69 170.23,54.87 182.98,54.87 183.22,55.11 190.27,55.11 190.56,55.4 193.07,55.4 v2(193.27,55.6)
  BOTTOM w0.102: RC19.1 134.79,60.87 136.31,59.35 139.35,59.35 141.34,57.36 147.9,57.36 v2(151.48,60.93)
PCH_AZ_CODEC_SYNC: length 54.1
  TOP w0.102: v2(194.16,55.71) 194.16,56.98 196.2,59.03 196.2,64.84 197.28,65.92 197.28,67.63 197.96,68.3 v1(198.48,68.3) 201.69,68.3 201.92,68.08 202.33,68.08 202.53,68.28 202.53,68.85 203.05,69.37 UA1.10 ; RC20.1 164.25,59.99 v2(165.34,59.99)
  IN1 w0.084: v2(165.34,59.99) 165.34,58.41 165.72,58.03 167.55,58.03 170.37,55.21 182.84,55.21 183.08,55.45 190.13,55.45 190.42,55.74 192.68,55.74 192.94,56 193.87,56 v2(194.16,55.71)
PCH_AZ_RST#: length 8.1
  BOTTOM w0.076: 134.22,67.24 134.24,67.25 134.24,68.78 134.27,68.82 134.27,69.29 UC1.AU8
  BOTTOM w0.089: 134.22,67.24 134.22,66.46 136.7,63.99 v1(136.7,63.72) RC22.2
PCH_AZ_SDIN0_R: length 1.5
  TOP w0.102: RA9.2 202.2,70.17 UA1.8
PCH_AZ_SDOUT: length 12.3
  BOTTOM w0.089: v1(134.13,60.53) 133.76,60.9 133.76,61.87 RC11.2 RC19.2 134.79,63.1 134.84,63.15 134.84,65.09 132.82,67.11 132.82,69.25 UC1.AU11
PCH_AZ_SYNC: length 40
  TOP w0.102: RC20.2 162.58,59.79 161.85,59.07 161.85,58.68 161.39,58.22 158.63,58.22 156.97,56.56 141.43,56.56 137.44,60.54 137.05,60.54 v1(136.51,61.09) 135.1,62.5 135.1,65.61 v2(132.07,68.64)
  BOTTOM w0.076: UC1.AV11 132.37,68.94 v2(132.07,68.64)
PCH_BATLOW#: length 32.6
  TOP w0.102: RPC5.5 155.24,75.99 155.74,76.5 155.74,77.66 156.01,77.93 v1(157.48,77.93) 158.08,77.93 v2(158.62,78.47)
  IN3 w0.089: 146.46,73.94 145.6,73.08 140.85,73.08 139.58,71.8 137.58,71.8 v2(137.2,72.18)
  IN3 w0.122: 146.46,73.94 148.6,76.08 148.6,77.69 149.66,78.75 153.62,78.75 154.84,79.98 156.87,79.98 158.38,78.47 v2(158.62,78.47)
  BOTTOM w0.076: v2(137.2,72.18) 136.87,71.84 UC1.AN4
PCH_CL_CLK1: length 56.2
  IN4 w0.084: v2(168.72,87.91) 167.67,87.91 164.75,84.99 164.75,83.84 163.74,82.83 162.63,82.83 162.35,82.54 162.35,82.13 161.31,81.09 160.23,81.09 159.46,80.33 157.99,80.33 157.38,79.72 157.38,78.63 155.64,76.89 155.64,76.66 153.84,74.87 146.3,74.87 144.53,76.64 143.51,76.64 v2(142.99,76.12)
  BOTTOM w0.076: v2(142.99,76.12) v1(142.42,76.69) 142.26,76.85 139.03,76.85 138.94,76.76 138.63,76.76 138.62,76.75 138.61,76.75 UC1.AF2
  BOTTOM w0.102: v2(168.72,87.91) 168.72,90.52 170.16,91.95 178.53,91.95 180.41,90.07 180.41,89.67 180.55,89.52 JNGFF1.34
PCH_CL_DATA1: length 56.1
  IN4 w0.084: v2(169.17,88.75) 167.56,88.75 162.36,83.56 161.52,83.56 160.26,82.3 158.78,82.3 156.62,80.14 156.62,78.82 155.07,77.27 154.48,77.27 153.84,76.64 152.97,76.64 151.88,75.54 150.29,75.54 150.2,75.63 150.2,76.13 150.12,76.22 149.87,76.22 149.79,76.13 149.79,75.63 149.7,75.54 149.45,75.54 149.37,75.63 149.37,76.13 149.28,76.22 149.03,76.22 148.95,76.13 148.95,75.63 148.86,75.54 146.82,75.54 145.02,77.33 144.34,77.33 143.95,77.72 v2(143.95,77.93)
  BOTTOM w0.076: v2(143.95,77.93) 143.2,77.18 139.25,77.18 139.09,77.34 138.7,77.34 138.4,77.05 UC1.AD2
  BOTTOM w0.102: v2(169.17,88.75) 169.17,90.46 170.3,91.6 178.38,91.6 180.05,89.93 JNGFF1.32
PCH_CL_RST1#: length 55.7
  IN4 w0.084: v2(139.94,76.15) 140.76,76.98 144.72,76.98 146.49,75.2 153.7,75.2 154.22,75.72 154.22,76.54 154.62,76.93 155.21,76.93 157.04,78.77 157.04,79.86 157.89,80.71 159.15,80.71 161.66,83.22 163.54,83.22 164.41,84.09 164.41,85.13 167.59,88.31 168.93,88.31 v2(169.31,87.94)
  BOTTOM w0.076: v2(139.94,76.15) 139.08,76.15 138.94,76.01 138.63,76.01 138.46,75.84 137.68,75.84 137.58,75.94 137.19,75.94 UC1.AF4
  BOTTOM w0.102: v2(169.31,87.94) 169.7,88.33 169.7,90.49 170.45,91.24 178.23,91.24 179.55,89.92 JNGFF1.30
PCH_DPWROK: length 97.3
  TOP w0.102: v2(165.66,64.56) 165.24,64.14 165.24,62.02 164.52,61.29 160.54,61.29 159.5,60.25 157.09,60.25 155.25,58.41 142.42,58.41 140.76,60.07 v1(140.76,61.06) 140.76,63.42 v2(138.27,65.91) ; v2(199.36,94.63) 199.36,94.34 199.46,94.25 UE2.A36
  IN4 w0.084: v2(199.36,94.63) 199.24,94.75 196.02,94.75 194.71,93.44 194.44,93.44 193.76,92.76 192.29,92.76 192.14,92.91 189.36,92.91 185.72,89.27 185.72,85.46 185.28,85.02 185.28,80.7 182.42,77.84 176.6,77.84 174.37,75.62 174.37,72.15 172.85,70.62 168.32,70.62 166.52,68.83 166.52,65.42 v2(165.66,64.56)
  BOTTOM w0.076: UC1.AV5 135.9,68.68 135.9,67.5 136.18,67.22 136.18,66.85 136.74,66.28 137.89,66.28 v2(138.27,65.91)
PCH_GPIO4: length 8.3
  BOTTOM w0.076: UC1.F2 138.17,86.84 138.55,87.22 v1(141.01,87.22) 142.65,87.22 142.79,87.37
  BOTTOM w0.102: 142.79,87.37 144.48,87.37 145.37,86.47 RPC8.3
PCH_GPIO5: length 13.7
  TOP w0.089: v2(140.79,86.8) 140.79,87.2 144.86,91.27 144.86,91.92
  TOP w0.102: RPC4.6 v1(144.88,93.88) 144.88,91.93 144.86,91.92
  BOTTOM w0.076: UC1.F3 137.73,86.75 138.03,86.45 138.34,86.45 138.39,86.5 139.07,86.5 139.18,86.39 139.92,86.39
  BOTTOM w0.089: v2(140.79,86.8) 140.32,86.8 139.92,86.39
PCH_GPIO6: length 12.5
  IN1 w0.084: v2(143.31,86.79) 143.54,87.02 143.54,87.14 143.38,87.3 140.61,87.3 140.32,87.02 140.32,86.25 139.75,85.67 138.95,85.67 138.61,86.01 138.28,86.34 137.84,86.34 v2(137.17,85.67)
  BOTTOM w0.089: RPC8.1 145.36,85.47 145.2,85.63 143.86,85.63 143.49,86 143.49,86.61 v2(143.31,86.79) ; v2(137.17,85.67) 137.17,85.78 UC1.G4
PCH_GPIO7: length 11.8
  IN1 w0.084: v2(143.89,86.79) 143.72,86.96 143.72,87.22 143.46,87.48 140.53,87.48 140.14,87.09 140.14,86.33 139.67,85.86 139.03,85.86 138.74,86.14 138.74,86.74 138.83,86.83 v2(139.4,86.83)
  BOTTOM w0.089: UC1.F1 v2(139.4,86.83) ; RPC8.2 145.36,85.97 145.2,85.82 143.94,85.82 143.68,86.08 143.68,86.57 v2(143.89,86.79)
PCH_GPIO9: length 37.1
  TOP w0.102: RPC7.6 161.97,73.51 161.64,73.84 161.64,74.21 161.98,74.55 161.98,75.61 163.32,76.95 v1(163.32,78.35) 163.32,78.58 v2(162.75,79.16)
  IN3 w0.122: v2(162.75,79.16) 159.85,79.16 158.78,80.22 154.74,80.22 153.51,79 149.56,79 148.36,77.8 148.36,76.19 145.5,73.33 138.97,73.33 v2(137.82,72.18)
  BOTTOM w0.076: UC1.AM3 137.52,72.48 v2(137.82,72.18)
PCH_GPIO10: length 7.2
  TOP w0.089: v2(143.78,72.56) 143.78,72.91 T27.1
  BOTTOM w0.076: v2(143.78,72.56) 142.96,71.75 141.31,71.75 140.99,72.07 140.48,72.07 139.57,72.97 139.13,72.97 139.01,72.85 138.7,72.85 138.4,72.55 UC1.AM2
PCH_GPIO14: length 2.9
  TOP w0.089: T21.1 138.29,74.79 136.46,74.79 v2(136.37,74.88)
  BOTTOM w0.089: UC1.AH4 136.49,74.76 v2(136.37,74.88)
PCH_GPIO16: length 10.6
  TOP w0.089: v2(140.77,79.68) 140.82,79.68 141.32,80.17 v1(144.57,80.17) 145.08,80.17 145.19,80.06 146.46,80.06
  TOP w0.102: 146.46,80.06 148.02,80.06 148.45,80.5 RPC9.5
  BOTTOM w0.076: UC1.Y1 140.39,79.3 v2(140.77,79.68)
PCH_GPIO19: length 11.1
  IN3 w0.089: v2(136.36,79.64) 136.76,80.04 139.25,80.04 140.06,79.23 144.43,79.23 v2(144.68,79.48)
  BOTTOM w0.089: RC66.2 145.29,78.87 v1(145.16,79) v2(144.68,79.48) ; v2(136.36,79.64) 136.18,79.46 UC1.Y5
PCH_GPIO44: length 13.4
  TOP w0.102: RPC10.8 148,76.05 146.49,74.54 143.06,74.54 v2(142.66,74.14)
  BOTTOM w0.076: v2(142.66,74.14) 142.66,74.4 v1(142.38,74.68) 140.88,74.68 140.71,74.51 138.63,74.51 138.46,74.34 137.68,74.34 137.64,74.38 137.16,74.38 UC1.AK4
PCH_GPIO46: length 30.5
  TOP w0.102: v1(164.61,74.69) 162.97,74.69 v2(162.69,74.41) 162.28,74.01 RPC7.5
  IN1 w0.084: v2(162.69,74.41) 161.81,73.54 156.15,73.54 154.78,74.9 148.64,74.9 147.03,73.29 139.7,73.29 v2(137.82,75.18)
  BOTTOM w0.076: v2(137.82,75.18) 137.52,75.48 UC1.AG3
PCH_GPIO49: length 4.9
  TOP w0.089: T22.1 140.58,79.26 v2(140.16,79.68)
  BOTTOM w0.076: UC1.Y3 137.77,79 138.29,79 138.52,79.24 138.52,79.42 138.7,79.59 140.07,79.59 v2(140.16,79.68)
PCH_GPIO52: length 11.6
  TOP w0.089: 146.46,82.96 145.25,82.96 145.13,82.83 144.43,82.83 v2(144.05,83.21) 143.97,83.21 v1(143.61,82.86)
  TOP w0.102: RPC3.6 146.46,82.96
  BOTTOM w0.076: v2(144.05,83.21) 144.05,83.37 143.27,84.15 142.36,84.15 142.16,84.36 140.28,84.36 139.71,83.79 UC1.L1
PCH_GPIO53: length 11.2
  BOTTOM w0.076: UC1.L4 137.21,83.41 137.6,83.41 137.68,83.34 138.46,83.34 138.63,83.5 139.65,83.5 140.34,84.19 142,84.19 142.22,83.98
  BOTTOM w0.089: 146.46,83.09 146.04,82.67 143.89,82.67 143.53,83.02 143.53,83.45 143.14,83.84 v1(142.75,83.84) 142.36,83.84 142.22,83.98
  BOTTOM w0.102: RC140.1 146.46,83.09
PCH_GPIO59: length 33.7
  TOP w0.089: 140.99,66.15 137.68,69.46 v2(136.36,69.46)
  TOP w0.102: RC245.1 161.03,64.63 v1(160.5,64.11) 159.46,63.07 157.13,63.07 155.25,61.19 152.7,61.19 151.9,60.39 143.17,60.39 142.69,60.87 142.69,64.45 140.99,66.15
  BOTTOM w0.089: UC1.AT5 135.92,69.91 v2(136.36,69.46)
PCH_GPIO66: length 16.7
  BOTTOM w0.076: UC1.D3 137.85,87.9 138.46,87.9 138.63,88.07 140.63,88.07 141.29,88.73
  BOTTOM w0.102: 141.29,88.73 143.52,88.73 148.92,94.13 v1(148.92,95.3) RC176.2
PCH_GPIO67: length 23.2
  TOP w0.102: v2(154.55,94.66) v1(154.55,95.3)
  IN4 w0.084: v2(154.55,94.66) 154.52,94.62 146.62,94.62 141.65,89.65 138.16,89.65 137.01,88.51 v2(137.01,88.16)
  BOTTOM w0.089: v2(137.01,88.16) 137.01,88.17 136.87,88.02 UC1.E4
  BOTTOM w0.102: v2(154.55,94.66) 154.94,94.66 RC163.2
PCH_GPIO68: length 15.8
  BOTTOM w0.076: 140.5,89.08 140.15,88.73 138.53,88.73 138.43,88.64 138.05,88.64 137.73,88.96 UC1.C3
  BOTTOM w0.089: 140.5,89.08 143.55,89.08 146.26,91.79
  BOTTOM w0.102: RC164.2 v1(148.05,94.1) 148.05,93.58 146.26,91.79
