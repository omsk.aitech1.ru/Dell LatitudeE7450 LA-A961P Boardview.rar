# Allegro board LAA961PR10-1007A.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+1.05V_MP on BOTTOM (solid shape): 194.69,63.57 194.69,62.09 194.49,61.89 192.88,61.89 192.74,62.03 192.74,62.32 193.18,62.77 193.18,63.67 194.59,63.67
+1.05V_MP on BOTTOM (solid shape): 183.97,68.61 183.97,63.16 184,63.14 184,61.65 183.7,61.34 176.25,61.34 175.29,60.38 173.6,60.38 173.5,60.48 173.5,61.34 173.47,61.37 172.96,61.37 172.95,61.38 172.95,61.83 172.96,61.84 173.48,61.84 173.5,61.85 173.5,62.53 173.46,62.56 172.96,62.56 172.94,62.59 172.94,63 172.99,63.05 173.41,63.05 173.51,63.15 173.51,64.37 174.27,65.13 174.7,65.13 174.94,65.36 175.74,65.36 175.83,65.46 177.45,65.46 177.68,65.69 177.68,66.42 178.21,66.96 179.69,66.96 179.9,67.16 179.9,68.85 180.23,69.18 183.4,69.18
+1.05V_RUN on TOP (solid shape): outline of 222 points within 133.06,100.04 142.86,108.41
+1.05V_RUN on TOP (solid shape): outline of 473 points within 122.56,53.06 129.73,78.6
+1.5V_RUN on BOTTOM (solid shape): 198.92,86.11 198.92,85.8 198.5,85.39 198.09,85.39 197.64,85.84 197.64,87.29 197.66,87.31 197.73,87.31
+1.05V_RUN on BOTTOM (solid shape): 140.05,110.91 140.05,108.34 139.6,107.89 137.49,107.89 137.07,108.32 137.07,110.82 137.2,110.94 137.25,110.96 137.3,110.99 139.98,110.99
+1.05V_RUN on BOTTOM (solid shape): 141.54,100.83 142.59,100.83 142.83,100.59 142.83,99.46 142.48,99.11 140.36,99.11 140.36,99.51 139.93,99.51 139.93,99.11 139.52,99.11 139.45,99.19 139.45,100.01 139.48,100.08 139.55,100.11 139.88,100.38 139.7,100.78 139.69,100.78 139.65,100.82 139.65,101.55 139.7,101.59 140.78,101.59
+1.05V_RUN on BOTTOM (solid shape): outline of 526 points within 126.49,100.08 137.21,115.94
+1.05V_RUN on IN4 (solid shape): 143.77,100.51 143.77,99.04 143.57,98.84 140.31,98.84 139.93,99.23 139.93,100.67 140.01,100.75 143.53,100.75
+1.05V_RUN on VCC: 127.62,74.79 126.92,75.49 125.01,75.49 124.65,75.85 124.65,81.14 125.5,81.14 125.8,81.44 125.8,81.86 125.5,82.16 124.65,82.16 124.65,97.72 132.2,97.72 132.98,98.5 132.98,101.7 145.45,101.7 148.78,98.37 148.78,97.44 135.45,84.11 135.45,79.22 134.83,78.6 129.82,78.6 128.34,77.12 128.34,74.79
+1.05V_RUN_UZ7 on TOP (solid shape): 136.14,100.99 136.14,100.11 136.18,100.07 136.49,100.07 136.58,99.98 136.58,99.22 136.47,99.11 135.71,99.11 135.35,98.75 135.35,98.37 135.19,98.2 133.73,98.2 133.67,98.26 133.67,98.8 134.57,99.7 134.64,99.73 134.72,99.7 134.85,99.61 135.01,99.6 135.37,99.78 135.34,100.18 135.31,100.21 135.31,101.1 135.4,101.18 135.94,101.18
+1.05V_RUN_VMM on TOP (solid shape): 147.8,116.53 147.8,115.65 147.67,115.52 146.21,115.52 145.92,115.81 145.92,116.5 146,116.59 147.74,116.59
+1.05V_RUN_VMM on TOP (solid shape): 161.17,115.43 161.17,114.29 160.85,113.97 159.74,113.97 159.51,114.2 159.51,115.59 159.61,115.69 160.91,115.69
+1.05V_RUN_VMM on BOTTOM (solid shape): 148.47,101.91 148.47,100.63 145.11,97.27 143.05,97.27 142.98,97.32 142.81,97.36 142.73,97.35 141.9,97.35 141.81,97.36 141.73,97.35 140.66,97.35 140.57,97.4 140.48,97.41 140.46,97.41 139.56,98.31 139.56,98.71 139.65,98.81 142.59,98.81 143.03,98.37 143.36,98.37 143.4,98.32 143.4,97.86 143.43,97.83 143.94,97.83 143.97,97.86 143.97,98.22 144.09,98.34 144.29,98.34 144.41,98.46 144.41,101.28 145.26,102.13 148.24,102.13
+1.05V_RUN_VMM on IN2 (solid shape): 147.89,101.4 147.89,100.64 147.64,100.38 146.81,100.38 146.5,100.7 146.5,101.59 146.81,101.91 147.39,101.91
+1.05V_RUN_VMM on IN2 (solid shape): outline of 356 points within 142.77,109.4 146.94,118
+1.05V_RUN_VMM on IN3 (solid shape): 148.18,117.29 148.18,116.5 147.72,116.04 146.03,116.04 145.91,116.16 145.91,116.88 146.49,117.46 148.01,117.46
+1.05V_RUN_VMM on IN3 (solid shape): outline of 125 points within 155.01,114.23 161.06,117.47
+1.05V_VCCST on TOP (solid shape): outline of 1534 points within 121.38,57.08 126.92,78.23
+1.5V_VIN on BOTTOM (solid shape): 197.2,83.03 197.2,83.01 197.3,82.73 197.57,82.63 197.6,82.63 198.25,81.97 198.25,78.73 198.21,78.72 197.93,78.36 198.24,78.02 198.26,78.02 198.33,77.95 198.33,77.35 198.33,77.34 198.3,77.21 198.33,77.07 198.33,77.06 198.33,76.65 198.33,76.64 198.3,76.51 198.33,76.38 198.33,76.37 198.33,75.51 198.1,75.28 197.44,75.28 197.39,75.23 197.39,74.72 197.21,74.72 197.21,75.24 197.17,75.28 196.76,75.28 196.71,75.33 196.71,75.89 197.08,76.25 197.08,80.28 196.84,80.52 194.36,80.52 193.98,80.9 193.98,82.78 194.31,83.11 197.11,83.11
+1.05V_VMM_UV10 on BOTTOM (solid shape): 141.04,105.07 141.04,102.99 141.16,102.86 143.17,102.86 144.27,101.76 144.27,98.67 144.21,98.61 143.2,98.61 143.07,98.73 143.07,100.65 142.76,100.96 141.61,100.96 140.36,102.21 140.36,102.77 140.29,102.84 139.73,102.84 139.63,102.94 139.63,103.69 139.98,104.04 139.98,105.17 140.04,105.24 140.87,105.24
+1.05V_VMM_VDD on TOP (solid shape): outline of 806 points within 150.29,105 160.52,117.03
+1.05V_VMM_VDD on IN2 (solid shape): outline of 1143 points within 149.86,108.3 155.09,116.35
+1.05V_VMM_VDD on IN3 (solid shape): outline of 395 points within 149.25,107 154.43,111.4
+1.05V_VMM_VDDTX on TOP (solid shape): 149.16,116.49 149.16,114.79 149.35,114.6 149.66,114.6 149.82,114.43 149.82,112.96 149.65,112.78 149.38,112.78 149.19,112.97 149.19,113.73 148.95,113.97 148.73,113.97 147.96,114.75 147.96,116.46 148.15,116.65 149,116.65
+1.05V_VMM_VDDTX on TOP (solid shape): 154.03,116.46 154.03,116.08 154.38,115.73 154.38,114.71 154.34,114.62 154.24,114.62 153.88,114.57 153.8,114.21 153.79,114.12 153.71,114.07 153.35,114.07 153.22,114.21 153.22,115.69 153.33,115.8 153.33,116.48 153.38,116.52 153.96,116.52
+1.05V_VMM_VDDTX on IN1 (solid shape): outline of 1296 points within 148.22,108.33 155.18,115.98
+1.05V_VMM_VDDTX on IN4 (solid shape): outline of 877 points within 149.05,108.59 155.11,116.13
+1.8V_RUN_CARD on TOP (solid shape): 19.69,16.67 19.69,16.06 17.23,13.6 15.11,13.6 14.98,13.72 14.98,14.42 15.14,14.58 16.75,14.58 17.45,15.28 17.45,15.95 17.49,15.99 18.07,15.99 18.82,16.74 19.63,16.74
+1.8V_RUN_CARD on BOTTOM (solid shape): 16.31,13.96 16.31,12.23 16.07,11.99 14.96,11.99 14.76,12.2 14.76,14.04 14.9,14.18 16.09,14.18
+1.8V_RUN_CARD on BOTTOM (solid shape): 25.39,12.28 25.39,10.75 25.17,10.53 24.45,10.53 24.12,10.86 24.12,12.34 24.23,12.45 25.22,12.45
+1.8V_RUN_CARD on BOTTOM (solid shape): 3.68,42.71 3.68,40.65 3.59,40.57 2.59,40.57 2.39,40.77 2.39,42.68 2.75,43.03 3.36,43.03
+1.8V_RUN_CARD on BOTTOM (solid shape): 7.47,31.27 7.47,29.73 7.4,29.66 3.69,29.66 3.51,29.84 3.51,31 3.99,31.48 7.25,31.48
+1.8V_RUN_CARD on IN1 (solid shape): 26.19,12.65 26.19,11.59 26.02,11.42 24.02,11.42 23.78,11.66 23.78,12.72 23.97,12.91 25.94,12.91
+1.8V_RUN_CARD on IN1 (solid shape): 28.13,30.15 28.13,28.76 27.78,28.4 26.09,28.4 25.94,28.55 25.94,29.98 26.24,30.28 28.01,30.28
+1.8V_RUN_CARD on IN2 (solid shape): 7.79,31.32 7.79,29.47 7.67,29.35 6.34,29.35 6.14,29.56 6.14,31.18 6.46,31.5 7.61,31.5
+1.8V_RUN_CARD on IN2 (solid shape): 26.77,30.51 26.77,28.78 26.58,28.59 25.57,28.59 25.39,28.77 25.39,29.12 25.11,29.4 24.53,29.4 24.39,29.54 24.39,30.61 24.54,30.76 26.52,30.76
+1.35V_MEM on TOP (solid shape): 131.71,33.74 131.09,33.12 131.09,31.33 131.02,31.26 130.94,31.26 130.94,33.65 131.24,33.95 131.49,33.95
+1.35V_MEM on TOP (solid shape): outline of 14096 points within 76.53,9.68 177.21,76.08
+1.35V_MEM on BOTTOM (solid shape): 118.94,60.37 118.94,58.26 118.13,57.45 106.36,57.45 106.2,57.61 106.2,60.7 106.5,61 118.3,61
+1.35V_MEM on BOTTOM (solid shape): 83.46,25.14 83.52,25.23 83.63,25.22 83.75,25.16 83.88,25.14 83.9,25.14 84.17,24.88 84.15,24.81 84.14,24.76 84.14,23.22 83.56,23.22 83.56,24.76 83.53,24.88 83.46,24.98
+1.35V_MEM on BOTTOM (solid shape): 85.26,25.14 85.32,25.23 85.43,25.22 85.55,25.16 85.68,25.14 85.7,25.14 85.97,24.88 85.96,24.85 85.95,24.81 85.94,24.76 85.94,23.22 85.36,23.22 85.36,24.76 85.33,24.88 85.26,24.98
+1.35V_MEM on BOTTOM (solid shape): 87.44,31.31 87.47,31.19 87.54,31.09 87.54,30.93 87.48,30.84 87.37,30.85 87.25,30.91 87.12,30.93 87.1,30.93 86.83,31.19 86.84,31.22 86.85,31.26 86.86,31.31 86.86,32.72 87.44,32.72
+1.35V_MEM on BOTTOM (solid shape): 87.78,25.23 87.84,25.14 87.84,24.98 87.77,24.88 87.74,24.76 87.74,23.22 87.16,23.22 87.16,24.76 87.15,24.81 87.14,24.85 87.13,24.88 87.4,25.14 87.42,25.14 87.55,25.16 87.67,25.22
+1.35V_MEM on BOTTOM (solid shape): 94.64,31.31 94.67,31.19 94.74,31.09 94.74,30.93 94.68,30.84 94.57,30.85 94.45,30.91 94.32,30.93 94.3,30.93 94.03,31.19 94.05,31.26 94.06,31.31 94.06,32.72 94.64,32.72
+1.35V_MEM on BOTTOM (solid shape): 82.05,31.31 82.09,31.16 82.2,31.04 82.25,31.02 82.32,30.95 82.29,30.85 81.3,29.86 81.21,29.83 81.14,29.9 81.13,29.92 81.1,30 81.05,30.06 81.05,30.33 81.09,30.37 81.11,30.42 81.14,30.51 81.15,30.6 81.14,30.63 81.36,30.84 81.36,31.09 81.43,31.19 81.46,31.31 81.46,32.72 82.05,32.72
+1.35V_MEM on BOTTOM (solid shape): 85.64,31.31 85.67,31.19 85.74,31.09 85.74,29.81 85.68,29.75 85.63,29.8 85.63,29.82 85.58,29.98 85.47,30.11 85.42,30.19 85.47,30.28 85.61,30.69 85.24,30.93 85.22,30.93 85.01,31.14 85.02,31.17 85.05,31.24 85.05,31.31 85.05,32.72 85.64,32.72
+1.35V_MEM on BOTTOM (solid shape): 89.54,26.87 89.62,26.83 89.69,26.76 89.77,26.7 89.83,26.63 89.8,26.54 89.66,26.4 89.66,26.39 89.66,26.38 89.66,25.39 89.8,25.25 89.8,25.13 89.69,25.02 89.69,25.02 89.58,24.91 89.54,24.76 89.54,23.22 88.96,23.22 88.96,24.76 88.93,24.88 88.86,24.98 88.86,26.43 89.1,26.67 89.13,26.67 89.31,26.71 89.45,26.83
+1.35V_MEM on BOTTOM (solid shape): 171.18,31.11 171.25,31.14 171.32,31.11 171.34,31.09 171.34,30.33 171.59,30.08 171.82,30.08 171.89,30.03 171.9,29.95 171.96,29.57 172.31,29.44 172.4,29.41 172.43,29.33 172.43,25.57 172.1,25.23 171.19,25.23 170.83,24.87 170.83,22.99 170.92,22.91 170.92,22.43 170.79,22.3 170.47,22.3 170.34,22.43 170.34,22.92 170.47,23.05 170.47,24.86 170.28,25.05 170.28,25.55 170.44,25.7 170.58,26.01 170.43,26.3 170.39,26.38 170.58,26.76 170.39,27.14 170.43,27.22 170.55,27.38 170.57,27.6 170.97,28 170.97,30.76 171.16,30.96 171.16,31.09
+1.35V_MEM on BOTTOM (solid shape): outline of 82 points within 155.94,25.2 163.6,32.5
+1.35V_MEM on BOTTOM (solid shape): outline of 95 points within 163.41,22.26 169.78,30.85
+1.35V_MEM on BOTTOM (solid shape): outline of 467 points within 79.52,19.28 172.81,46.38
+1.35V_MEM on BOTTOM (solid shape): outline of 231 points within 90.06,23.22 96.47,32.72
+1.35V_MEM on BOTTOM (solid shape): outline of 294 points within 81.05,24.9 90.05,32.72
+1.35V_MEM on IN3 (solid shape): outline of 503 points within 80.92,19.5 127.9,25.84
+1.35V_MEN_P on TOP (solid shape): 82.87,17.17 82.87,15.37 82.46,14.96 81.73,14.96 81.64,15.05 81.64,15.43 81.7,15.5 82.16,15.5 82.21,15.55 82.21,16.54 82.15,16.6 81.68,16.6 81.65,16.63 81.65,16.75 81.68,16.78 82.17,16.78 82.21,16.82 82.21,17.19 82.24,17.21 82.83,17.21
+1.35V_MEN_P on BOTTOM (solid shape): outline of 289 points within 92.38,6.18 114.18,19.7
+3.3V_ALW on TOP (solid shape): 82.43,125.43 82.43,121.36 81.87,120.81 79.75,120.81 79.53,121.02 79.53,125.49 79.78,125.75 82.11,125.75
+3.3V_ALW on TOP (solid shape): 173.25,97.5 173.25,95.64 173.13,95.51 172.68,95.51 171.9,96.29 171.9,97.67 171.99,97.76 173,97.76
+3.3V_ALW on TOP (solid shape): 194.76,44.43 194.76,43.58 194.43,43.25 193.17,43.25 192.9,43.51 192.9,44.57 192.97,44.63 194.55,44.63
+3.3V_ALW on TOP (solid shape): 203.39,36.31 203.39,35.36 203.27,35.23 201.93,35.23 201.87,35.3 201.87,36.19 202.12,36.44 203.27,36.44
+3.3V_ALW on TOP (solid shape): 132.4,96.76 132.4,96.19 132.21,96 131.26,96 131.07,96.19 131.07,96.45 131.19,96.57 131.45,96.57 131.7,96.83 132.34,96.83
+3.3V_ALW on TOP (solid shape): 188.03,89.21 188.03,87.11 187.9,86.99 187.07,86.99 187.01,87.05 187.01,89.34 187.07,89.4 187.84,89.4
+3.3V_ALW on TOP (solid shape): 203.9,33.71 203.9,32.82 203.71,32.63 202.12,32.63 201.87,32.88 201.87,33.77 201.93,33.84 203.77,33.84
+3.3V_ALW on TOP (solid shape): 190.85,44.63 191.44,44.63 191.51,44.57 191.51,43.55 191.37,43.41 190.01,43.41 189.52,43.89 189.52,44.63 189.75,44.86 190.62,44.86
+3.3V_ALW on TOP (solid shape): 196.9,104.02 196.9,102.1 196.44,101.64 195.55,101.64 195.36,101.83 195.36,104.24 195.75,104.63 196.29,104.63
+3.3V_ALW on TOP (solid shape): 194.78,107.7 194.78,107.09 194.72,107.03 192.88,107.03 192.76,107.14 192.76,107.57 192.93,107.74 194.73,107.74
+3.3V_ALW on TOP (solid shape): 9.13,40.16 9.72,40.16 9.9,40.34 12.13,40.34 12.4,40.07 12.4,38.98 12.08,38.66 8.58,38.66 8.33,38.9 8.33,40.39 8.47,40.52 8.77,40.52
+3.3V_ALW on TOP (solid shape): 194.77,110.25 194.77,109.14 194.7,109.07 194.07,109.07 193.53,109.61 192.92,109.61 192.79,109.74 192.79,110.41 192.87,110.49 194.52,110.49
+3.3V_ALW on TOP (solid shape): 216.61,83.51 216.61,82.39 216.63,82.38 216.63,82.12 216.51,82.01 214.73,82.01 214.6,81.88 214.57,81.85 214.54,81.82 214.14,81.41 213.59,81.41 213.51,81.49 213.51,83.16 213.89,83.54 216.58,83.54
+3.3V_ALW on TOP (solid shape): 175.56,106.14 175.56,105.36 174.88,104.68 174.88,103.95 174.79,103.86 174.33,103.86 174.3,103.89 174.3,104.4 174.27,104.43 173.82,104.43 173.8,104.41 173.8,103.93 173.75,103.87 173.51,103.87 173.2,104.19 173.2,105.98 173.46,106.24 175.46,106.24
+3.3V_ALW on TOP (solid shape): 60.11,63.26 60.11,61.75 59.62,61.26 59.22,61.26 58.96,61.52 58.83,61.52 58.81,61.52 58.67,61.5 58.55,61.43 57.67,61.43 57.6,61.5 57.6,62.04 57.71,62.14 58.17,62.14 59.43,63.4 59.97,63.4
+3.3V_ALW on TOP (solid shape): 182.57,84.93 182.57,82.62 182.27,82.32 182.27,81.75 182.19,81.67 181.51,81.67 181.41,81.77 181.41,82.29 181.45,82.3 181.64,82.82 181.1,82.92 181.07,82.9 181.04,82.92 180.55,83.41 180.55,85.01 180.72,85.18 182.32,85.18
+3.3V_ALW on TOP (solid shape): outline of 201 points within 33.53,28.83 42.01,37.23
+3.3V_ALW on BOTTOM (solid shape): 205.56,16.31 205.56,14.9 205.41,14.75 204.54,14.75 204.45,14.84 204.45,16.39 204.51,16.45 205.43,16.45
+3.3V_ALW on BOTTOM (solid shape): 193.41,67.57 193.41,66.45 193.33,66.37 192.56,66.37 192.36,66.58 192.36,66.96 192.23,67.08 190.52,67.08 190.48,67.12 190.48,67.3 190.52,67.34 192.19,67.34 192.47,67.62 193.36,67.62
+3.3V_ALW on BOTTOM (solid shape): outline of 419 points within 212.93,87.11 217.05,95.04
+3.3V_ALW on IN1 (solid shape): 12.32,39.3 12.32,37.39 11.05,36.12 9.15,36.12 9.02,36.25 9.02,36.63 9.21,36.82 10.35,36.82 10.54,37.01 10.54,39.17 10.86,39.49 12.13,39.49
+3.3V_ALW on IN4 (solid shape): outline of 4042 points within 48.94,44.96 81.88,85.7
+3.3V_ALW on VCC: outline of 84 points within 29.81,22.28 214.06,139.58
+3.3V_ALW2 on TOP (solid shape): 48,29.07 48,27.93 47.84,27.78 47.18,27.78 46.84,27.44 46.84,26.13 46.78,26.06 46.7,26.06 46.64,26.13 46.64,27.52 46.4,27.77 46.1,27.77 45.95,27.92 45.95,29.05 46.03,29.12 47.95,29.12
+3.3V_ALW_PCH on TOP (solid shape): 137.43,57.12 137.43,56.41 136.82,55.8 136.22,55.8 134.55,57.48 134.55,58.16 135.25,58.85 135.69,58.85
+3.3V_ALW_PCH on TOP (solid shape): 221.08,98.23 221.08,97.54 220.93,97.39 219.76,97.39 219.64,97.51 219.64,98.16 219.85,98.38 220.93,98.38
+3.3V_ALW_PCH on TOP (solid shape): 150.43,77.59 150.43,77.07 150.94,76.56 150.94,76.13 150.75,75.94 149.67,75.94 149.55,76.06 149.55,77.65 149.57,77.68 150.35,77.68
+3.3V_ALW_PCH on TOP (solid shape): 153.23,77.65 153.23,77.03 153.86,76.4 153.86,76.08 153.71,75.94 152.59,75.94 152.47,76.06 152.47,77.59 152.59,77.71 153.16,77.71
+3.3V_ALW_PCH on TOP (solid shape): 179.11,56.17 179.11,55.35 179.09,55.34 178.59,55.34 178.56,55.31 178.56,54.89 178.59,54.87 179.11,54.87 179.11,54.15 179.01,54.05 177.27,54.05 177.07,54.26 177.07,55.93 177.46,56.33 178.95,56.33
+3.3V_ALW_PCH on TOP (solid shape): 133.51,94.84 133.51,94.26 133.67,94.1 134.69,94.1 134.88,93.91 134.88,93.59 134.75,93.46 134.44,93.46 134.34,93.48 134.25,93.46 133.49,93.46 133.39,93.48 133.26,93.46 132.91,93.81 132.91,94.76 133.07,94.92 133.43,94.92
+3.3V_ALW_PCH on TOP (solid shape): 132.28,60.71 132.28,59.65 132.09,59.46 129.72,59.46 129.48,59.7 129.48,60.54 129.54,60.6 129.59,60.56 129.59,60.55 129.97,60.32 130.24,60.68 130.26,60.75 130.34,60.79 132.2,60.79
+3.3V_ALW_PCH on TOP (solid shape): 164.88,74.11 164.88,66.54 164.66,66.31 164.56,66.31 164.55,66.32 164.33,66.39 164.12,66.31 164.04,66.31 163.59,65.86 162.88,65.86 162.66,65.65 162.66,65.37 162.56,65.27 161.16,65.27 161.07,65.36 161.07,66.11 161.27,66.32 162.43,66.32 162.95,66.84 162.95,70.88 162.66,71.17 162.47,71.17 162.41,71.19 162.36,71.2 162.32,71.2 162.31,71.21 162.23,71.24 162.15,71.25 161.58,71.25 161.5,71.34 161.5,71.75 161.93,72.18 162.45,72.18 162.77,72.5 162.77,73.99 163,74.24 163.03,74.32 163.04,74.36 164.64,74.36
+3.3V_ALW_PCH on IN2 (solid shape): 150.99,95.31 150.99,94.75 150.62,94.38 148.43,94.38 148.2,94.61 148.2,95.28 148.44,95.53 150.78,95.53
+3.3V_ALW_PCH on IN3 (solid shape): 150.93,95.26 150.93,94.45 150.81,94.32 148.55,94.32 148.44,94.43 148.44,95.24 148.61,95.41 150.79,95.41
+3.3V_ALW_PCH on IN3 (solid shape): outline of 210 points within 132.03,91.31 135.3,95.49
+3.3V_ALW_PCH on IN3 (solid shape): outline of 738 points within 150.47,69.8 163.74,78.19
+3.3V_ALW_PCH_UZ7 on TOP (solid shape): 134.83,96.36 135.07,96.36 135.22,96.31 135.37,96.36 135.82,96.36 135.94,96.47 136.47,96.47 136.51,96.43 136.51,95.82 136.4,95.71 136.08,95.71 135.87,95.78 135.66,95.71 135.33,95.71 135.08,95.46 135.08,94.7 134.72,94.34 134.56,94.34 134.52,94.38 134.52,94.82 134.48,94.86 134.01,94.86 133.97,94.82 133.97,94.4 133.92,94.35 133.77,94.35 133.67,94.45 133.67,95.21 133.75,95.43 133.67,95.65 133.67,96.78 133.71,96.82 134.38,96.82
+3.3V_ALW_UE1 on TOP (solid shape): 173.43,103.72 174.62,103.72 174.68,103.66 174.68,102.98 174.55,102.85 173.1,102.85 172.58,103.37 172.01,103.37 171.88,103.51 171.88,104.08 172.02,104.22 172.93,104.22
+3.3V_ALW_UE1 on BOTTOM (solid shape): outline of 545 points within 173.46,94.54 189.49,108.46
+3.3V_ALW_UE2 on TOP (solid shape): 213.18,93.63 213.36,93.63 213.46,93.52 213.46,92.68 213.28,92.5 212.68,92.5 212.44,92.74 212.44,93.4 212.79,93.75 213.05,93.75
+3.3V_ALW_UE2 on TOP (solid shape): 199.66,98.1 199.66,97.3 199.46,97.1 199.05,97.1 198.68,97.47 197.91,97.47 197.86,97.51 197.86,98.17 197.95,98.26 199.5,98.26
+3.3V_ALW_UE2 on TOP (solid shape): 216.6,84.51 216.6,83.87 216.54,83.81 215.71,83.81 215.27,84.26 213.93,84.26 213.81,84.38 213.81,84.7 214.05,84.81 214.15,85.06 214.37,85.27 215.84,85.27
+3.3V_ALW_UE2 on TOP (solid shape): 204.65,99.67 204.65,99.32 204.83,99.15 204.83,99.04 204.99,99.04 205.19,98.84 205.19,98.39 205.02,98.22 205.02,97.17 204.92,97.07 204.8,97.07 204.71,97.16 204.71,97.2 204.75,97.26 204.78,97.31 204.79,97.38 204.8,97.45 204.8,97.99 204.41,98.38 204.41,98.7 204.31,98.8 204.31,98.91 204.09,99.12 204.09,99.7 204.62,99.7
+3.3V_ALW_UE2 on IN2 (solid shape): outline of 413 points within 212.05,83.84 216.04,93.25
+3.3V_ALW_UE2 on IN3 (solid shape): outline of 155 points within 209.3,88.13 214.7,89.97
+3.3V_ALW_UE2 on IN3 (solid shape): outline of 274 points within 198.18,97.79 205.3,100.93
+3.3V_ALWP on TOP (solid shape): 35.59,29.33 35.59,28.81 35.61,28.78 36.3,28.78 36.32,28.81 36.32,29.33 36.34,29.34 36.78,29.34 36.79,29.33 36.79,28.81 36.82,28.78 37.53,28.78 37.71,28.6 37.71,26.63 37.1,26.01 34.38,26.01 34.1,26.29 34.1,26.84 34.11,26.85 34.11,28.53 34.38,28.79 35.08,28.79 35.13,28.85 35.13,29.31 35.16,29.34 35.58,29.34
+3.3V_ALWP on BOTTOM (solid shape): 38.53,29.55 38.53,26.36 37.33,25.16 37.33,20.31 37.15,20.13 35.49,20.13 35.46,20.11 34.29,20.11 33.81,20.59 33.81,29.28 34.23,29.69 38.39,29.69
+3.3V_CAM on TOP (solid shape): 105.54,119.75 105.54,119.31 105.01,118.77 102.4,118.77 101.69,118.06 101.69,117.14 101.58,117.02 101.36,117.02 100.94,117.44 100.94,118.88 102.14,120.07 105.22,120.07
+3.3V_HDD on TOP (solid shape): 220.35,110.48 220.35,108.49 220.06,108.19 218.19,108.19 218.06,108.32 216.16,108.32 216.03,108.45 216.03,109.02 216.16,109.15 217.74,109.15 219.2,110.61 220.22,110.61
+3.3V_HDD on TOP (solid shape): 201.4,107.64 201.83,107.64 201.83,108.17 202.1,108.17 202.14,108.13 202.14,105.92 201.2,104.98 199.39,104.98 199.23,105.15 199.23,106.24 199.37,106.38 200.38,106.38 200.6,106.59 200.6,107.81 200.95,108.17 201.4,108.17
+3.3V_HDD on BOTTOM (solid shape): 219.8,112.16 219.8,110.95 220.37,110.38 220.37,109.57 220.03,109.22 219.5,109.22 219.41,109.31 219.41,109.92 219.04,110.29 219.04,112.14 219.12,112.22 219.74,112.22
+3.3V_HDD on IN4 (solid shape): 202.38,105.96 202.38,105.62 202,105.24 200.76,105.24 200.37,105.63 200.37,106.2 200.47,106.3 202.03,106.3
+3.3V_HDD on IN4 (solid shape): 220.4,110.4 220.4,108.44 220.23,108.26 218.42,108.26 218.08,108.6 218.08,109.65 218.34,109.9 218.35,109.91 218.52,110 218.61,110.17 218.61,110.18 219.08,110.65 220.16,110.65
+3.3V_HDD_UL3 on TOP (solid shape): 198.21,106.44 198.53,106.12 198.53,105.13 198.48,105.09 197.04,105.09 196.54,105.59 196.54,105.91 196.01,106.43 196.01,107.64 196.08,107.7 196.95,107.7
+3.3V_LAN on TOP (solid shape): 197.36,113.21 197.36,111.88 197.23,111.75 196.73,111.75 196.66,111.81 196.66,112.13 196.6,112.2 196.09,112.2 196.03,112.13 196.03,111.81 195.9,111.69 195.58,111.69 195.46,111.81 195.46,113.08 195.77,113.4 197.17,113.4
+3.3V_LAN on TOP (solid shape): 205.41,109.44 205.41,108.91 205.39,108.88 205.39,108.41 205.29,108.31 205.29,107.41 205.51,107.19 205.9,107.19 206.04,107.06 206.04,106.53 205.55,106.05 204.08,106.05 203.94,106.19 203.94,109.41 204,109.48 205.37,109.48
+3.3V_LAN on TOP (solid shape): 207.94,122.06 207.94,120.86 208.1,120.69 209.45,120.69 209.55,120.59 209.55,120.15 209.41,120.01 207.81,120.01 206.81,121 205.5,121 205.46,121.05 205.46,122.06 205.59,122.19 207.81,122.19
+3.3V_LAN on BOTTOM (solid shape): 213.8,121.83 213.8,120.54 212.63,120.54 212.63,121.25 213.32,121.95 213.68,121.95
+3.3V_LAN on BOTTOM (solid shape): 222.81,125.99 222.81,125.72 222.46,125.37 222.46,124.76 222.39,124.69 221.96,124.69 221.91,124.74 221.91,125.5 221.73,125.68 221.73,125.97 221.85,126.09 222.71,126.09
+3.3V_LAN on IN2 (solid shape): 220.74,121.93 220.74,121.27 220.33,120.85 218.43,120.85 218.14,121.15 218.14,121.92 218.38,122.16 218.8,122.16 219.01,122.38 220.29,122.38
+3.3V_LAN on IN3 (solid shape): 258.18,126.8 258.18,126.38 256.68,124.88 255.64,124.88 255.48,125.05 255.48,125.71 256.92,127.16 257.83,127.16
+3.3V_LAN on IN3 (solid shape): outline of 742 points within 206.55,121.43 222.95,128.61
+3.3V_LAN on IN4 (solid shape): 205.43,108.96 205.43,108.5 205.41,108.45 205.39,108.39 205.15,108.15 204.39,108.15 202.57,109.97 202.46,110.24 202.19,110.35 201.11,111.43 196.34,111.43 196.09,111.69 196.09,112.77 196.28,112.96 201.43,112.96
+3.3V_LAN_OUT on IN2 (solid shape): outline of 414 points within 207.13,112.95 212.49,117.44
+3.3V_LAN_UL3 on TOP (solid shape): 197.86,110.68 198.46,110.68 198.51,110.62 198.51,110.03 197.88,109.4 197.87,109.4 197.55,109.08 196.08,109.08 196.02,109.14 196.02,110.69 195.72,110.99 195.72,111.36 195.79,111.42 197.12,111.42
+3.3V_M on TOP (solid shape): 134.71,79.67 134.71,78.53 134.6,78.42 133.15,78.42 132.98,78.59 132.98,79.58 133.04,79.63 133.75,79.63 133.97,79.86 134.52,79.86
+3.3V_M on TOP (solid shape): 184.26,48.94 184.26,47.22 183.47,46.43 183.12,46.43 181.99,47.56 181.99,49.34 182.18,49.53 183.68,49.53
+3.3V_M on TOP (solid shape): 200.6,39.61 200.6,38.73 195.6,38.73 195.28,39.04 195.28,39.44 195.58,39.74 200.47,39.74
+3.3V_M on TOP (solid shape): 174.72,66.98 174.72,65.54 174.56,65.38 173.78,65.38 173.59,65.57 173.59,65.92 173.89,66.22 173.89,66.55 173.89,66.56 173.92,66.72 173.89,66.88 173.89,66.92 174.04,67.07 174.63,67.07
+3.3V_M on TOP (solid shape): 177.54,57.59 176.96,57.59 176.96,57.08 177.54,57.08 177.54,56.82 177.22,56.82 177.03,56.63 177.03,56.2 176.82,56 176.82,54.75 176.71,54.64 175,54.64 174.73,54.91 174.73,57.59 174.98,57.84 177.54,57.84
+3.3V_M on BOTTOM (solid shape): 174.21,67.67 174.21,66.56 174.56,66.21 174.56,65.45 174.5,65.38 173.69,65.38 173.55,65.52 173.55,67.69 173.66,67.81 173.66,67.83 174.04,67.83
+3.3V_M on IN2 (solid shape): 176.8,56.94 176.8,55.86 176.7,55.76 174.82,55.76 174.67,55.91 174.67,57.01 174.83,57.18 176.56,57.18
+3.3V_M on IN2 (solid shape): 174.75,65.9 174.75,65.28 174.89,65.14 174.89,64.46 174.82,64.38 173.74,64.38 173.6,64.52 173.6,65.97 173.7,66.07 174.59,66.07
+3.3V_M on IN2 (solid shape): outline of 1226 points within 134.05,66.34 144.05,80.4
+3.3V_M on IN3 (solid shape): 143.97,67.1 143.97,66.02 143.84,65.89 141.92,65.89 141.66,66.16 141.66,67.06 141.84,67.25 143.82,67.25
+3.3V_M on IN3 (solid shape): 174.73,66.81 174.73,65.55 174.56,65.38 173.7,65.38 173.54,65.55 173.54,66.86 173.71,67.03 174.5,67.03
+3.3V_M on IN4 (solid shape): 184.28,49.23 184.28,48.68 184.04,48.43 183.52,48.43 182.15,49.81 182.15,49.97 182.48,50.3 183.22,50.3
+3.3V_M on IN4 (solid shape): 177.95,55.61 177.95,55.31 177.46,54.83 177.14,54.83 175.65,56.31 175.65,56.66 175.88,56.88 176.67,56.88
+3.3V_M_TPM on TOP (solid shape): 186.58,60.02 186.58,55.01 186.36,54.79 183.61,54.79 183.37,55.03 183.37,60.19 183.58,60.4 186.2,60.4
+3.3V_M_TPM on TOP (solid shape): 178.73,57.41 180.38,57.41 180.49,57.29 180.49,55.93 180.63,55.79 180.85,55.79 180.88,55.77 180.88,55.27 180.83,55.22 180.23,55.22 179.92,54.92 179.92,54.65 179.86,54.59 179.31,54.59 179.25,54.65 179.25,54.99 179.22,55.02 178.72,55.02 178.7,55.03 178.7,55.18 178.72,55.2 179.25,55.2 179.26,55.21 179.26,56.25 179.03,56.48 177.75,56.48 177.7,56.53 177.7,57.22 177.69,57.23 177.13,57.23 177.12,57.24 177.12,57.41 177.14,57.43 177.65,57.43 177.69,57.47 177.69,57.81 177.71,57.84 178.3,57.84
+3.3V_M_UZ8 on TOP (solid shape): 200.73,37.93 200.73,36 200.6,35.87 200.6,35.3 200.54,35.23 199.58,35.23 199.33,35.49 199.33,38.01 199.37,38.05 200.6,38.05
+3.3V_MMI on TOP (solid shape): 20.69,13.24 20.69,12.5 20.81,12.39 21.12,12.39 21.21,12.3 21.21,10.33 21.26,10.28 21.76,10.28 21.78,10.25 21.78,10.1 21.76,10.07 21.25,10.07 21.21,10.04 21.21,9.67 21.1,9.55 20.2,9.55 19.9,9.85 19.9,10.68 20.02,10.8 20.02,12.18 19.69,12.51 19.69,13.31 19.76,13.39 20.54,13.39
+3.3V_MMI on IN3 (solid shape): outline of 812 points within 14.47,9.16 31.12,25.91
+3.3V_RUN on TOP (solid shape): 150.92,83.39 150.92,82.01 150.74,81.83 149.68,81.83 149.66,81.85 149.66,83.56 149.75,83.64 150.66,83.64
+3.3V_RUN on TOP (solid shape): 150.98,80.73 150.98,79.34 150.47,78.83 149.83,78.83 149.61,79.06 149.61,80.55 149.8,80.74 150.97,80.74
+3.3V_RUN on TOP (solid shape): 31.28,12.25 31.28,11.14 29.71,9.57 22.01,9.57 21.92,9.66 21.92,10.75 22.06,10.89 28.5,10.89 30.09,12.47 31.05,12.47
+3.3V_RUN on TOP (solid shape): 222.33,85.71 222.33,84.92 223.06,84.19 223.06,82.91 222.95,82.81 221.99,82.81 221.59,83.21 221.59,85.71 221.67,85.79 222.25,85.79
+3.3V_RUN on TOP (solid shape): 222.04,119.1 222.04,117.44 221.96,117.36 221.16,117.36 220.72,117.8 220.23,117.8 220.06,117.98 220.06,118.98 220.37,119.29 221.84,119.29
+3.3V_RUN on TOP (solid shape): 118.99,121.68 119.66,121.01 120.77,121.01 120.84,120.93 120.84,120.01 120.77,119.93 119.5,119.93 118.29,121.14 118.29,121.98 118.25,122.02 118.25,122.49 118.33,122.57 118.99,122.57
+3.3V_RUN on TOP (solid shape): 195.49,106.66 195.49,105.64 195.37,105.51 194.59,105.51 194.53,105.58 194.53,106.28 194.41,106.39 194.17,106.39 194.07,106.49 194.07,106.82 194.12,106.87 195.28,106.87
+3.3V_RUN on TOP (solid shape): 197.32,74.83 197.32,73.04 196.81,73.02 196.78,72.98 196.78,72.26 196.71,72.2 196.03,72.2 195.95,72.28 195.95,74.9 196.1,75.05 197.11,75.05
+3.3V_RUN on TOP (solid shape): 201.72,61.26 201.72,60.18 201.45,59.91 201.11,59.91 201.09,59.92 201.09,60.46 201.08,60.47 200.64,60.47 200.61,60.44 200.61,59.93 200.57,59.9 199.51,59.9 199.38,60.02 199.38,61.47 199.52,61.61 201.36,61.61
+3.3V_RUN on TOP (solid shape): 202.95,109.16 202.95,108.35 202.8,108.19 202.3,108.19 202.16,108.33 201.72,108.33 201.7,108.32 201.7,107.78 201.55,107.78 201.53,107.8 201.53,108.31 201.5,108.33 201.12,108.33 200.87,108.59 200.87,109.21 200.99,109.34 202.77,109.34
+3.3V_RUN on TOP (solid shape): 182.11,90.54 182.11,86.78 181.06,85.73 179.61,85.73 179.35,85.99 179.35,86.78 179.72,87.15 179.72,87.76 179.97,88 179.97,88.68 179.97,88.68 179.97,89.59 179.7,89.86 179.7,90.22 179.27,90.65 179.27,90.76 179.39,90.88 181.77,90.88
+3.3V_RUN on TOP (solid shape): 146.74,99.84 146.74,96.26 146.51,96.03 144.33,96.03 144.23,96.14 144.23,96.73 145.04,97.54 145.04,98.7 144.89,98.85 143.21,98.85 142.42,98.06 140.52,98.06 140.12,97.66 140.12,96.24 139.97,96.09 138.27,96.09 138.14,96.22 138.14,97.1 138.9,97.1 138.9,97.05 138.91,97 138.92,96.95 138.94,96.9 138.97,96.86 139.01,96.82 139.05,96.78 139.1,96.76 139.15,96.74 139.2,96.72 139.25,96.72 139.31,96.72 139.36,96.74 139.41,96.76 139.45,96.78 139.5,96.82 139.53,96.86 139.56,96.9 139.59,96.95 139.6,97 139.61,97.05 139.61,97.1 139.6,97.16 139.59,97.21 139.56,97.26 139.53,97.3 139.5,97.34 139.45,97.37 139.41,97.4 139.36,97.42 139.31,97.43 139.25,97.43 139.2,97.43 139.15,97.42 139.1,97.4 139.05,97.37 139.01,97.34 138.97,97.3 138.94,97.26 138.92,97.21 138.91,97.16 138.9,97.1 138.14,97.1 138.14,97.29 137.55,97.88 137.55,99.61 137.82,99.89 142.84,99.89 143.03,100.07 146.51,100.07
+3.3V_RUN on TOP (solid shape): outline of 98 points within 130.98,79.11 134.81,81.35
+3.3V_RUN on TOP (solid shape): outline of 180 points within 55.13,61.14 68.66,67.67
+3.3V_RUN on TOP (solid shape): outline of 273 points within 152.49,78.71 160.12,95.2
+3.3V_RUN on BOTTOM (solid shape): 149.05,98.32 149.08,98.33 149.26,98.14 149.26,97.39 149.15,97.28 146.96,97.28 146.76,97.07 146.73,97.07 146.73,97.04 146.41,96.72 146.12,96.72 145.68,97.16 145.68,97.58 146.53,98.43 148.95,98.43
+3.3V_RUN on BOTTOM (solid shape): 198.02,75 198.02,74.58 197.61,74.17 197.61,73.52 197.49,73.4 194.95,73.4 194.82,73.52 194.82,74.29 195.07,74.54 195.8,74.54 196.38,75.12 197.03,75.12 197.06,75.1 197.06,74.6 197.09,74.57 197.5,74.57 197.54,74.6 197.54,75.09 197.59,75.14 197.88,75.14
+3.3V_RUN on BOTTOM (solid shape): 138.27,101.51 138.27,100.81 138.2,100.78 138.17,100.76 138.03,100.37 138.36,100.11 138.38,100.11 138.49,100 138.84,100 139.2,99.63 139.2,99.34 138.94,99.08 137.92,99.08 137.62,99.37 137.62,99.99 137.62,99.99 137.62,100.06 137.36,100.32 137.36,101.12 137.37,101.12 137.37,101.41 137.56,101.6 138.18,101.6
+3.3V_RUN on BOTTOM (solid shape): 147.25,88.81 147.35,88.16 147.56,87.53 148.99,85.79 151.12,85.1 151.14,85.09 151.42,84.82 152.84,84.82 153.76,83.9 153.76,78.08 152.02,78.08 152.01,78.07 147.12,78.07 146.71,78.48 146.71,82.05 147.01,82.34 147.01,83.58 146.41,84.18 146.41,87.05 145.71,87.75 145.71,88.51 146.01,88.81
+3.3V_RUN on BOTTOM (solid shape): 139.32,112.07 139.32,111.37 139.13,111.18 137.82,111.18 137.68,111.87 137.55,111.18 137.19,111.18 137.16,111.18 136.72,111.18 136.53,110.99 136.53,109.4 136.08,108.96 135.13,108.96 135.07,109.02 135.07,109.46 135,109.53 134.56,109.53 134.5,109.46 134.5,109.02 134.43,108.96 134.18,108.96 133.99,109.15 133.99,112.2 134.43,112.64 138.75,112.64
+3.3V_RUN on BOTTOM (solid shape): outline of 275 points within 220.86,75.53 230.33,90.47
+3.3V_RUN on IN1 (solid shape): outline of 205 points within 134.05,80.18 137.36,81.97
+3.3V_RUN on IN2 (solid shape): 197.37,74.92 197.37,73.33 197.22,73.18 196.19,73.18 196.19,74.83 196.41,75.05 197.25,75.05
+3.3V_RUN on IN2 (solid shape): 200.34,62.17 200.34,60.18 200.19,60.03 199.33,60.03 198.99,60.38 198.99,62.12 199.33,62.46 200.05,62.46
+3.3V_RUN on IN2 (solid shape): 125.99,126.56 125.99,126.41 127.45,124.95 127.45,124.67 127.24,124.46 125.91,124.46 125.14,123.69 124.49,123.69 123.5,124.69 123.5,124.99 125.5,124.99 125.5,124.93 125.51,124.88 125.53,124.83 125.55,124.78 125.58,124.74 125.62,124.7 125.66,124.66 125.7,124.64 125.75,124.62 125.81,124.61 125.86,124.6 125.91,124.61 125.96,124.62 126.01,124.64 126.06,124.66 126.1,124.7 126.14,124.74 126.17,124.78 126.19,124.83 126.21,124.88 126.22,124.93 126.22,124.99 126.21,125.04 126.19,125.09 126.17,125.14 126.14,125.18 126.1,125.22 126.06,125.25 126.01,125.28 125.96,125.3 125.91,125.31 125.86,125.32 125.81,125.31 125.75,125.3 125.7,125.28 125.66,125.25 125.62,125.22 125.58,125.18 125.55,125.14 125.53,125.09 125.51,125.04 125.5,124.99 123.5,124.99 123.5,127.59 123.67,127.76 124.78,127.76
+3.3V_RUN on IN2 (solid shape): outline of 465 points within 217.68,77.77 221.43,88.7
+3.3V_RUN on IN2 (solid shape): outline of 773 points within 136.94,96.39 146.99,112.45
+3.3V_RUN on IN3 (solid shape): 31.25,13.27 31.25,12.02 31.14,11.91 30.19,11.91 29.97,12.13 29.97,13.31 30.2,13.54 30.98,13.54
+3.3V_RUN on IN3 (solid shape): 78.53,62.13 78.53,59.74 77.65,58.87 70.17,58.87 66.12,62.92 66.12,64.58 66.59,65.05 75.61,65.05
+3.3V_RUN on IN3 (solid shape): 166.56,115.01 166.56,113.95 166.39,113.77 165.07,113.77 164.66,114.18 164.66,114.65 165.16,115.15 166.43,115.15
+3.3V_RUN on IN3 (solid shape): 201.74,61.08 201.74,59.81 201.55,59.62 199.58,59.62 199.27,59.93 199.27,61.08 199.65,61.46 201.36,61.46
+3.3V_RUN on IN3 (solid shape): 225.65,77.35 225.65,75.52 225.4,75.28 224.51,75.28 224.37,75.42 224.37,77.36 224.56,77.55 225.44,77.55
+3.3V_RUN on IN3 (solid shape): 203.93,108.96 203.93,108.55 203.48,108.11 201.07,108.11 200.8,108.37 200.8,109.02 200.98,109.2 202.68,109.2 202.9,109.41 203.47,109.41
+3.3V_RUN on IN3 (solid shape): 61.47,40.81 61.48,40.81 61.86,40.43 61.86,39.39 61.55,39.08 60.84,39.08 60.29,39.63 60.29,40.62 60.74,41.07 61.21,41.07
+3.3V_RUN on IN3 (solid shape): outline of 123 points within 191.34,106.14 196.83,109.39
+3.3V_RUN on IN3 (solid shape): outline of 147 points within 212.14,109.36 221.07,114.27
+3.3V_RUN on IN3 (solid shape): 135.2,120.05 135.29,120.01 135.29,119.91 135.61,119.4 135.93,119.91 135.94,120.01 136.02,120.05 137.02,120.05 137.17,119.91 137.16,119.88 137.14,119.76 137.15,119.65 137.2,119.55 137.27,119.48 137.27,118.91 137.11,118.75 134.98,118.75 134.38,118.16 129.44,118.16 129.22,118.37 128.63,118.37 128.23,117.97 125.8,117.97 125.61,118.15 125.61,119.14 125.85,119.38 128.55,119.38 128.73,119.38 128.82,119.33 128.82,119.23 128.79,119.16 128.78,119.09 128.92,118.78 129.26,118.73 129.44,118.88 129.49,119.12 129.48,119.15 129.71,119.38 129.83,119.38 129.92,119.33 129.92,119.23 130.23,118.7 130.54,119.23 130.55,119.33 130.63,119.38 132.79,119.38 132.85,119.44 132.88,119.44 132.96,119.4 132.98,119.31 133.17,118.89 133.61,119.01 133.67,119.3 133.49,119.53 133.41,119.56 133.32,119.57 133.23,119.63 133.25,119.74 133.56,120.05
+3.3V_RUN on IN3 (solid shape): outline of 429 points within 166.72,73.3 197.51,79.05
+3.3V_RUN on IN4 (solid shape): 138.56,112.7 138.56,112.07 138.54,112.05 138.54,111.42 138.43,111.31 138.01,111.31 137.98,111.32 137.94,111.75 137.51,111.82 137.47,111.86 137.47,112.93 137.62,113.08 138.18,113.08
+3.3V_RUN on IN4 (solid shape): outline of 278 points within 124.45,112.03 127.23,125.07
+3.3V_RUN on VCC: 57.26,35.42 56.84,35.85 56.84,43 77.41,63.58 77.41,71.07 90.62,84.28 90.62,103.46 90.34,103.74 90.34,106.84 92.35,108.86 92.97,108.86 99.23,115.12 164.68,115.12 166.12,113.68 166.12,109.74 167.71,108.15 167.71,97.06 166.56,95.92 166.56,94.18 167.71,93.04 167.71,70.67 159.39,70.67 158.99,71.06 158.99,72.71 161.23,74.94 161.23,77.44 159.45,79.22 159.45,101.89 157.14,104.19 151.76,104.19 146.55,109.4 114.03,109.4 113.9,109.53 111.34,109.53 108.42,106.61 102.83,106.61 101.05,104.83 99.21,104.83 98.3,103.92 98.3,91.45 101.16,88.59 101.16,76.38 93.31,76.38 89.92,72.99 89.92,68.99 86.11,65.18 86.11,37.5 84.03,35.42 ; 1 cut-out
+3.3V_RUN_AUDIO on TOP (solid shape): 215.33,77.69 215.33,76.89 215.2,76.76 214.32,76.76 214.19,76.89 214.19,77.59 214.09,77.68 214.09,78 214.25,78.16 214.86,78.16
+3.3V_RUN_AUDIO on TOP (solid shape): 202.61,73.6 202.61,72.34 202.46,72.19 201.54,72.19 201.49,72.24 201.49,72.63 201.36,72.76 201.36,73.96 201.4,74 202.22,74
+3.3V_RUN_AUDIO on TOP (solid shape): 198.57,74.7 198.57,72.47 198.27,72.17 197.76,72.17 197.69,72.1 197.55,72.1 197.5,72.15 197.5,72.65 197.5,72.88 197.5,73.39 197.5,74.34 197.5,74.88 197.6,74.98 198.29,74.98
+3.3V_RUN_AUDIO on IN1 (solid shape): 202.97,72.99 202.97,68.22 203.22,67.98 203.22,66.22 203.78,65.66 203.78,64.2 202.71,63.15 204.2,63.2 205.08,62.32 204.6,61.84 203.49,61.84 203.11,62.21 203.05,62.21 202.01,63.25 202.01,66.49 202.05,66.58 202.14,66.59 202.6,66.93 202.14,67.27 202.05,67.29 202.01,67.37 202.01,72.11 202.01,73.13 202.2,73.32 202.65,73.32
+3.3V_RUN_AUDIO on IN2 (solid shape): 199.88,79.04 200.12,79.04 200.32,78.84 200.32,74.3 200.14,74.12 200.14,73.07 199.2,72.13 198.06,72.13 197.81,72.38 197.81,73.31 198.78,73.31 198.78,73.25 198.8,73.2 198.81,73.15 198.84,73.11 198.87,73.07 198.91,73.03 198.96,73 199.01,72.98 199.06,72.96 199.11,72.95 199.16,72.95 199.22,72.96 199.27,72.98 199.31,73 199.36,73.03 199.4,73.07 199.43,73.11 199.46,73.15 199.48,73.2 199.49,73.25 199.49,73.31 199.49,73.36 199.48,73.41 199.46,73.46 199.43,73.51 199.4,73.55 199.36,73.59 199.31,73.62 199.27,73.64 199.22,73.66 199.16,73.66 199.11,73.66 199.06,73.66 199.01,73.64 198.96,73.62 198.91,73.59 198.87,73.55 198.84,73.51 198.81,73.46 198.8,73.41 198.78,73.36 198.78,73.31 197.81,73.31 197.81,74.73 199.26,76.19 199.26,78.85 199.46,79.05 199.88,79.05
+3.3V_RUN_AUDIO on IN3 (solid shape): outline of 308 points within 197.87,72 203.23,80.38
+3.3V_RUN_CARD on TOP (solid shape): 17.97,17.83 18.51,17.83 18.8,17.54 19.64,17.54 19.69,17.49 19.69,17.35 19.67,17.34 17.8,17.34 17.52,17.62 17.07,17.62 17.01,17.68 17.01,18.2 17.07,18.27 17.54,18.27
+3.3V_RUN_CARD on BOTTOM (solid shape): 29.2,27.17 29.2,26.79 29.31,26.67 30.3,26.67 30.43,26.55 30.43,25.89 30.3,25.77 27.73,25.77 27.63,25.87 27.63,27.79 27.69,27.85 28.51,27.85
+3.3V_RUN_CARD on IN2 (solid shape): 20.08,18.05 20.08,17.54 19.77,17.23 17.76,17.23 17.6,17.39 17.6,17.75 17.88,18.02 18.62,18.02 19.17,18.57 19.56,18.57
+3.3V_RUN_CARD on IN2 (solid shape): 28.96,27.31 28.96,26.99 28.07,26.1 27.42,26.1 26.96,26.57 26.96,27.15 27.74,27.93 28.34,27.93
+3.3V_RUN_UZ9 on TOP (solid shape): 58.71,64.24 58.71,62.92 58.22,62.42 56.62,62.42 56.35,62.16 56.35,61.5 56.29,61.43 55.5,61.43 55.39,61.54 55.37,61.54 55.08,61.83 54.33,61.83 54.23,61.93 54.23,63.74 54.85,64.37 58.59,64.37
+3.3V_RUN_VDDA on TOP (solid shape): outline of 186 points within 147.27,110.09 151.07,112.64
+3.3V_RUN_VDDA on IN3 (solid shape): outline of 976 points within 147.95,110.77 155.72,116.27
+3.3V_RUN_VDDIO on TOP (solid shape): 150.14,109.79 150.14,108.87 150.45,108.56 150.45,107.71 150.33,107.6 148.39,107.6 148.2,107.79 148.2,109.3 148.86,109.96 149.97,109.96
+3.3V_RUN_VDDIO on TOP (solid shape): 155.11,116.49 155.11,114.91 154.98,114.79 154.63,114.79 154.52,114.89 154.52,115.87 154.38,116.01 154.38,116.53 154.42,116.56 155.03,116.56
+3.3V_RUN_VDDIO on TOP (solid shape): outline of 83 points within 154.52,108.96 158.45,110.75
+3.3V_RUN_VMM on BOTTOM (solid shape): 136.29,108.58 136.29,107.1 136.15,106.96 134.47,106.96 134.2,107.23 134.2,108.64 134.31,108.74 136.12,108.74
+3.3V_RUN_VMM on BOTTOM (solid shape): 167.08,118.32 167.08,115.45 167.11,115.42 166.68,114.99 164.27,114.99 163.74,115.52 163.74,117.96 163.8,118.02 165.25,118.02 165.74,118.51 166.9,118.51
+3.3V_RUN_VMM on BOTTOM (solid shape): 141.48,122.29 141.48,119.82 142.04,119.26 142.42,119.26 142.72,119.56 143.37,119.56 143.44,119.49 143.44,118.99 143.77,118.66 143.77,117.81 143.13,117.18 143.13,115.52 143.04,115.43 142.59,115.43 142.52,115.5 142.52,117.38 140.74,119.17 138.57,119.17 137.79,119.95 137.74,120.01 137.69,120.05 136.99,120.75 136.99,122.18 137.1,122.29 137.35,122.29 138.31,121.34 139.92,121.34 139.97,121.37 140.01,121.4 140.59,121.4 140.85,121.66 140.85,122.36 140.97,122.48 141.29,122.48
+3.3V_RUN_VMM on IN2 (solid shape): outline of 230 points within 160.58,108.86 165.16,116.56
+3.3V_RUN_VMM on IN2 (solid shape): outline of 288 points within 135.89,121.71 142.31,127.47
+3.3V_SUS on TOP (solid shape): 204.04,30.97 204.03,30.95 204.03,28.3 203.84,28.11 201.22,28.11 200.92,28.41 200.92,30.41 201.49,30.41 201.49,30.92 200.92,30.92 200.92,31.17 201.04,31.3 203.71,31.3
+3.3V_SUS on TOP (solid shape): 220.99,49.16 220.99,44.58 220.81,44.4 219.67,44.4 219.6,44.47 219.6,45.98 219.49,46.08 219.49,46.92 219.97,47.36 219.33,47.42 219.22,47.53 217.78,47.53 217.6,47.7 217.6,48.94 218.37,49.7 220.45,49.7
+3.3V_SUS on BOTTOM (solid shape): outline of 782 points within 125.01,125.43 133.4,134.66
+3.3V_SUS on IN1 (solid shape): outline of 173 points within 200.15,43.17 221.25,47.53
+3.3V_SUS on IN2 (solid shape): 78.31,112.74 78.31,111.13 78.07,110.89 76.24,110.89 76.11,111.01 76.11,112.86 76.32,113.06 77.99,113.06
+3.3V_SUS on IN2 (solid shape): 201.93,30.8 203.29,30.8 203.58,30.51 203.58,29.29 203.38,29.09 200.69,29.09 199.39,30.38 199.39,31.41 199.99,32.01 200.73,32.01
+3.3V_SUS on IN2 (solid shape): 202.8,45.37 202.8,44.03 201.64,42.88 201.62,42.89 201.3,42.79 201.2,42.47 201.21,42.45 201.04,42.28 200.01,42.28 198.94,43.36 198.94,44.06 200.62,45.75 202.42,45.75
+3.3V_SUS on IN2 (solid shape): 131.22,129.45 131.22,128.35 131.17,128.25 131.16,128.14 131.16,128.12 130.99,127.94 130.76,127.94 130.75,127.95 130.61,127.98 130.47,127.95 130.46,127.94 130.17,127.94 130.16,127.95 130.02,127.98 129.88,127.95 129.87,127.94 129.59,127.94 129.58,127.95 129.44,127.98 129.3,127.95 129.29,127.94 129.01,127.94 129,127.95 128.85,127.98 128.71,127.95 128.7,127.94 128.39,127.94 128.33,127.97 128.18,128.11 128.18,129.43 128.35,129.59 131.08,129.59
+3.3V_SUS on IN3 (solid shape): 203.37,30.17 203.37,29.19 203.06,28.88 201.81,28.88 199.58,31.11 199.58,31.42 199.96,31.8 201.74,31.8
+3.3V_SUS on IN3 (solid shape): 78.12,111.31 78.12,110.17 77.75,109.79 74.35,109.79 74.09,110.05 74.09,110.88 74.64,111.43 77.99,111.43
+3.3V_SUS_UZ8 on TOP (solid shape): 200.6,33.77 200.6,33.14 200.73,33.01 200.73,30.22 199.33,30.22 199.13,30.42 199.13,33.63 199.33,33.84 200.54,33.84
+3.3V_TP on TOP (solid shape): outline of 92 points within 199.84,54.6 203.01,59.76
+3.3V_VMM_UV10 on BOTTOM (solid shape): 137.19,106.07 137.87,106.07 138.04,105.9 138.04,104.43 138.31,104.16 138.31,102.99 138.18,102.86 137.68,102.86 136.96,103.58 136.96,105.16 136.71,105.4 135.19,105.4 135.04,105.56 135.04,106.13 135.13,106.23 137.03,106.23
+3.3V_WLAN on TOP (solid shape): 171.56,89.74 171.56,88.74 171.34,88.52 170.8,88.52 170.58,88.74 170.58,89.4 170.22,89.76 167.82,89.76 167.65,89.92 167.65,90.53 167.72,90.6 170.7,90.6
+3.3V_WLAN on TOP (solid shape): 190.62,92 190.62,90.97 189.59,89.94 189.13,89.94 188.84,90.23 188.84,90.46 188.79,90.51 188.79,91.7 189.19,92.1 190.52,92.1
+3.3V_WLAN on TOP (solid shape): 189.19,51.73 189.92,51.73 190.01,51.64 190.01,50.51 188.86,49.37 185.82,49.37 185.61,49.57 185.61,50.88 186.34,51.6 186.34,51.62 186.97,52.25 188.67,52.25
+3.3V_WLAN on BOTTOM (solid shape): 163.45,96.06 163.45,93.37 163.04,92.97 163.04,92.27 163.28,92.04 163.28,91.6 163.17,91.49 162.03,91.49 161.8,91.72 161.8,92.49 162.94,93.64 162.94,96.12 162.99,96.17 163.34,96.17
+3.3V_WLAN on BOTTOM (solid shape): 171.31,90.29 171.31,89.61 171.21,89.51 171.21,87.98 171.12,87.88 170.46,87.88 170.34,88.01 170.33,88.03 170.31,88.13 170.26,88.22 170.26,90.26 170.6,90.6 171,90.6
+3.3V_WLAN on BOTTOM (solid shape): outline of 107 points within 187.87,87.98 191.94,92.01
+3.3V_WLAN on IN2 (solid shape): 189.08,53.19 189.08,51.29 188.8,51.01 187.44,51.01 187.23,51.22 187.23,53.15 187.5,53.42 188.85,53.42
+3.3V_WLAN on IN2 (solid shape): 191.96,91.81 191.96,89.97 191.65,89.65 191.39,89.65 191.38,89.66 190.51,89.66 190.3,89.88 189.34,89.88 189.24,89.98 189.24,90.82 189.42,91.01 190.46,91.01 191.46,92 191.77,92
+3.3V_WLAN on IN3 (solid shape): 163.26,93.16 163.26,90.37 162.94,90.04 161.79,90.04 161.7,90.13 161.7,92.8 162.21,93.31 163.12,93.31
+3.3V_WLAN on IN3 (solid shape): 172.45,90.58 172.45,89.59 172.28,89.42 169.5,89.42 169.23,89.68 169.23,90.47 169.48,90.72 172.32,90.72
+3.3V_WLAN on IN3 (solid shape): 190.64,90.68 190.64,89.92 190.46,89.74 190.29,89.74 190.28,89.74 190.19,89.75 190.09,89.74 190.08,89.74 189.71,89.74 189.7,89.74 189.36,89.66 189.25,89.32 189.26,89.3 189.02,89.06 187.89,89.06 187.52,89.43 187.52,90.64 187.87,90.99 190.32,90.99
+3.3V_WLAN on IN4 (solid shape): 190.26,52.98 190.26,52 189.3,51.04 187.73,51.04 187.42,51.36 187.42,52.04 188.56,53.18 190.07,53.18
+3.3V_WLAN on IN4 (solid shape): 191.96,91.81 191.96,90.1 191.58,89.72 191.01,89.72 190.95,89.78 189.49,89.78 189.11,90.16 189.11,90.86 189.49,91.24 190.95,91.24 191.01,91.3 191.01,91.62 191.39,92 191.77,92
+3.3V_WLAN on IN4 (solid shape): 194.75,67.31 194.75,64.97 194.77,64.95 194.77,63.95 194.69,63.87 193.72,63.87 193.72,64.01 193.11,64.62 193.11,64.88 193.16,64.97 193.27,64.96 193.72,64.97 193.8,65.41 193.8,65.5 193.86,65.56 193.91,66.23 193.45,65.73 193.46,65.64 193.39,65.59 193.33,65.56 193.27,65.53 193.16,65.52 193.11,65.61 193.11,66.31 193.31,66.63 193.11,66.95 193.11,67.3 193.61,67.81 194.25,67.81
+3.3V_WLAN_UZ2 on TOP (solid shape): 191.53,46.68 191.53,45.96 191.46,45.9 189.08,45.9 188.84,46.14 186.55,46.14 185.73,46.97 185.73,48.36 185.93,48.56 189.65,48.56
+3.3V_WWAN on TOP (solid shape): 194.31,52.47 194.31,49.65 194.03,49.37 191.12,49.37 191.01,49.48 191.01,50.13 192.47,51.59 192.47,52.06 193.08,52.67 194.11,52.67
+3.3V_WWAN on BOTTOM (solid shape): outline of 243 points within 192.47,50.85 205.11,66.69
+3.3V_WWAN on BOTTOM (solid shape): outline of 434 points within 217.67,59.52 228.34,67.25
+3.3V_WWAN on IN3 (solid shape): outline of 205 points within 192.47,50.97 219.41,61.71
+3.3V_WWAN_UZ2 on TOP (solid shape): 194.88,48.23 194.88,46.12 194.67,45.91 192.95,45.91 192.89,45.96 192.89,46.62 192.89,46.63 192.89,47.23 192.45,47.67 191.61,47.67 191.02,48.25 191.02,48.47 191.11,48.55 194.56,48.55
+3V5V_PWR_SRC on TOP (solid shape): 46.44,24.06 46.44,22.91 46.08,22.55 46.08,21.72 46.05,21.69 45.57,21.69 45.44,21.57 45.44,21.19 45.35,21.1 45.05,21.1 44.97,21.17 44.97,22.38 45.09,22.5 45.69,22.5 46.24,23.04 46.24,24.04 46.29,24.09 46.41,24.09
+3V5V_PWR_SRC on TOP (solid shape): 40.05,18.67 40.96,18.67 41,18.63 41,17.47 40.8,17.27 40.8,16.42 40.97,16.26 42.65,16.26 42.94,15.97 45.99,15.97 46.45,15.51 48.39,15.51 48.49,15.61 48.49,16.88 48.78,17.17 49.98,17.17 50.05,17.1 50.05,15.66 50.49,15.23 52.87,15.23 52.89,15.24 53.34,15.24 53.42,15.17 53.42,13.2 52.92,12.7 52.92,11.19 52.64,10.91 37.56,10.91 37.05,11.42 37.05,13.95 35.41,15.59 35.41,17.63 35.89,18.11 36.36,18.11 37.01,18.76 37.01,19.07 39.65,19.07
+3V5V_PWR_SRC on BOTTOM (solid shape): 41.61,16.92 41.61,12.32 41.39,12.11 38.28,12.11 38.12,12.27 38.12,14.52 38.15,14.56 38.64,14.56 38.66,14.58 38.66,15.28 38.64,15.31 38.13,15.31 38.1,15.33 38.1,15.73 38.14,15.76 38.64,15.76 38.66,15.79 38.66,16.46 38.61,16.51 38.12,16.51 38.1,16.53 38.1,17.03 38.13,17.06 41.47,17.06
+3V5V_PWR_SRC on IN2 (solid shape): 45.44,21.95 45.44,21.16 45.1,20.82 43.32,20.82 41.72,19.22 41.72,12.83 41.44,12.55 38.64,12.55 38.46,12.72 38.46,19.43 41.23,22.19 45.2,22.19
+5V_ALW on TOP (solid shape): 267.83,130.97 267.83,129.68 267.74,129.59 266.32,129.59 266.04,129.88 266.04,131.2 266.09,131.25 267.55,131.25
+5V_ALW on TOP (solid shape): 63.94,122.03 63.94,120.51 63.76,120.32 61.55,120.32 61.45,120.42 61.45,121.09 62.63,122.27 63.69,122.27
+5V_ALW on TOP (solid shape): 59.79,119.04 59.79,117.64 60.03,117.4 61.39,117.4 61.45,117.33 61.45,116.86 61.69,116.63 62.41,116.63 62.56,116.48 62.56,115.93 62.45,115.82 61.83,115.82 61.52,116.12 60.09,116.12 58.18,118.03 58.18,119 58.35,119.17 59.67,119.17
+5V_ALW on TOP (solid shape): 220.13,62.33 220.13,62.02 220.28,61.87 221.55,61.87 221.64,61.78 221.64,60.14 221.54,60.04 219.53,60.04 219.4,60.18 218.82,60.18 218.71,60.29 218.71,60.79 218.84,60.91 218.93,60.91 219.08,61.07 219.08,61.97 219.59,62.47 219.98,62.47
+5V_ALW on TOP (solid shape): 58.61,60.86 58.79,60.81 58.97,60.86 59.6,60.86 59.83,60.64 59.83,59.35 59.31,58.84 58.26,58.84 57.61,59.49 57.61,59.96 57.69,60.04 58.57,60.04 59.14,60.27 58.64,60.64 58.63,60.63 57.67,60.63 57.61,60.7 57.61,60.8 57.67,60.86
+5V_ALW on BOTTOM (solid shape): 59.65,119.66 59.65,117.92 59.47,117.74 58.55,117.74 58.2,118.09 58.2,119.64 58.45,119.88 59.43,119.88
+5V_ALW on BOTTOM (solid shape): 216.29,25.94 216.29,7.99 216.02,7.71 213.81,7.71 212.75,8.77 212.75,23.82 210.75,25.82 210.75,28.9 210.97,29.12 213.11,29.12
+5V_ALW on BOTTOM (solid shape): 196.33,80.22 196.55,80.22 196.69,80.08 196.69,78.13 196.59,78.03 195.82,78.03 195.44,77.65 195.44,77.41 195.43,77.4 194.85,77.4 194.78,77.46 194.78,78.15 194.85,78.21 195.33,78.21 195.98,78.86 195.98,80.1 196.1,80.23 196.32,80.23
+5V_ALW on BOTTOM (solid shape): 66.75,20.16 68.87,20.16 69.01,20.02 69.01,17.78 68.81,17.58 65.64,17.58 65.59,17.63 65.59,18.08 65.62,18.11 66.09,18.11 66.13,18.15 66.13,18.84 66.09,18.88 65.66,18.88 65.62,18.91 65.62,19.26 65.66,19.29 66.08,19.29 66.13,19.35 66.13,20.03 66.09,20.07 65.6,20.07 65.57,20.09 65.57,20.58 65.6,20.6 66.31,20.6
+5V_ALW on BOTTOM (solid shape): 241.32,122.85 241.32,122.6 242.57,121.34 242.57,119.97 241.67,119.07 241.51,119.07 241.26,118.82 240.86,118.82 240.74,118.94 240.74,120.26 240.91,120.42 240.91,120.51 240.95,120.55 240.95,121.57 240.96,121.66 240.95,121.75 240.95,121.85 240.91,121.89 240.91,121.94 240.81,122.04 239.41,122.04 239.25,122.2 239.25,122.96 239.47,123.19 240.97,123.19
+5V_ALW on IN1 (solid shape): 216.26,26.09 216.26,8.09 215.93,7.76 212.92,7.76 212.51,8.17 212.51,22.52 210.94,24.1 210.94,28.57 211.23,28.86 213.49,28.86
+5V_ALW on IN1 (solid shape): outline of 110 points within 220.16,92.76 226.76,96.07
+5V_ALW on IN2 (solid shape): 217.81,27.04 217.81,14.34 216.28,12.82 216.28,8.18 215.97,7.86 212.79,7.86 212.41,8.25 212.41,14.21 213.87,15.68 213.87,23.23 210.89,26.22 210.89,28.38 211.33,28.82 216.03,28.82
+5V_ALW on IN2 (solid shape): outline of 1298 points within 222.76,92.64 268.03,131.35
