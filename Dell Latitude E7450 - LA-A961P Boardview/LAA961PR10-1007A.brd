# Allegro board LAA961PR10-1007A.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SIO_SLP_S5#: length 156.1
  TOP w0.089: T8.1 136.05,71.54 v2(136.37,71.22)
  TOP w0.102: v2(209.22,98.16) 208.87,97.8 UE2.A18 ; JAPS1.4 219.72,99.7 219.18,99.17 219.18,89.83 217.85,88.49 217.85,85.97 217.54,85.66 v2(217.54,85.07)
  IN1 w0.084: v2(136.37,71.22) 136.77,70.82 136.77,69.71 141.84,64.64 141.84,62.03 146.32,57.55 163.33,57.55 165.6,55.29 167.07,55.29 169.61,52.75 183.2,52.75 183.7,53.25 189.08,53.25 189.88,52.45 191.85,52.45 192.65,53.25 195.97,53.25 196.48,52.74 200.02,52.74 200.53,53.25 201.77,53.25 202.33,53.81 v2(202.33,54.09) ; v2(217.54,85.07) 217.21,84.74 216.12,84.74 215.16,85.7 212.42,85.7 212.08,86.04 v2(210.51,86.04)
  IN2 w0.122: v2(209.22,98.16) 209.22,97.21 210.66,95.77 210.66,86.19 v2(210.51,86.04) 210.39,85.91 210.39,84.59 209.62,83.82 209.62,78.24 208.38,77 203.51,77 203.03,76.52 203.03,73.94 203.16,73.81 203.16,65.32 204.68,63.81 204.68,62.4 203.97,61.69 203.97,58.6 202.87,57.5 202.87,54.64 v2(202.33,54.09)
  BOTTOM w0.076: v2(136.37,71.22) 136.06,71.54 UC1.AP5
SIO_SLP_SUS#: length 108.4
  TOP w0.102: v2(199.08,85.33) 199.08,85.8 v1(199.19,85.92) 200.67,87.4 UE2.B52
  IN1 w0.084: v2(197.54,54.25) 196.76,54.25 194.21,56.8 192.61,56.8 192.34,56.54 189.57,56.54 189.26,56.85 170.18,56.85 169.29,57.74 169.28,57.74 166.45,60.56 166.21,60.56 165.53,61.25 164.09,61.25 159.72,65.62 155.4,65.62 153.93,64.15 148.63,64.15 146.18,66.6 146.18,68.93 144.97,70.14 141.35,70.14 v2(140.75,70.74)
  IN2 w0.122: v2(199.08,85.33) 198.93,85.33 198.51,84.91 198.51,81.22 200.51,79.21 200.51,71.73 200.71,71.52 200.71,66.16 201.01,65.86 201.01,59.3 200.39,58.69 200.39,57.33 197.54,54.47 v2(197.54,54.25)
  BOTTOM w0.076: UC1.AP4 137.17,71.4 137.64,71.4 137.69,71.35 138.46,71.35 138.63,71.51 139.33,71.51 139.43,71.41 140.08,71.41 v2(140.75,70.74)
SIO_SLP_WLAN#: length 67.7
  TOP w0.102: v2(167.44,80) v1(167.44,80.61) ; v2(176.15,99.24) 176.15,99.16 176.47,98.84 UE1.A14
  IN2 w0.122: v2(176.15,99.24) 168.72,99.24 167.96,98.48 167.96,92.86 166.99,91.89 166.99,85.23 168.01,84.21 168.01,80.58 v2(167.44,80)
  IN3 w0.089: 146.46,73.36 145.1,72 140.03,72 139.58,71.56 137.24,71.56 v2(136.35,72.44)
  IN3 w0.122: v2(167.44,80) 167.02,79.58 165.01,79.58 164.16,78.73 159.95,78.73 159.26,78.05 158.45,78.05 156.77,79.73 154.95,79.73 153.72,78.5 149.76,78.5 148.85,77.59 148.85,75.75 146.46,73.36
  BOTTOM w0.076: UC1.AM5 135.96,72.84 v2(136.35,72.44)
SKIP#: length 1.4
  BOTTOM w0.203: PU500.7 89.75,103.01 PR520.2
SKIP#1: length 15.7
  TOP w0.102: v2(99.09,112.18) v1(99.09,112.74)
  IN3 w0.254: v2(99.09,112.18) 99.08,112.2 96.23,112.2 94.9,110.86 94.9,110 93.89,108.99 91.87,108.99 90.86,107.98 v2(90.86,104.11)
  BOTTOM w0.254: v2(90.86,104.11) 90.63,104.33 PR520.1
SL_BAT_PRES#: length 5.2
  TOP w0.102: v1(23.93,42.54) 23.93,40.96 23.57,40.61 PR854.1
  TOP w0.254: PU800.21 21.91,39.04 22.49,39.63 22.89,39.63 23.47,40.21 PR854.1
SLATE_MODE: length 13.8
  TOP w0.102: RPC10.7 147.98,76.55 v1(147.2,75.77) 146.21,74.78 142.49,74.78 141.55,73.84 139.58,73.84 138.95,73.22 137.62,73.22 v2(137.17,73.68)
  BOTTOM w0.076: v2(137.17,73.68) 136.87,73.38 UC1.AL4
SLEEVE: length 8.4
  IN1 w1.016: 216.52,74.29 216.21,74.6 212.41,74.6 210.97,73.17 210.97,71.09
  vias: v1(218.61,74.13) v2(210.6,70.1) v2(211.08,69.75) v2(217.66,74.21) v2(217.66,73.63)
SLEWA: length 4
  TOP w0.254: PR510.2 v2(92.01,97.78)
  BOTTOM w0.203: PR500.1 92.51,97.78 v2(92.01,97.78) 91.91,97.88 v1(91.91,98.29) 91.91,98.45 91.65,98.72 91.65,98.73 91.27,99.1 PU500.15
SLICE_BAT_ON: length 358.4
  TOP w0.102: UE1.A31 185.69,95.16 184.87,94.34 v2(184.55,94.34) 184.11,93.9 184.11,93.69 RE17.2
  TOP w0.254: v2(16.07,40.47) 16.26,40.47 17.93,42.14 18.95,42.14 19.19,41.9 PR845.2
  IN1 w0.254: v2(10.04,19.68) 10.04,17.31 11.78,15.56 14.47,15.56 15.25,14.77 16.31,14.77 17.66,13.43 17.66,12.26 20.4,9.52 59.5,9.52 59.91,9.92 87.27,9.92 87.51,9.68 142.85,9.68 143.95,10.79 151.66,10.79 152.56,9.88 175.69,9.88 180.11,14.3 203.43,14.3 v2(203.51,14.38)
  IN2 w0.122: v2(184.55,94.34) 184.55,93.62 183.04,92.11 183.04,90.1 176.72,83.78 176.72,81.52 176.27,81.07 175.43,81.07 170.11,75.75 170.11,74.31 167.04,71.23 167.04,70.57 164.45,67.98 164.45,67.14 163.22,65.91 163.22,62.58 161.68,61.05 161.68,60.63 160.37,59.32 160.37,51.72 v2(162.32,49.77)
  IN2 w0.254: v2(16.07,40.47) 15.61,40.47 13.12,37.98 v2(12.78,37.98)
  BOTTOM w0.102: v2(162.32,49.77) 162.83,49.27 168.62,49.27 180.49,37.39 197.23,37.39 199.96,34.66 199.96,28.62 203.63,24.95 203.63,18.46 202.49,17.31 202.49,16.61 203.35,15.75 203.35,14.53 v2(203.51,14.38) 203.16,14.38 v1(202.62,13.83)
  BOTTOM w0.254: v2(12.78,37.98) 12.78,37.18 9.49,33.89 9.49,20.22 v2(10.04,19.68)
SLICE_BAT_PRES#: length 398.8
  TOP w0.102: v2(192.71,97.49) 192.71,97.03 191.82,96.14 190.9,96.14 190.1,95.34 190.1,94.42 189.79,94.11 RE5.2 ; UE1.B33 185.94,97.52 v2(185.79,97.67)
  TOP w0.254: v1(13.1,44.75) 13.57,45.22 17.31,45.22 v2(17.74,44.78) 18.66,44.78 19.18,44.26 19.18,43.21 19.73,42.66 22.55,42.66 23.47,41.74 PR854.2
  IN1 w0.084: v2(164.4,48.01) 164.84,48.01 174.71,38.14 174.71,18.6 v2(174.3,18.19)
  IN1 w0.254: v2(17.74,44.78) 12.8,44.78 6.35,38.33 6.35,35.09 7.69,33.76 7.69,30.65 5.39,28.35 v2(4.74,28.35) ; v2(13.15,18.94) 13.15,18.94 13.15,24.17 v2(13.11,24.21)
  IN2 w0.122: v2(164.4,48.01) 167.19,48.01 169.71,50.54 169.71,58.48 166.57,61.62 166.57,64.6 166.09,65.08 166.09,67.07 166.2,67.18 166.2,68.91 167.54,70.24 167.54,71.03 170.61,74.1 170.61,75.55 173.2,78.14 180.93,78.14 182.46,79.67 182.46,86.34 183.12,87 183.12,88.62 184.6,90.1 184.6,92.57 186.28,94.26 186.28,95.08 185.79,95.57 v2(185.79,97.67)
  IN2 w0.254: v2(13.15,18.94) 15.59,16.5 15.97,16.5 16.52,15.95 17.88,15.95 18.2,16.27 24.17,16.27 25.66,17.76 25.89,17.76 27.17,19.04 27.17,20.52 29.63,22.99 29.63,26.88 30.23,27.47 30.23,29.37 32.85,31.99 41.78,31.99 43.39,30.38 48.62,30.38 49.37,29.63 51.59,29.63 56.93,24.3 97.78,24.3 99.31,22.76 103.21,22.76 106.98,18.99 120.14,18.99 122.16,16.97 145.66,16.97 v2(146.08,17.39) 147.26,18.57 167.08,18.57 168,19.5 173.12,19.5 174.3,18.32 v2(174.3,18.19)
  IN3 w0.254: v2(4.74,28.35) 6.72,28.35 10.67,24.4 12.93,24.4 13.11,24.22 v2(13.11,24.21)
  IN4 w0.084: v2(178.48,126.41) 181.46,126.41 183.41,124.45 188.47,124.45 v2(188.86,124.06) ; v2(185.79,97.67) 186.14,97.31 192.53,97.31 v2(192.71,97.49)
  BOTTOM w0.102: JDOCK1.141 178.75,127.77 178.48,127.5 v2(178.48,126.41) 178.98,126.91 178.98,127.35 179.25,127.61 JDOCK1.143 ; v2(188.86,124.06) 188.64,123.83 188.64,120.62 190.38,118.88 190.38,101.2 190.77,100.8 192.78,100.8 193.03,100.55 193.03,97.82 v2(192.71,97.49)
  BOTTOM w0.254: PR6.1 v2(146.08,17.39)
SM_RCOMP0: length 9.8
  IN3 w0.305: v2(102.04,70.09) 101.84,70.09 98.53,66.79 v2(98.53,66.03)
  BOTTOM w0.229: UC1.AU60 102.25,69.89 v2(102.04,70.09)
  BOTTOM w0.305: v2(98.53,66.03) 98.53,64.89 97.14,63.49 RC130.1
SM_RCOMP1: length 8.1
  IN3 w0.305: v2(99.17,66.67) 101.26,68.75 v2(101.78,68.75)
  BOTTOM w0.229: v2(101.78,68.75) 101.96,68.94 UC1.AV60
  BOTTOM w0.305: v2(99.17,66.67) 99.17,64.19 99,64.02 v1(99,64.03) 98.09,63.11 RC131.1
SM_RCOMP2: length 9.7
  IN3 w0.305: v2(101.06,70.06) 97.9,66.89 v2(97.9,65.4)
  BOTTOM w0.229: UC1.AU61 101.26,69.86 v2(101.06,70.06)
  BOTTOM w0.305: RC132.1 96.18,63.87 v1(96.47,64.16) 97.71,65.4 v2(97.9,65.4)
SMART_DET#: length 1.7
  TOP w0.102: UE1.A15 176.2,98.34 175.95,98.09 T99.1
SML0_SMBCLK: length 21.9
  IN1 w0.084: v2(141.3,70.78) 142.2,71.67 147.02,71.67 149.05,73.69 154.41,73.69 155.62,72.49 156.2,72.49 v2(156.47,72.22)
  BOTTOM w0.076: v2(141.3,70.78) v1(140.78,71.3) 140.51,71.57 139.5,71.57 139.36,71.71 138.91,71.71 UC1.AN1
  BOTTOM w0.102: RC30.2 155.95,72.43 156.26,72.43 v2(156.47,72.22) 156.65,72.39 157.15,72.39 RC33.2
SML0_SMBDATA: length 22.1
  IN1 w0.084: v2(156.47,72.8) 156.37,72.7 155.7,72.7 154.5,73.9 148.96,73.9 146.94,71.88 142.76,71.88 v2(142.06,72.57)
  BOTTOM w0.076: v2(142.06,72.57) v1(141.15,73.49) 140.58,74.05 UC1.AK1
  BOTTOM w0.102: RC34.2 156.9,72.62 156.65,72.62 v2(156.47,72.8) 156.33,72.66 156.08,72.66 155.72,73.02 RC32.2
SML1_SMBCLK: length 107.7
  TOP w0.102: UE2.B6 209.47,90.5 208.92,91.05 v2(208.92,91.41) ; 161.38,69.42 160.48,69.42 158.26,67.2 v4(157.58,67.2) 156.82,67.2 153.34,63.72 150.01,63.72 149.98,63.74 149.41,63.74 149.39,63.72 149.15,63.72 146.05,66.82 146.05,67.97 144.62,69.41 143.75,69.41 v2(143.35,69.01) ; 161.38,69.42 161.91,69.95 RPC14.3 ; 161.38,69.42 v2(161.4,69.42)
  IN4 w0.084: v2(208.92,91.41) 209.33,91.81 209.76,91.81 210.38,92.44 210.38,95.93 209.74,96.57 209.74,98.22 209.35,98.61 208.75,98.61 208.32,99.04 207.77,99.04 207.53,98.8 206.73,98.8 206.49,99.04 200.89,99.04 200.35,98.5 200.35,97.79 199.73,97.17 198.86,97.17 198,96.32 195.81,96.32 195.39,96.74 194.27,96.74 193.48,95.94 188.61,95.94 186.39,93.72 185.17,93.72 183.62,92.17 183.62,87.14 182.61,86.13 182.61,82.96 180.8,81.16 179.19,81.16 177.27,79.24 175.02,79.24 172.3,76.51 171.27,76.51 166.51,71.76 164.92,71.76 162.9,69.74 161.46,69.74 161.4,69.68 v2(161.4,69.42)
  BOTTOM w0.076: UC1.AU3 137.72,69.62 138.05,69.29 138.67,69.29 138.68,69.28 139.39,69.28 140.05,68.61 142.96,68.61 v2(143.35,69.01)
SML1_SMBDATA: length 117.7
  TOP w0.102: RPC14.4 161.91,69.45 161.83,69.36 161.83,69.23 161.46,68.86 v2(161.11,68.86) 160.99,68.98 160.33,68.98 158.34,67 157.89,67 157.87,66.97 157.3,66.97 157.28,67 156.91,67 153.43,63.52 v4(149.7,63.52) 149.07,63.52 145.85,66.74 145.85,67.89 145.22,68.52 v2(144.67,68.52) ; v2(212.38,90.75) 212.38,90.32 212.16,90.1 211.61,90.1 211.46,90.25 UE2.A5
  IN4 w0.084: v2(212.38,90.75) 212.38,90.96 212.17,91.16 211.39,91.16 210.57,91.99 210.57,96 209.92,96.65 209.92,98.3 209.43,98.8 208.83,98.8 208.4,99.23 207.7,99.23 207.46,98.99 206.81,98.99 206.56,99.23 200.81,99.23 200.16,98.57 200.16,97.86 199.65,97.36 198.78,97.36 197.93,96.51 195.89,96.51 195.47,96.92 194.2,96.92 193.4,96.13 188.53,96.13 186.31,93.91 185.1,93.91 183.43,92.25 183.43,87.22 182.42,86.21 182.42,83.04 180.73,81.35 179.11,81.35 177.19,79.42 174.95,79.42 172.22,76.7 171.19,76.7 166.44,71.94 164.84,71.94 162.82,69.92 161.34,69.92 160.98,69.56 160.98,69 v2(161.11,68.86)
  BOTTOM w0.076: 146.41,72.51 145.52,73.4 143.75,73.4 143.26,73.88 143.26,74.64 142.68,75.23 139.94,75.23 139.68,74.97 139.07,74.97 138.94,75.09 138.7,75.09 138.52,74.92 138.52,74.75 138.29,74.51 137.77,74.51 UC1.AH3
  BOTTOM w0.102: 146.41,72.51 146.41,70.55 144.67,68.81 v2(144.67,68.52)
SNB_1.05V: length 1.5
  TOP w0.102: PR305.2 v1(183.96,67.08)
SNUB_1.35V:
  vias: v1(83.05,14.85)
SNUB_3V: length 1.6
  TOP w0.102: PR111.2 40.34,25.39 v1(40.01,25.72)
SNUB_5V: length 1.4
  BOTTOM w0.102: v1(48.24,22.09) 48.36,21.96 PC114.1
SOFT_START_GC: length 109.3
  TOP w0.254: PU800.2 v2(19.41,31.68) ; v2(70.98,102.54) PR17.2
  IN1 w0.254: v2(19.41,31.68) 21.27,33.54 24.35,33.54 24.62,33.81 28.69,33.81 30.71,35.84 30.71,41.65 31.28,42.22 31.28,43.46 32.21,44.39 32.21,50.84 30.55,52.51 30.55,57.6 34.19,61.24 49.46,61.24 53.6,65.38 53.6,65.4 70.98,82.78 v2(70.98,102.54)
  BOTTOM w0.102: v2(70.98,102.54) v1(71.67,101.86)
SPI_CLK32: length 21.7
  TOP w0.102: v2(186.55,75.11) 186.98,74.68 RC61.2 190.2,73.75 185.38,73.75 184.15,74.98 182.82,74.98 182.78,75.02 180.42,75.02 180.32,74.92 179.9,74.92 v1(179.73,74.76) 179.18,74.21 RPC12.7
  BOTTOM w0.102: UC3.6 185.83,73.71 186.55,74.44 v2(186.55,75.11)
SPI_CLK64: length 22.7
  TOP w0.102: v3(171.9,72.57) 171.96,72.57 v2(172.47,73.08) 172.47,73.47 RC62.2 173.2,74.21 RPC11.6
  BOTTOM w0.102: v2(172.47,73.08) 168.63,73.08 168.51,73.21 168.51,74.49 168.63,74.62 169.79,74.62 169.92,74.74 169.92,75.1 169.84,75.17 168.05,75.17 167.92,75.05 167.92,72.36 168.05,72.23 172.48,72.23 173.96,73.71 UC2.6
SPI_CLKTPM: length 2.9
  TOP w0.102: RZ35.2 RZ26.2 189.13,56.61 189.07,56.55 UZ1.21
SPI_DIN32: length 19.7
  TOP w0.102: RPC12.5 178.82,73.21 180.8,71.22 181.87,71.22 182.58,71.94 186.48,71.94 187.07,72.53 v1(190.64,72.53) 191.9,72.53 192.67,73.31 193.37,73.31 v2(193.75,73.69)
  BOTTOM w0.102: v2(193.75,73.69) 192.46,74.98 UC3.2
SPI_DIN64: length 18.4
  TOP w0.102: RPC11.8 174.46,73.21 174.56,73.1 174.56,72.67 174.67,72.57 176.09,72.57 176.22,72.44 v3(176.22,72) 176.22,71.81 176.34,71.68 177.19,71.68 177.29,71.78 177.29,72.53 177.4,72.63 178.65,72.63 178.76,72.53 178.76,71.96 178.65,71.86 v2(178.18,71.86)
  BOTTOM w0.102: v2(178.18,71.86) 179.86,71.86 179.96,71.96 179.96,72.53 179.86,72.63 178.29,72.63 178.18,72.74 178.18,74.88 178.29,74.98 UC2.2
SPI_DINTPM: length 4.5
  TOP w0.102: v1(188.48,62.77) 188.48,61.92 189.51,60.89 RZ30.2 189.51,60.56 188.75,59.8 UZ1.26
SPI_DO32: length 17.8
  TOP w0.102: RPC12.6 178.82,73.71 v1(180.44,72.08) 181.07,71.45 181.77,71.45 182.85,72.53 185.78,72.53 v2(185.93,72.38)
  BOTTOM w0.102: UC3.5 185.08,72.44 185.74,73.1 187.67,73.1 187.77,73.21 187.77,73.93 187.87,74.03 188.27,74.03 188.37,73.93 188.37,72.48 188.27,72.38 v2(185.93,72.38)
SPI_DO64: length 18.8
  TOP w0.102: v2(173.55,72.42) 173.55,72.24 173.68,72.11 175.4,72.11 175.53,71.99 175.53,70.71 175.4,70.58 172.24,70.58 172.15,70.67 v3(172.15,70.79) 172.15,70.95 172.29,71.09 174.89,71.09 175.02,71.21 175.02,71.47 174.89,71.6 172.04,71.6 171.91,71.72 171.91,71.98 172.06,72.13 172.95,72.13 173.05,72.23 173.05,73.09 173.67,73.71 RPC11.7
  BOTTOM w0.102: UC2.5 173.57,72.44 v2(173.55,72.42)
SPI_DOTPM: length 2.2
  TOP w0.102: RZ29.2 189.5,57.85 UZ1.23
SPI_PCH_CLK: length 16.5
  TOP w0.102: RPC12.2 v2(176.49,74.21) RPC11.3 ; RC227.1 170.13,67.88 v2(170.13,68.47) 170.13,68.53 v1(170.61,69.02)
  BOTTOM w0.102: v2(176.49,74.21) 176.9,73.8 176.9,72.14 175.92,71.16 169.79,71.16 169.38,70.76 JSPI1.7 169.38,69.21 v2(170.13,68.47)
SPI_PCH_CS0#: length 19.2
  TOP w0.102: RC228.1 171.21,67.68 v2(171.21,68.47) 171.21,69.47 170.79,69.89 170.79,75.67 172.75,77.63 177.19,77.63 v1(177.57,77.24) RC35.1
  BOTTOM w0.102: JSPI1.9 170.38,69.29 v2(171.21,68.47)
SPI_PCH_CS0#_R: length 13.8
  TOP w0.102: RC35.2 180.13,76.17 180.28,76.32 v2(180.28,76.92) 179.8,77.4 v3(179.77,77.4)
  BOTTOM w0.102: v2(180.28,76.92) 180.82,77.46 182.6,77.46 182.7,77.36 182.7,76.95 182.6,76.85 181.04,76.85 180.44,76.25 178.68,76.25 178.58,76.15 178.58,75.84 178.68,75.73 180.75,75.73 181.27,76.25 UC2.1
SPI_PCH_CS1#: length 35.4
  TOP w0.102: RC50.1 190.58,76.2 188.07,76.2 185.21,79.06 184.02,79.06 183.78,79.3 182.25,79.3 182.01,79.06 180.25,79.06 179.05,77.85 172.65,77.85 170.56,75.76 170.56,73.43 v1(170.36,73.23) 167.41,70.29 v2(167.41,68.42) 167.26,68.27 RC224.1
  BOTTOM w0.102: v2(167.41,68.42) 166.77,68.42 166.38,68.8 JSPI1.1
SPI_PCH_CS1#_R: length 13.6
  TOP w0.102: v2(192.99,75.78) 194.45,75.78 194.55,75.89 194.55,76.47 194.45,76.57 v1(193.77,76.57) 193.08,76.57 192.98,76.67 192.98,77.11 192.88,77.21 192.51,77.21 192.41,77.11 192.41,76.67 192.31,76.57 192,76.57 191.9,76.67 191.9,78.74 191.8,78.84 191.43,78.84 191.33,78.74 191.33,76.37 RC50.2
  BOTTOM w0.102: v2(192.99,75.78) 192.99,76.11 192.85,76.25 UC3.1
SPI_PCH_DIN: length 15.9
  TOP w0.102: RPC12.4 v2(176.49,73.21) RPC11.1 ; v1(169.23,69.09) 169.29,69.03 v2(169.29,68.47) RC226.1
  BOTTOM w0.102: v2(169.29,68.47) 168.38,69.38 JSPI1.5 168.38,70.76 169.02,71.39 175.83,71.39 176.49,72.05 v2(176.49,73.21)
SPI_PCH_DO: length 17.3
  TOP w0.102: RPC11.2 v2(176.13,73.71) RPC12.3 ; RC225.1 v2(168.4,68.47) 168,68.88 v1(167.83,68.88)
  BOTTOM w0.102: v2(168.4,68.47) 167.38,69.49 JSPI1.3 167.38,70.81 168.2,71.62 175.74,71.62 176.08,71.97 176.08,73.66 v2(176.13,73.71)
SPI_PCH_DO2: length 38.8
  TOP w0.102: v2(179.75,73.75) 180.3,73.19 RC38.1 180.96,72.56 181.99,72.56 182.58,73.14 190.57,73.14 RC55.1 ; RC229.1 v2(172.34,68.47) 172.34,68.86 v1(172.08,69.12) 171.02,70.18 171.02,75.57 172.15,76.7 173.13,76.7 173.69,76.14 RC29.2
  IN4 w0.084: v2(179.75,73.75) 178.98,73.75 176.41,71.17 176.41,68.57 175.39,67.55 173.26,67.55 v2(172.34,68.47)
  BOTTOM w0.102: v2(172.34,68.47) 171.38,69.43 JSPI1.11
SPI_PCH_DO2_32: length 13.7
  TOP w0.102: RC55.2 193.13,73.7 v2(193.14,73.71)
  BOTTOM w0.102: UC3.3 189.59,73.71 189.49,73.61 189.49,73.12 189.59,73.02 190.46,73.02 190.57,72.91 190.57,72.55 190.46,72.44 189.65,72.44 189.55,72.34 189.55,71.85 189.65,71.75 193.74,71.75 193.87,71.87 v1(193.87,72.38) 193.87,72.99 v2(193.14,73.71)
SPI_PCH_DO2_64: length 15.8
  TOP w0.102: RC38.2 181.8,73.75 183.93,73.75 184.05,73.88 184.05,74.22 183.93,74.35 182.17,74.35 182.11,74.41 v3(181.45,74.41) v2(180.79,74.41)
  BOTTOM w0.102: v2(180.79,74.41) 180.53,74.67 178.82,74.67 178.69,74.54 178.69,74.22 178.82,74.1 179.2,74.1 179.33,73.97 179.33,73.59 179.2,73.46 178.82,73.46 178.69,73.33 178.69,72.99 178.82,72.86 179.45,72.86 180.09,72.86 180.22,72.99 180.22,73.59 180.34,73.71 UC2.3
SPI_PCH_DO3: length 22.7
  TOP w0.102: v2(173.36,68.47) 173.37,68.47 v1(173.75,68.85) ; v2(173.36,68.47) RC230.1 ; v2(173.36,68.47) 171.25,70.58 171.25,75.48 172.21,76.44 173.06,76.44 173.76,75.75 174.22,75.75 174.46,75.5 177.09,75.5 RC31.2 178.12,75.77 178.12,75.37 177.46,74.71 RPC12.1 RPC11.4
  BOTTOM w0.102: JSPI1.13 172.38,69.44 v2(173.36,68.47)
SPI_PCH_DO3_32: length 15.8
  TOP w0.102: v2(185.85,75.11) 185.85,75.35 185.61,75.59 185.29,75.59 185.18,75.69 185.18,76.42 185.08,76.52 184.78,76.52 184.68,76.42 184.68,75.69 184.57,75.59 184.27,75.59 184.17,75.69 184.17,76.6 184.07,76.7 183.76,76.7 183.66,76.6 183.66,75.69 183.56,75.59 183.25,75.59 183.15,75.69 183.15,76.85 183.05,76.95 182.75,76.95 182.64,76.85 182.64,75.94 182.52,75.81 v1(180.83,75.81) 180.34,75.81 180.13,75.59 179.11,75.59 178.95,75.43 178.95,74.86 178.79,74.71 RPC12.8
  BOTTOM w0.102: UC3.7 185.73,74.98 v2(185.85,75.11)
SPI_PCH_DO3_64: length 15
  TOP w0.102: RPC11.5 173.71,74.71 173.61,74.81 v2(173.61,75.14) 173.5,75.14 v3(172.6,76.05)
  BOTTOM w0.102: v2(173.61,75.14) 173.54,75.14 173.43,75.03 173.43,74.2 173.33,74.1 169.1,74.1 169,73.99 169,73.68 169.1,73.57 173.5,73.57 173.92,73.99 173.92,74.4 174.5,74.98 UC2.7
SPKR: length 72.4
  TOP w0.102: RA12.2 198.76,67.21 v2(198.07,67.21)
  IN1 w0.084: v2(198.07,67.21) 197.39,67.89 197.39,69.49 196.99,69.9 195.02,69.9 193.71,71.2 190.5,71.2 188.44,73.27 177.99,73.27 170.74,80.52 169.55,80.52 168.74,81.33 165.66,81.33 165.06,81.93 v2(163.46,81.93) 163.46,81.73 163.22,81.49 162.65,81.49 161.72,82.42 160.04,82.42 159.35,81.74 155.47,81.74 154.43,80.71 151.64,80.71 150.84,79.91 150.4,79.91 149.82,80.48 143.44,80.48 v2(142.62,79.66)
  BOTTOM w0.076: v2(142.62,79.66) 141.73,80.55 140.44,80.55 140.17,80.81 139.38,80.81 138.92,80.36 138.47,80.36 138.17,80.05 UC1.V2
  BOTTOM w0.102: RC180.2 163.73,81.66 v2(163.46,81.93) 163.46,82.07 v1(163.15,82.39)
SRCDET: length 6.1
  BOTTOM w0.102: RV84.1 157.19,105.71 v1(157.08,105.71) 156.93,105.71 155.8,106.84 155.23,106.84 154.78,107.28 154.78,108.45 UV8.C2
SRTCRST#: length 36.8
  TOP w0.102: v2(135.07,68.64) 135.17,68.64 136.33,67.48 138.29,67.48 141.73,64.05 141.73,60.47 142.82,59.38 152.25,59.38 152.92,60.04 155.5,60.04 v1(156.22,60.76) 156.68,61.22 159.1,61.22 160.61,62.73 RC10.2 CC3.2
  BOTTOM w0.076: v2(135.07,68.64) 135.37,68.94 UC1.AV6
STSTART_DCBLOCK_GC: length 239.3
  TOP w0.254: v2(24.78,36.54) PU800.16
  IN1 w0.254: v2(206.39,14.43) 205.6,14.43 204.13,15.9 201.8,15.9 200.59,14.7 179.97,14.7 175.53,10.26 152.72,10.26 151.81,11.17 143.8,11.17 143.48,10.85 86.97,10.85 86.43,10.3 59.75,10.3 59.34,9.9 21.56,9.9 19.12,12.34 19.12,12.96 17.39,14.7 16.92,14.7 16.47,15.15 15.41,15.15 14.62,15.94 11.94,15.94 10.53,17.35 10.53,33.4 12.02,34.89 12.02,36.36 13.45,37.8 23.19,37.8 24.45,36.54 v2(24.78,36.54)
  BOTTOM w0.102: v2(206.39,14.43) 206.5,14.43 v1(206.97,13.96)
  BOTTOM w0.254: PR811.2 206.01,14.71 206.24,14.48 206.34,14.48 v2(206.39,14.43)
SUS_ON: length 292.7
  TOP w0.102: RE281.2 205.84,102.54 v2(205.67,102.54) 205.37,102.84 RPE10.2 ; v2(214.76,35.64) 206.63,35.64 205.08,34.09 v3(204.08,34.09) 202.63,34.09 202.59,34.13 UZ8.3
  IN1 w0.084: v2(208.52,91.85) 208.46,91.79 208.46,91.29 208.75,91 209.99,91 212.28,88.71 212.57,88.71 213.35,87.93 214.5,87.93 215.46,86.97 216.79,86.97 217.25,87.44 223.05,87.44 223.61,88 225.85,88 226.74,87.1 226.74,79.59 224.59,77.44 224.59,70.26 219.7,65.38 219.45,65.38 217.05,62.97 217.05,62.7 215.71,61.36 215.71,58.35 218.87,55.18 221.48,55.18 222.84,53.83 222.84,45.19 223.52,44.5 223.52,42.72 216.44,35.64 v2(214.76,35.64)
  IN2 w0.122: v2(208.52,91.85) 208.05,92.32 208.05,96.57 207.3,97.33 207.3,98.71 207.34,98.76 207.34,101.12 205.92,102.54 v2(205.67,102.54)
  IN3 w0.122: v2(71.35,19) 71.03,18.69 71.03,14.75 71.34,14.44 71.34,10.8 71.95,10.19 76.74,10.19 77.45,9.48 148.94,9.48 149.36,9.06 172.08,9.06 172.51,9.49 209.35,9.49 214.76,14.89 v2(214.76,35.64)
  BOTTOM w0.254: PR207.1 72.95,19.89 72.65,19.59 72.65,19.26 72.37,18.98 RE282.2 71.38,18.98 v2(71.35,19)
SUS_ON_EC: length 9
  TOP w0.102: v2(206.57,95.34) 207.12,95.89 UE2.B23 ; v2(206.75,101.02) 207.19,101.02 207.61,101.44 RE281.1
  BOTTOM w0.102: v2(206.57,95.34) 207.08,95.85 207.08,98.55 207.36,98.83 207.36,100.41 v2(206.75,101.02)
SUS_STAT#/LPCPD#: length 29.3
  TOP w0.102: RC82.2 160.68,72.47 160.09,71.87 159.58,71.87 159.57,71.86 159.27,71.86 v2(159.12,71.71)
  IN1 w0.084: v2(159.12,71.71) 158.78,71.71 157.16,73.32 156.06,73.32 154.69,74.69 148.73,74.69 147.11,73.08 139.67,73.08 137.96,74.79 137.55,74.79 v2(137.17,75.18)
  BOTTOM w0.076: v2(137.17,75.18) 136.87,75.48 UC1.AG4
  BOTTOM w0.102: v2(159.12,71.71) 158.57,71.16 v1(158.57,71.05)
SUSACK#: length 106.7
  TOP w0.102: UE2.A23 206.37,98.45 v2(206.44,98.53)
  IN3 w0.122: v2(154.31,63.31) 154.31,64 154.56,64.25 160.85,64.25 161.36,63.74 163.77,63.74 164.31,64.28 164.72,64.28 165.29,64.86 v2(165.29,65.09)
  IN4 w0.084: v2(206.44,98.53) 206.44,97.55 206.25,97.36 201.35,97.36 199.68,95.69 195.97,95.69 195.25,96.4 194.41,96.4 193.62,95.61 188.75,95.61 186.63,93.48 186.63,92.57 185.25,91.2 185.25,85.66 184.15,84.55 184.15,81.31 182.07,79.23 180.16,79.23 179.25,78.31 176.04,78.31 173.48,75.75 173.36,75.75 172.34,74.73 170.8,74.73 166.06,69.99 166.06,65.86 v2(165.29,65.09)
  BOTTOM w0.076: 141.14,74.34 138.7,74.34 138.4,74.05 UC1.AK2
  BOTTOM w0.102: 141.14,74.34 142.48,73 145.11,73 145.55,72.56 145.55,70.25 145.04,69.74 144.3,69.74 143.79,69.23 143.79,67.15 147.98,62.96 v1(148.36,62.96) 152.07,62.96 153.11,61.92 RC81.2 154.31,62.4 v2(154.31,63.31)
SUSCLK: length 72.4
  TOP w0.089: RC136.2 142.48,76.8 v1(142.71,76.57) 143.7,76.57 v2(144.15,76.13)
  TOP w0.102: v2(180.66,110.25) 180.23,109.82 RZ56.1
  IN4 w0.084: v2(173.78,94.62) 173.89,94.51 173.89,92.18 172.43,90.72 172.43,89.85 171.15,88.58 171.15,85.08 169.56,83.48 165.74,83.48 163.47,81.21 162.26,81.21 161.48,80.43 160.4,80.43 159.04,79.07 158.55,79.07 158.12,78.64 158.12,77.7 156.92,76.51 156.32,76.51 154.09,74.27 146,74.27 v2(144.15,76.13)
  BOTTOM w0.102: v2(180.66,110.25) 180.32,110.59 174.06,110.59 170.93,107.47 170.93,97.08 173.39,94.62 v2(173.78,94.62)
SUSCLK_R: length 6.3
  TOP w0.102: v2(135.71,76.78) 135.71,77.12 135.87,77.28 v1(136.04,77.28) 136.75,77.28 136.98,77.06 138.76,77.06 139.02,76.8 RC136.1
  BOTTOM w0.076: v2(135.71,76.78) 135.53,76.61 UC1.AE6
SW1: length 7.1
  TOP w0.102: 50.31,26.03 v2(50.24,25.96)
  IN1 w1.016: 51.08,25.73 51.09,25.75 51.09,25.71 52.02,24.78 52.02,20.84 52.21,20.65
  BOTTOM w0.102: PR112.1 v1(53.67,20.89)
  vias: v2(49.9,25.43) v2(51.93,19.68) v2(51.88,19.02) v2(51.88,18.39) v2(51.89,17.75) v2(52.54,19.68) v2(52.49,19.02) v2(52.49,18.39) v2(52.49,17.76) v2(53.15,19.65) v2(53.1,18.99) v2(53.09,18.38) v2(53.09,17.77)
SW2: length 6.5
  TOP w0.102: PR111.1 v1(37.67,25.78)
  IN1 w1.016: 38.64,23.99 38.64,24.78 39.94,26.09 42.18,26.09 42.19,26.08
  vias: v2(37.8,22.7) v2(37.8,22.03) v2(37.81,21.38) v2(38.41,22.7) v2(38.43,22.04) v2(38.41,21.34) v2(39,22.74) v2(39.03,22.05) v2(39.03,21.35) v2(39.63,22.74) v2(39.63,22.05) v2(39.65,21.35) v2(43.16,26.39) v2(43.17,25.77)
SW_1.35V:
  vias: v1(85.03,20.92) v2(84,20.01) v2(84.72,19.97) v2(85.46,19.96) v2(86.2,19.94) v2(86.58,19.36) v2(86.83,19.92) v2(86.82,18.76) v2(88,19.74) v2(88,19.13) v2(88.59,19.74) v2(88.59,19.13) v2(89.05,18.29) v2(89.17,19.13) v2(89.08,17.66) v2(89.08,17.02) v2(89.18,19.74)
SW_10_GRN#: length 8.7
  TOP w0.102: QL2.1 218.65,122.7 221.08,122.7 v1(221.5,122.28) v2(221.92,121.86) 221.92,120.99 RL30.2
  BOTTOM w0.102: UL4.41 221.4,124.07 221.92,123.55 v2(221.92,121.86)
SW_100_ORG#: length 5.3
  TOP w0.102: QL1.4 209.98,122.81 209.85,122.94 v2(209.64,122.94) 209.64,122.52 208.36,121.24 RL29.2
  BOTTOM w0.102: UL4.18 211.18,123.57 210.54,122.94 v1(210.25,122.94) v2(209.64,122.94)
SW_+V1.05SP: length 1.6
  TOP w0.102: PR305.1 v1(186.63,66.98)
  vias: v2(187.56,68.46) v2(188.23,68.46)
SW_ACTLED_YEL#: length 8.1
  TOP w0.102: QL1.1 207.94,124.11 v1(207.37,123.54) 207.14,123.3 v2(207.14,122.93)
  BOTTOM w0.102: v2(207.14,122.93) 207.77,122.29 210.95,122.29 211.39,121.85 211.97,121.85 212.22,122.1 UL4.17
SW_DPB_AUX: length 33.4
  IN1 w0.091: v2(149.43,119.12) 149.77,118.78 149.77,118.64 149.68,118.56 139.51,118.56 139.42,118.46 135.07,118.46 133.94,117.34 133.94,116.63 v2(133.64,116.32)
  IN2 w0.114: v2(133.64,116.32) 133.83,116.13 133.83,115.94 133.74,115.85 133.34,115.85 131.32,117.87 131.32,122.18 131.56,122.42 131.83,122.42 v2(132.02,122.23)
  BOTTOM w0.102: RV75.1 149.53,119.43 149.53,119.22 v2(149.43,119.12) 149.8,118.75 149.8,118.11 150.05,117.86 150.05,117.25 150.18,117.12 150.18,116.3 UV8.J13 ; CV119.2 131.12,122.02 131.51,122.42 131.83,122.42 v2(132.02,122.23)
SW_DPB_AUX#: length 33.2
  IN1 w0.091: v2(134.22,116.32) 134.12,116.43 134.12,117.27 135.14,118.29 139.49,118.29 139.58,118.38 149.75,118.38 149.94,118.57 149.94,119.04 v2(150.01,119.12)
  IN2 w0.114: v2(132.02,122.81) 131.82,122.61 131.48,122.61 131.12,122.26 131.12,117.79 133.26,115.65 133.82,115.65 134.03,115.86 134.03,116.13 v2(134.22,116.32)
  BOTTOM w0.102: RV82.1 149.85,119.85 149.85,119.28 v2(150.01,119.12) 150.01,118.2 150.27,117.95 150.27,117.34 150.4,117.21 150.4,116.74 UV8.J14 ; CV120.2 131.12,123.07 131.37,122.81 v2(132.02,122.81)
SW_DPB_AUX#_C: length 1.8
  BOTTOM w0.102: UV11.5 132.11,123.77 CV120.1
SW_DPB_AUX_C: length 1.9
  BOTTOM w0.102: CV119.1 132.4,121.59 132.62,121.82 UV11.2
SW_DPC_AUX: length 20.5
  IN4 w0.091: v2(162.63,110.81) 162.86,111.04 162.86,111.2 162.73,111.32 160.42,111.32 158.78,109.69 157.2,109.69 156.24,110.65 156.24,115.14 156.8,115.7 157,115.7 157.22,115.92 v2(157.22,116.2)
  BOTTOM w0.102: v2(162.63,110.81) 162.74,110.69 162.74,110.42 CV122.2 ; RV74.1 158.83,116.22 158.72,116.22 158.44,116.5 157.52,116.5 v2(157.22,116.2) 157.36,116.06 157.36,115.87 157.27,115.78 156.76,115.78 155.98,115 155.64,115 155.3,114.66 UV8.B11
SW_DPC_AUX#: length 20
  IN4 w0.091: v2(163.25,110.79) 163.03,111.02 163.03,111.27 162.8,111.5 160.34,111.5 158.71,109.86 157.27,109.86 156.41,110.72 156.41,115.07 156.87,115.53 157.07,115.53 157.34,115.79 157.38,115.79 157.6,116.01 v2(157.8,116.01)
  BOTTOM w0.102: v2(163.25,110.79) 163.19,110.79 162.96,110.56 162.96,110.28 163.06,110.18 CV123.2 ; UV8.A11 155.85,114.79 156.07,114.79 156.85,115.56 157.18,115.56 157.36,115.56 157.57,115.78 157.57,115.9 157.68,116.01 v2(157.8,116.01) 158.07,116.28 158.35,116.28 158.63,116.01 158.74,116.01 RV85.1
SW_DPC_AUX#_C: length 4.4
  BOTTOM w0.102: CV123.1 163.03,108.91 163.03,108.7 162.82,108.49 161.57,108.49 161.48,108.4 161.48,108.19 161.57,108.11 162.11,108.11 162.39,107.82 UV12.5
SW_DPC_AUX_C: length 4.3
  BOTTOM w0.102: CV122.1 162.82,108.94 162.82,108.79 162.73,108.7 161.48,108.7 161.27,108.49 161.27,108.19 161.17,108.09 160.6,108.09 160.44,107.93 UV12.2
SW_LAN_TX0+: length 62.6
  IN4 w0.084: v2(273.98,132.72) 273.56,133.15 272.82,133.15 270.76,135.22 261.66,135.22 253.88,127.43 237.72,127.43 237.39,127.1 234.04,127.1 233.14,126.2 225.07,126.2 224.54,126.74 220.57,126.74 220.16,127.15 220.16,127.6 v2(220.2,127.63)
  BOTTOM w0.089: v2(220.2,127.63) 220.13,127.56 220.13,126.81 220.22,126.72 UL4.38 ; v2(273.98,132.72) 274.24,132.72 274.62,132.34 TL1.6
SW_LAN_TX0-: length 62.5
  IN4 w0.084: v2(219.61,127.63) 219.78,127.47 219.78,126.99 220.41,126.36 224.38,126.36 224.91,125.82 233.3,125.82 234.2,126.72 237.55,126.72 237.88,127.05 254.03,127.05 261.82,134.83 270.6,134.83 272.21,133.22 272.21,132.68 272.34,132.55 272.55,132.55 v2(272.71,132.72)
  BOTTOM w0.089: UL4.37 219.72,126.69 219.81,126.78 219.81,127.44 v2(219.61,127.63) ; v2(272.71,132.72) 273.22,132.72 273.35,132.59 TL1.5
SW_LAN_TX1+: length 60.3
  IN4 w0.084: v2(269.21,133.15) 269.11,133.25 269.11,133.67 268.73,134.04 262.15,134.04 254.3,126.19 238.14,126.19 237.87,125.93 234.53,125.93 233.59,124.98 224.63,124.98 224.2,125.41 219.82,125.41 218.16,127.07 218.16,127.58 v2(218.26,127.68)
  BOTTOM w0.089: v2(218.26,127.68) 218.13,127.55 218.13,126.81 218.22,126.72 UL4.34 ; v2(269.21,133.15) 269.54,132.82 TL1.2
SW_LAN_TX1-: length 60.3
  IN4 w0.084: v2(217.68,127.68) 217.78,127.58 217.78,126.91 219.66,125.03 224.04,125.03 224.47,124.6 233.75,124.6 234.69,125.54 238.03,125.54 238.3,125.81 254.46,125.81 262.3,133.66 268.58,133.66 268.73,133.51 268.73,133.25 v2(268.62,133.15)
  BOTTOM w0.089: v2(217.68,127.68) 217.81,127.55 217.81,126.77 217.72,126.68 UL4.33 ; v2(268.62,133.15) 268.27,132.79 TL1.1
SW_LAN_TX2+: length 78.2
  IN4 w0.084: v2(215.53,128.07) 215.43,127.97 215.43,127.72 215.59,127.56 215.59,126.55 217.62,124.51 218.76,124.51 219.04,124.24 223.71,124.24 224.14,123.81 234.08,123.81 235.02,124.75 238.36,124.75 238.63,125.02 254.87,125.02 260.98,131.13 277.88,131.13 278.25,130.77 278.25,129.23 278.44,129.04 v2(278.45,129.04)
  BOTTOM w0.089: v2(278.45,129.04) 278.56,129.15 280.93,129.15 282.24,130.46 TL1.12 ; v2(215.53,128.07) 215.39,127.94 215.39,127.69 215.65,127.44 215.65,126.76 215.72,126.68 UL4.29
SW_LAN_TX2-: length 78.1
  IN4 w0.084: v2(214.94,128.07) 215.05,127.97 215.05,127.56 215.2,127.4 215.2,126.39 217.46,124.13 218.6,124.13 218.88,123.85 223.55,123.85 223.98,123.43 234.23,123.43 235.17,124.37 238.52,124.37 238.79,124.64 255.03,124.64 261.14,130.75 277.73,130.75 277.87,130.61 v2(277.87,129.04)
  BOTTOM w0.089: UL4.28 215.22,126.68 215.33,126.79 215.33,127.31 215.08,127.56 215.08,127.94 v2(214.94,128.07) ; v2(277.87,129.04) 277.87,129.18 278.16,129.47 280.79,129.47 281.12,129.79 281.12,130.2 280.97,130.36 TL1.11
SW_LAN_TX3+: length 74.8
  IN4 w0.084: v2(213.76,127.68) 213.56,127.48 213.56,126.79 215.08,125.28 215.08,124.64 217.09,122.63 219.2,122.63 219.63,123.06 223.22,123.06 223.65,122.63 236.1,122.63 236.95,123.49 238.17,123.49 238.62,123.04 240.18,123.04 240.46,123.32 246.04,123.32 246.26,123.54 250.59,123.54 250.62,123.57 252.99,123.57 253.2,123.37 254.34,123.37 254.78,123.82 256.08,123.82 261.52,129.25 274.23,129.25 274.37,129.39 274.83,129.39 v2(275.03,129.59)
  BOTTOM w0.089: v2(213.76,127.68) 213.5,127.42 213.5,126.86 213.72,126.63 UL4.25 ; v2(275.03,129.59) 274.77,129.33 274.66,129.33 274.51,129.47 274.51,129.81 274.73,130.03 275.52,130.03 275.91,130.42 276.35,130.42 277.16,131.22 TL1.8
SW_LAN_TX3-: length 74.9
  IN4 w0.084: v2(275.03,129.01) 274.53,129.01 274.39,128.87 261.67,128.87 256.24,123.43 254.94,123.43 254.5,122.99 253.04,122.99 252.83,123.19 250.78,123.19 250.74,123.16 246.41,123.16 246.2,122.94 240.61,122.94 240.33,122.66 238.46,122.66 238.01,123.1 237.11,123.1 236.26,122.25 223.49,122.25 223.07,122.68 219.79,122.68 219.36,122.25 216.93,122.25 214.7,124.48 214.7,125.12 213.18,126.64 v2(213.18,127.68)
  BOTTOM w0.089: UL4.24 213.22,126.63 213.18,126.67 v2(213.18,127.68) ; TL1.7 275.89,130.84 275.39,130.34 274.6,130.34 274.2,129.94 274.2,129.34 274.53,129.01 v2(275.03,129.01)
SW_MDP_AUX#_C: length 6
  TOP w0.102: UV502.5 239.14,119.13 238.44,118.43 238.44,118.35 238.31,118.22 238.19,118.1 v4(237.52,118.1) 236.21,118.1 235.88,118.43 235.41,118.43 235.4,118.44 234.98,118.44 CV513.1
SW_MDP_AUX_C: length 6.1
  TOP w0.102: CV512.1 234.86,118.66 v4(235.68,118.66) 235.96,118.66 236.3,118.32 237.24,118.32 237.26,118.34 237.77,118.34 237.8,118.32 238,118.32 238.18,118.49 238.18,118.68 238.04,118.82 237.34,118.82 237.19,118.97 UV502.2
SW_USB3RN1: length 82
  TOP w0.102: v2(128.23,133.69) 128.02,133.48 128.02,132.79 128.13,132.67 UI4.26 ; LI1.4 64.67,117.65 64.81,117.5 64.81,116.99 v2(64.77,116.95)
  IN1 w0.091: v2(128.23,133.69) 127.99,133.46 127.99,132.11 127.81,131.92 127.81,128.52 121.67,122.38 112.53,122.38 111.14,120.99 73.32,120.99 68.77,116.45 68.77,114.11 68.06,113.4 65.66,113.4 65,114.06 65,115.95 64.77,116.18 v2(64.77,116.95)
SW_USB3RP1: length 82
  TOP w0.102: LI1.1 65.51,117.6 65.42,117.5 65.1,117.5 65.03,117.43 65.03,117.33 v2(65.41,116.95) ; v2(127.64,133.69) 127.8,133.53 127.8,132.74 127.73,132.67 UI4.27
  IN1 w0.091: v2(65.41,116.95) 64.95,116.49 64.95,116.25 65.18,116.02 65.18,114.13 65.73,113.57 67.99,113.57 68.6,114.18 68.6,116.52 73.25,121.17 111.07,121.17 112.46,122.55 121.6,122.55 127.63,128.59 127.63,131.99 127.82,132.18 127.82,133.51 v2(127.64,133.69)
SW_USB3TN1: length 72.9
  TOP w0.102: v2(66.39,115.02) 66.46,115.09 66.46,115.45 CI4.2 ; v2(125.87,130.61) 126.01,130.47 126.25,130.47 126.3,130.52 UI4.30
  IN1 w0.091: v2(66.39,115.02) 66.39,114.42 66.61,114.21 67.5,114.21 67.87,114.58 67.87,116.62 73.02,121.77 110.82,121.77 112.18,123.12 121.36,123.12 127.03,128.8 127.03,130.05 126.47,130.61 v2(125.87,130.61)
SW_USB3TP1: length 72.9
  TOP w0.102: CI5.2 66.77,115.7 66.68,115.61 66.68,115.32 v2(66.98,115.02) ; v2(125.87,130.03) 126.09,130.25 126.17,130.25 126.3,130.12 UI4.31
  IN1 w0.091: v2(66.98,115.02) 66.56,114.61 66.56,114.5 66.68,114.38 67.43,114.38 67.7,114.65 67.7,116.69 72.95,121.94 110.75,121.94 112.11,123.29 121.28,123.29 126.86,128.87 126.86,129.98 126.4,130.44 126.28,130.44 v2(125.87,130.03)
SW_USBP0+: length 84.3
  TOP w0.102: v2(130.97,133.43) 131.28,133.11 131.28,132.93 131.19,132.85 131,132.85 130.93,132.78 UI4.19 ; UI3.3 60.65,118.25 60.49,118.1 60.49,118.02 v2(60.73,117.78)
  IN1 w0.091: v2(130.97,133.43) 130.97,133.43 131.28,133.73 131.28,133.88 130.87,134.29 127.39,134.29 125.39,132.29 125.39,128.29 122.42,125.32 121.58,125.32 120.03,123.78 110.99,123.78 109.75,122.54 96.65,122.54 96.24,122.95 70.81,122.95 66.15,118.29 60.54,118.29 60.42,118.17 60.42,118.08 60.72,117.78 v2(60.73,117.78)
SW_USBP0-: length 84.3
  TOP w0.102: UI4.18 131.33,132.68 131.5,132.84 131.5,133.37 v2(131.55,133.43) ; UI3.2 60.15,118.25 60.28,118.12 60.28,117.91 v2(60.15,117.78)
  IN1 w0.091: v2(60.15,117.78) 60.25,117.88 60.25,118.24 60.47,118.46 66.08,118.46 70.74,123.12 96.31,123.12 96.73,122.71 109.68,122.71 110.92,123.95 119.96,123.95 121.5,125.49 122.35,125.49 125.22,128.36 125.22,132.36 127.32,134.46 130.94,134.46 131.45,133.95 131.45,133.53 v2(131.55,133.43)
SW_USBP3+: length 115.5
  IN1 w0.091: v2(227.96,125.39) 227.64,125.08 227.64,125.02 227.36,124.74 224.82,124.74 224.32,125.24 219.83,125.24 218.71,126.36 213.61,126.36 211.48,124.23 206.73,124.23 206.48,123.98 197.77,123.98 196.15,125.61 177.93,125.61 177.66,125.34 165.42,125.34 164.35,124.28 162.63,124.28 160.94,125.97 156.71,125.97 156.2,126.47 152.91,126.47 151.22,124.79 144.52,124.79 144.28,125.02 133.15,125.02 132.9,125.28 131.45,125.28 131.26,125.47 131.26,125.7 v2(131.09,125.86)
  BOTTOM w0.102: UI5.1 130.29,125.52 130.44,125.36 131.05,125.36 131.21,125.52 131.21,125.75 v2(131.09,125.86) ; LI4.1 235.36,119.28 235.05,118.97 233.56,118.97 227.79,124.74 227.79,125.22 v2(227.96,125.39)
SW_USBP3-: length 115.7
  IN1 w0.091: v2(227.38,125.39) 227.47,125.3 227.47,125.09 227.29,124.91 224.89,124.91 224.39,125.41 219.9,125.41 218.78,126.53 213.54,126.53 211.41,124.4 206.65,124.4 206.41,124.16 197.85,124.16 196.22,125.78 177.74,125.78 177.49,125.53 165.36,125.53 164.28,124.45 162.7,124.45 161.01,126.14 156.78,126.14 156.28,126.65 152.83,126.65 151.15,124.96 144.59,124.96 144.36,125.19 133.23,125.19 132.97,125.45 131.52,125.45 131.43,125.54 131.43,125.62 v2(131.68,125.86)
  BOTTOM w0.102: UI5.2 130.29,124.99 130.44,125.15 131.14,125.15 131.42,125.43 131.42,125.61 v2(131.68,125.86) ; v2(227.38,125.39) 227.57,125.2 227.57,124.65 233.48,118.75 235.05,118.75 235.36,118.43 LI4.4
SYS_LED_MASK#: length 60.1
  TOP w0.102: v2(185.35,103.29) 185.33,103.29 185.33,103.31 186.12,104.09 UE1.B48 ; v2(202.19,118.42) 202.19,122.08 202.58,122.47 207.25,122.47 208.24,123.46 QL1.2 QL1.5 210.62,123.46 210.94,123.14 210.94,122.19 211.42,121.71 212.3,121.71 212.52,121.94 212.52,123.03 212.66,123.17 216.13,123.17 217.13,122.18 217.13,121.77 217.54,121.35 QL2.2 ; 186.63,114.1 186.3,114.43 UZ10.1 ; 186.63,114.1 186.63,112.07 187.94,110.76 187.94,109.3 RE21.2 187.53,108.61 v2(187.53,108.09) ; 186.63,114.1 187.71,114.1 v1(187.84,114.23) 188,114.39 188,115.94 188.57,116.51 190.57,116.51 v2(190.92,116.16) 190.92,115.54 191.33,115.13 QZ3.2
  IN4 w0.084: v2(202.19,118.42) 194.01,118.42 192.08,116.49 191.25,116.49 v2(190.92,116.16)
  BOTTOM w0.102: v2(185.35,103.29) 185.33,103.29 185.33,103.31 185.9,103.88 186.31,103.88 186.78,104.35 186.78,107.14 187.53,107.89 v2(187.53,108.09)
SYS_PWROK: length 216.7
  TOP w0.102: v3(70.54,38.1) 70.54,38.95 v2(69.93,39.56) 69.15,39.56 69.04,39.45 CC22.1 RC120.1 68.15,44.53 67.75,44.92 JXDP1.47 ; UE2.B7 209.75,91 209.53,91.23 v2(209.53,91.41)
  IN2 w0.089: v2(145.88,77.91) 145.88,73.19 146.46,72.61 ; 146.23,66.14 146.46,66.38
  IN2 w0.122: 146.46,66.38 146.69,66.6 146.69,72.38 146.46,72.61 ; v2(69.93,39.56) 70.07,39.42 70.47,39.42 73.76,42.71 73.76,45.36 77.23,48.82 132.22,48.82 139.7,56.3 139.7,60.63 145.21,66.14 146.23,66.14
  IN4 w0.084: v2(145.88,77.91) 145.99,77.79 147.26,77.79 148.24,76.81 151.73,76.81 159.6,84.68 160.68,84.68 163.12,87.12 163.59,87.12 166.52,90.05 169.06,90.05 172.63,93.62 172.63,95.35 175.16,97.87 175.16,98.82 177.86,101.52 179.84,101.52 180.24,101.92 184.63,101.92 185.45,101.11 187.67,101.11 188.28,101.72 190.19,101.72 190.76,101.15 197.08,101.15 198.42,102.49 202.94,102.49 203.37,102.06 206.83,102.06 v2(207.28,102.51)
  BOTTOM w0.076: v2(145.88,77.91) 145.88,76.22 144.53,74.87 143.69,74.87 143,75.56 139.9,75.56 139.49,75.97 139.13,75.97 139.01,75.84 138.7,75.84 138.4,75.55 UC1.AG2
  BOTTOM w0.102: v2(207.28,102.51) 207.36,102.51 208.66,101.21 208.66,99.3 209.72,98.24 209.72,97.03 210.45,96.29 210.45,92.33 v2(209.53,91.41)
SYS_RESET#: length 106.2
  TOP w0.102: v2(219.59,103.08) 219.4,103.27 219.4,103.89 219.71,104.2 JAPS1.13
  IN4 w0.084: v2(219.59,103.08) 220.08,102.58 220.08,102.24 219.81,101.97 218.68,101.97 215.38,98.67 212.88,98.67 209.97,101.58 209.48,101.58 208.1,102.95 198.15,102.95 197.49,102.29 190.5,102.29 189.93,102.86 187.19,102.86 186.72,102.39 180.05,102.39 179.65,101.99 177.67,101.99 174.69,99.01 174.69,98.07 172.17,95.55 172.17,93.82 168.87,90.51 166.1,90.51 163.73,88.15 162.4,88.15 160.87,86.62 160.87,85.82 160.19,85.14 159.29,85.14 v2(157.71,83.57) 156.64,83.57 155.63,82.56 155.63,81.39 152.76,78.52 151.92,78.52 151.23,77.83 148.21,77.83 147.74,78.3 140.53,78.3 v2(140.13,77.9)
  BOTTOM w0.076: UC1.AC3 137.77,77.51 139.74,77.51 v2(140.13,77.9)
  BOTTOM w0.102: UC4.4 159,84.24 RC77.2 158,83.86 v2(157.71,83.57)
TDI_IREF: length 8.8
  BOTTOM w0.203: UC1.B12 131.3,89.67 131.3,90.37 131.42,90.5 131.42,91.24 131.75,91.56 131.75,92.8 132.47,93.53 133.23,93.53 134.17,94.47 v1(134.17,95.44) 134.17,96.47 RC186.2
TDI_XDP_R: length 12.8
  TOP w0.102: v2(67,65.59) 67.63,65.59 v1(67.99,65.95) RC118.1 ; v2(65.75,70.59) 65.99,70.35 66.22,70.35 RC99.2 66.5,69.92 65.69,69.11 UC7.5
  IN2 w0.122: v2(65.75,70.59) 65.75,70.63 65.03,69.9 65.03,66.92 66.36,65.59 v2(67,65.59)
TDO_XDP: length 22
  TOP w0.102: JXDP1.52 68.77,52.6 RC117.2 69.3,56.43 69.3,57.36 67.14,59.51 v1(65.15,59.51) v2(64.49,59.51) ; RC115.1 RC98.2 65.69,67.15 v2(65.66,67.12) 65.18,67.61 UC7.2
  IN1 w0.084: v2(65.66,67.12) 65.47,66.93 65.47,66.33 65.01,65.87 65.01,60.04 v2(64.49,59.51)
TEST: length 4
  TOP w0.102: v1(228.4,83.84) RI37.1 RI36.2 228.1,81.92 227.14,80.96 UI7.14
THERMATRIP2#: length 6.1
  TOP w0.102: UE2.B34 201.62,96.88 200.69,97.81 v1(200.69,98.39) 200.69,99.08 201.03,99.42 CE36.1 200.95,99.63 200.55,99.63 200.41,99.5 QE4.1 199.9,100.24 RE69.2
THERMATRIP3#: length 31.5
  TOP w0.102: UE2.A2 211.38,88.75 v2(211.83,88.31) ; v1(190.91,87.62) 190.26,88.27 RPE6.1 188.34,88.27 188.22,88.14 188.22,86.92 188.09,86.8 v2(188.09,86.48)
  IN3 w0.122: v2(211.83,88.31) 211.08,87.56 204.49,87.56 204.16,87.89 200.99,87.89 200.84,88.04 199.58,88.04 198.66,87.11 191.81,87.11 190.82,88.1 189.43,88.1 188.09,86.76 v2(188.09,86.48)
THSEL_STRAP: length 11.2
  TOP w0.102: v2(201.9,101.59) 201.9,102.26 v1(202.2,102.56) RE78.1 ; UE2.B29 204.12,95.86 v2(203.62,95.35)
  BOTTOM w0.102: v2(201.9,101.59) 201.9,101.02 204.02,98.9 204.02,95.76 v2(203.62,95.35)
TMDS_CON_CLK: length 6.9
  TOP w0.102: LV3.3 91.2,127.86 91.51,128.18 91.51,128.41 91.26,128.65 90.72,128.65 90.71,128.67 90.53,128.67 90.4,128.54 90.15,128.29 89.64,128.29 89.39,128.54 v4(89.39,128.73) 89.39,129.25 90.2,130.06 90.54,130.06 90.82,130.34 90.82,130.51 JHDMI1.10
TMDS_CON_CLK#: length 6.9
  TOP w0.102: JHDMI1.12 91.04,130.45 91.04,130.25 90.63,129.85 90.29,129.85 89.6,129.16 89.6,129.01 89.61,129 89.61,128.63 89.74,128.5 90.06,128.5 90.19,128.63 90.19,128.63 90.44,128.88 v4(90.99,128.88) 91.34,128.88 91.73,128.5 91.73,128.17 92.05,127.85 LV3.2
TMDS_CON_N0: length 10.3
  TOP w0.102: LV12.2 95.8,128.1 95.7,128.21 95.29,128.21 95.17,128.33 v4(95.17,128.65) 95.17,129.29 95.31,129.43 95.31,131.14 95.16,131.3 94.92,131.53 94.55,131.62 94.26,131.62 94.08,131.54 93.89,131.54 93.55,131.62 93.33,131.62 93.05,131.49 92.53,131.62 92.32,131.62 92.1,131.52 91.9,131.52 91.5,131.66 91.05,131.54 90.84,131.54 90.62,131.61 90.12,131.61 89.96,131.76 JHDMI1.9
TMDS_CON_N1: length 10.3
  TOP w0.102: JHDMI1.6 88.08,130.49 88.08,129.47 87.8,129.19 86.31,129.19 86.18,129.06 86.18,127.17 86.3,127.05 86.68,127.05 86.79,127.17 86.79,128.43 87.05,128.68 v4(87.57,128.68) 88.02,128.68 88.25,128.45 88.25,128.17 88.57,127.85 LV10.2
TMDS_CON_N2: length 6.8
  TOP w0.102: JHDMI1.3 86.36,131.47 86.22,131.47 85.87,131.11 85.87,130.74 85.74,130.61 85.74,130.51 85.96,130.29 85.96,130 v4(85.7,129.74) 85.36,129.4 85.07,129.4 84.9,129.57 84.72,129.57 84.38,129.22 84.38,129.07 84.78,128.67 84.78,128.64 84.83,128.59 84.83,128.22 84.95,128.1 LV6.2
TMDS_CON_P0: length 10.4
  TOP w0.102: LV12.3 94.95,128.37 94.94,128.39 94.94,128.92 94.95,128.93 94.95,129.38 95.1,129.52 95.1,131.05 94.81,131.34 94.6,131.39 94.49,131.41 94.37,131.41 94.12,131.32 93.94,131.32 93.51,131.41 93.36,131.41 93.07,131.29 93.07,131.28 92.5,131.41 92.37,131.41 92.14,131.31 91.87,131.31 91.49,131.44 91.07,131.33 90.81,131.33 90.59,131.4 89.63,131.4 JHDMI1.7
TMDS_CON_P1: length 10.3
  TOP w0.102: LV10.3 87.72,127.84 88.03,128.15 88.03,128.36 87.93,128.46 87.85,128.46 87.83,128.45 87.3,128.45 87.29,128.46 87.14,128.46 87.01,128.34 87.01,127.08 86.76,126.83 v4(86.5,126.83) 86.22,126.83 85.97,127.08 85.97,129.15 86.22,129.4 87.71,129.4 87.86,129.56 87.86,130.47 JHDMI1.4
TMDS_CON_P2: length 6.8
  TOP w0.102: LV6.3 84.1,127.82 84.61,128.34 84.61,128.5 v4(84.41,128.7) 84.16,128.95 84.16,129.33 84.61,129.78 84.99,129.78 85.16,129.62 85.24,129.62 85.74,130.11 85.74,130.2 85.52,130.42 85.52,130.7 85.65,130.83 85.65,131.2 86.18,131.74 86.18,131.84 JHDMI1.1
TOUCH_PANEL_INTR#: length 81.4
  TOP w0.102: RPC18.6 151.47,82.94 151.22,83.19 151.22,83.34 150.73,83.82 147.61,83.82 147.46,83.97 v1(147.08,83.97) 141.51,83.97 v2(140.77,83.23)
  IN2 w0.122: v2(140.77,83.23) 140.27,83.73 140.27,86.86 138.75,88.38 138.75,93.86 136.41,96.19 135.17,96.19 134.05,97.31 134.05,99.75 132.56,101.24 132.08,101.24 131.71,101.6 131.71,104.55 132.37,105.22 132.37,105.51 133.17,106.31 133.17,111.56 130.4,114.33 117.62,114.33 116.07,115.88 106.56,115.88 v2(105.16,117.28)
  BOTTOM w0.076: UC1.P3 137.77,82 138.29,82 138.49,82.2 138.49,82.38 138.7,82.59 139.02,82.59 139.22,82.78 140.32,82.78 v2(140.77,83.23)
  BOTTOM w0.102: JEDP1.5 104.47,116.96 104.78,117.28 v2(105.16,117.28)
TOUCH_SCREEN_PD#: length 7.7
  TOP w0.102: T96.1 182.93,108.4 v2(182.93,108.16) ; UE1.B55 184.94,106 v2(184.46,105.53)
  BOTTOM w0.102: v2(182.93,108.16) 182.93,108.74 183.2,109.01 184.33,109.01 184.64,108.7 184.64,105.7 v2(184.46,105.53)
TOUCHPAD_INTR#: length 16.4
  TOP w0.102: v2(134.56,82.48) 135.03,82.01 138.26,82.01 138.79,82.54 141.39,82.54 141.44,82.59 v1(141.75,82.59) 142.09,82.59 142.14,82.54 145.25,82.54 145.39,82.68 147.99,82.68 148.21,82.46 RPC3.7
  BOTTOM w0.076: v2(134.56,82.48) 134.56,81.39 UC1.U7
TP_DC_TEST_B2: length 6
  BOTTOM w0.254: RC192.2 v1(141.8,90.72) 139.27,90.72 UC1.B2
TP_LAN_JTAG_TCK: length 2.5
  TOP w0.102: RL2.2 205.74,119.66 206.55,118.86 UL1.35
TP_LAN_JTAG_TDI: length 1.3
  TOP w0.102: T88.1 207.75,119.35 UL1.32
TP_LAN_JTAG_TDO: length 1.4
  TOP w0.102: UL1.34 206.95,118.99 T89.1
TP_LAN_JTAG_TMS: length 2.5
  TOP w0.102: UL1.33 207.35,119.65 RL1.2
TPM_PIRQ#: length 83.9
  TOP w0.089: v2(144.15,88) 144.85,87.3 RC247.2
  TOP w0.102: UZ1.20 189.07,55.9 v2(189.21,56.04)
  IN1 w0.084: v2(145.47,67.43) 145.84,67.06 145.84,66.35 148.46,63.73 154.11,63.73 155.57,65.2 159.54,65.2 163.91,60.83 165.35,60.83 166.04,60.14 166.28,60.14 170.62,55.8 182.59,55.8 182.83,56.04 v2(189.21,56.04)
  IN2 w0.089: v2(137.82,81.17) 138.05,81.17 140.53,78.69 140.53,71.62 140.22,71.31 140.22,70.23 140.59,69.87 144.52,69.87 145.47,68.91 v2(145.47,67.43)
  IN3 w0.089: v2(137.82,81.17) 137.82,81.24 140.08,83.51 140.08,86.74 141.34,88 v2(144.15,88)
  BOTTOM w0.076: UC1.T3 137.52,81.47 v2(137.82,81.17)
TRST#_XDP: length 24.3
  TOP w0.102: v2(62.14,59.65) v1(63.02,59.65) 64.06,59.65 64.63,60.23 65.94,60.23 66.42,59.74 67.24,59.74 69.52,57.45 69.52,54.49 69.25,54.22 JXDP1.54 ; UC7.12 61.42,68.11 v2(61.03,68.51)
  IN1 w0.084: v2(62.14,59.65) 62.14,66.61 62.08,66.67 62.08,67.45 v2(61.03,68.51)
UG_3V: length 10.8
  TOP w0.102: v1(36.79,21.31) 37.13,20.98 PQ100.4
  IN1 w1.016: 37.65,19.23 37.65,19.22 39.71,19.22 40.74,20.26 40.74,23.82 41.42,24.49 42.85,24.49 42.87,24.48
  vias: v2(36.55,19.7) v2(36.54,19.05) v2(43.79,24.21) v2(44.38,24.22)
UG_5V: length 6.4
  IN1 w1.016: 50.79,23.55 50.79,17.78
  BOTTOM w0.102: v2(49.38,23.99) v1(49.38,24.58)
  vias: v2(50.04,23.99) v2(50.65,16.75) v2(50.64,16.16)
UIM_CLK: length 223.1
  TOP w0.102: v2(66.92,14.88) 67.62,15.58 JSIM1.3 67.62,17.4 67.31,17.71 66.94,17.71 66.49,18.16 CZ65.1 66.94,18.91 v1(66.94,20.3)
  IN3 w0.122: v2(66.92,14.88) 66.92,11.29 70.74,7.46 148.14,7.46 149.12,6.48 172.32,6.48 173.31,7.47 210.23,7.47 216.97,14.21 216.97,37.94 v2(220.26,41.23)
  IN4 w0.084: v2(220.26,41.23) 219.78,41.71 219.07,41.71 216.14,44.64 216.14,47.16 217.03,48.05 217.03,54.63 212.66,58.99 212.66,61.53 211.97,62.23 211.97,63.34 v2(211.7,63.6)
  BOTTOM w0.102: v2(211.7,63.6) 211.79,63.69 211.79,64.49 211.95,64.66 JNGFF2.24
UIM_DATA: length 224.5
  TOP w0.102: v2(66.92,15.46) JSIM1.7 66.92,17.15 66.68,17.39 65.92,17.39 65.6,17.71 CZ63.1 64.98,19.08 64.51,19.08 v1(64.34,19.24)
  IN3 w0.122: v2(66.92,15.46) 66.7,15.46 66.49,15.25 66.49,11.11 70.57,7.03 147.96,7.03 148.94,6.05 172.5,6.05 173.49,7.04 210.41,7.04 217.4,14.03 217.4,37.77 220.83,41.2 220.83,41.2 v2(220.88,41.25)
  IN4 w0.084: v2(212.32,63.64) 212.37,63.59 212.37,62.45 213.1,61.73 213.1,59.16 217.41,54.84 217.41,47.89 216.53,47 216.53,44.8 219.23,42.1 220.05,42.1 220.88,41.27 v2(220.88,41.25)
  BOTTOM w0.102: JNGFF2.26 212.45,64.89 212.37,64.81 212.37,63.69 v2(212.32,63.64)
UIM_DET: length 221.5
  TOP w0.102: v1(64.47,17.91) 64.82,17.56 JSIM1.9 v2(64.82,15.46)
  IN3 w0.122: v2(64.82,15.46) 64.82,10.7 68.92,6.59 147.79,6.59 148.77,5.62 172.68,5.62 173.67,6.61 210.59,6.61 217.83,13.85 217.83,37.59 v2(221.52,41.28)
  IN4 w0.084: v2(221.52,41.28) 221.7,41.46 221.7,43.89 218.95,46.64 218.95,54.32 219.6,54.98 219.6,59.56 219.23,59.93 219.23,63.5 v2(219.86,64.14)
  BOTTOM w0.102: v2(219.86,64.14) 220.45,64.72 JNGFF2.58
UIM_RESET: length 219.8
  TOP w0.102: JSIM1.2 v2(69.02,15.46) ; v1(211.6,62.63) 211.6,63.1 211.1,63.6 v2(211.1,63.62)
  IN3 w0.122: v2(219.66,41.23) 216.55,38.12 216.55,14.38 210.06,7.89 173.14,7.89 172.15,6.9 149.3,6.9 148.3,7.9 70.92,7.9 68.56,10.27 68.56,15 v2(69.02,15.46)
  IN4 w0.084: v2(219.66,41.23) 217.72,41.23 215.75,43.2 215.75,47.32 216.64,48.21 216.64,54.45 212.27,58.82 212.27,61.34 211.56,62.06 211.56,63.16 v2(211.1,63.62)
  BOTTOM w0.102: CZ64.1 68.2,14.64 v2(69.02,15.46) ; v2(211.1,63.62) 211.1,64.53 211.45,64.88 JNGFF2.22
USB3RN1: length 53.6
  TOP w0.102: UI4.5 129.33,128.37 129.24,128.28 129.24,127.82 v2(129.44,127.62)
  IN4 w0.091: v2(127.22,86.67) 126.9,86.35 126.75,86.35 126.34,86.76 126.34,89.82 123.13,93.03 123.13,94.91 121.03,97.01 121.03,105.74 123.4,108.11 125.7,108.11 126.75,109.16 128.58,109.16 129.83,110.42 129.83,112.06 129.56,112.33 129.56,112.99 128.68,113.87 128.68,117.18 128.08,117.78 128.08,119.47 128.68,120.07 128.68,126.56 129.03,126.91 129.03,127.21 v2(129.44,127.62)
  BOTTOM w0.076: UC1.G20 127.55,86.35 v2(127.22,86.67)
USB3RN1_D-: length 10.8
  TOP w0.102: LI1.3 64.67,120.28 64.96,120.58 v4(64.96,121.14) 64.96,121.77 65.16,121.96 DI1.1 DI1.9 65.16,123.6 65.31,123.75 65.31,124.78 63.64,126.44 63.64,127.31 63.03,127.92 63.03,128.46 62.96,128.54 JUSB1.5
USB3RN2: length 116.4
  TOP w0.102: CI31.1 224.07,86.79 224.07,86.9 v2(223.88,87.1)
  IN1 w0.084: v2(128.2,87.32) 128.2,87.3 128.45,87.05 128.54,87.05 128.59,87.1 128.59,88.79
  IN1 w0.091: 128.59,88.79 128.59,90.6 128.9,90.91 128.9,93.37 131.15,95.62 131.64,95.62 132.66,96.64 137.03,96.64 137.3,96.37 139.72,96.37 140.15,95.94 147.26,95.94 148.39,97.07 157.11,97.07 157.98,96.21 170.4,96.21 175.07,91.54 175.72,91.54 176.08,91.18 178.04,91.18 180.41,88.81 183.2,88.81 188.04,83.97 190.62,83.97 192.12,82.48 197.69,82.48 198.37,83.16 199.75,83.16 201.05,81.86 203.23,81.86 205.43,84.06 208.77,84.06 209.87,82.95 210.29,82.95 210.66,82.59 213.37,82.59 214.17,83.39 221.04,83.39 224.1,86.45 224.1,86.88 v2(223.88,87.1)
  BOTTOM w0.076: v2(128.2,87.32) 128.2,87.39 128.45,87.65 UC1.E18
USB3RN2_IO: length 17.3
  TOP w0.102: JIO1.16 220.7,66.7 221.71,66.7 221.77,66.64 221.77,66.48 221.83,66.41 222.53,66.41 225.47,69.35 v4(225.47,77.02) 225.47,77.47 225.25,77.69 225.01,77.69 224.86,77.84 224.84,77.84 224.32,78.36 224.32,78.37 224.18,78.52 224.18,78.98 223.9,79.26 UI7.8
USB3RN2_RP: length 2
  TOP w0.102: UI7.23 223.9,84.35 224.04,84.49 224.04,85.21 CI31.2
