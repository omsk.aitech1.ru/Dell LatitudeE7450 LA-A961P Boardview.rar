# Allegro board LAA961PR10-1007A.brd (continued)
## Via types (continued)
v3: diameter 0.406, hole 0.203, TOP to BOTTOM, 116 vias
v4: diameter 0.508, hole 0.254, TOP to BOTTOM, 262 vias
v5: diameter 0.432, hole 0.178, TOP to BOTTOM, 72 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
0.675V_DDR_VTT_ON: length 30.4
  TOP w0.508: v2(71.63,17.22) 72.06,17.66 74.86,17.66 76.86,15.65 76.86,14.46 78.37,12.94 78.37,8.73 78.69,8.42 v1(91.52,8.42) 94.15,8.42 94.19,8.45
  BOTTOM w0.508: PR210.1 v2(71.63,17.22)
1.05V_M_PWRGD: length 50.3
  IN1 w0.254: v2(160.2,72.84) 160.34,72.84 160.8,72.38 160.8,71.66 162.56,69.89 162.56,68.62 162.94,68.24 162.94,67.43 v2(164.34,66.03)
  IN3 w0.254: v2(188.9,62.37) 187.02,60.49 173.36,60.49 171.24,62.61 168.77,62.61 165.36,66.03 v2(164.34,66.03)
  BOTTOM w0.102: PR313.1 v2(188.9,62.37)
  BOTTOM w0.254: RC27.1 156.1,81.28 155.3,80.48 v1(155.3,75.44) 155.3,74.82 156.47,73.65 159.34,73.65 160.15,72.84 v2(160.2,72.84)
1.05V_MODPHY_EN: length 66
  TOP w0.102: v2(134.46,104.08) 134.62,103.91 134.62,102.7 134.53,102.61 QZ6.3 ; QZ10.3 165.65,79.15 CZ25.1 RZ5.2 165.39,78.22 v1(164.56,79.05) 163.9,79.72 163.9,82.48 163.77,82.6 163.77,83.37 164.54,84.13 164.54,96.64 163.45,97.72 163.45,101.6 163.96,102.1 v2(163.96,104.77)
  IN3 w0.122: v2(163.96,104.77) 162.82,103.62 161.61,103.62 161.1,104.13 148.87,104.13 145.23,107.78 139.23,107.78 137.11,105.66 135.75,105.66 134.46,104.37 v2(134.46,104.08)
1.5VSP: length 1.5
  BOTTOM w0.102: PC403.1 193.79,87.35 193.08,88.07 193.08,88.27 v1(192.94,88.41)
1.35V_B+: length 25.6
  IN3 w0.508: v2(86.46,13.44) 86.44,13.41 86.44,12.16 85.8,11.52 74.67,11.52 74.07,12.12 74.07,13.54 74.49,13.96 74.49,15.61 73.57,16.53 73.57,19.29 72.09,20.78 v2(71.38,20.78)
  BOTTOM w0.254: PR206.1 v2(71.38,20.78)
  vias: v1(87.75,15.93)
1.35V_FB:
  vias: v1(73.4,13.68)
3.3V_CAM_EN#: length 101
  TOP w0.102: v2(114.62,121.69) 111.35,121.69 v1(110.93,121.27) 108.18,118.52 QZ1.2 ; v2(143.22,72.56) 143.64,72.14 145.28,72.14 148.42,75.29 153.31,75.29 154.14,76.11 154.14,76.93 RC174.1
  IN2 w0.089: v2(143.22,72.56) 143.74,73.08 144.34,73.08 145.28,74.02 145.28,78.49
  IN2 w0.122: v2(114.62,121.69) 120.28,116.03 127.61,116.03 128.07,115.57 130.57,115.57 135.1,111.04 135.1,106.63 136.87,104.86 136.87,99.11 137.11,98.87 137.11,96.71 138.58,95.24 140.91,95.24 141.44,94.71 141.44,93.51 145.56,89.39 145.56,87.2 145.94,86.82 145.94,79.15 145.28,78.49
  BOTTOM w0.076: UC1.AM4 137.16,72.88 137.64,72.88 137.68,72.85 138.46,72.85 138.63,73.01 138.94,73.01 139.07,73.14 139.64,73.14 140.55,72.23 141.16,72.23 141.39,72 142.66,72 v2(143.22,72.56)
3.3V_HDD_EN: length 103.9
  TOP w0.102: UL3.5 192.82,107.99 191.92,107.09 v2(191.92,106.73) 192.01,106.65 v1(193,106.65) 193.68,105.97 RN6.2 RN7.1
  IN1 w0.084: v2(140.7,84.95) 140.7,84.85 141.31,84.24 147.4,84.24 149.88,81.76 150.81,81.76 151.61,82.55 153.8,82.55 156.58,85.33 159.74,85.33 161.06,86.66 161.54,86.66 162.71,85.48 163.62,85.48 164.11,85.97 166.03,85.97 168.15,83.85 169.11,83.85 170.5,82.47 171.56,82.47 174.73,79.3 177.13,79.3 178.8,77.63 179.07,77.63 179.65,77.05 179.65,76.69 180.03,76.31 188.31,76.31 v2(189.49,75.14)
  IN2 w0.122: v2(189.49,75.14) 189.49,76.97 191.58,79.06 191.58,84.66 191.01,85.24 191.01,87.91 190.48,88.44 189.53,88.44 188.77,89.2 188.77,91.04 189.54,91.81 190.57,91.81 192.21,93.46 192.21,99.01 192.93,99.72 192.93,100.6 192.4,101.12 192.4,104.58 191.76,105.22 191.76,106.57 v2(191.92,106.73)
  BOTTOM w0.102: UC1.K2 138.57,84.95 v2(140.7,84.95)
3.3V_TP_EN: length 14.8
  TOP w0.089: v2(137.21,84.17) 137.21,84.43 v1(137.63,84.85) 139.02,86.24 139.39,86.24 139.78,86.63 139.78,87.84 142.15,90.22 142.15,90.23 142.66,90.74 142.66,91.92
  TOP w0.102: RPC16.8 143.06,94.97 142.66,94.58 142.66,91.92
  BOTTOM w0.102: v2(137.21,84.17) 136.57,84.17 136.32,83.93 UC1.L5
3.3V_TS_EN: length 53.7
  TOP w0.089: 141.7,91.92 141.7,90.26 137.83,86.4 136.94,86.4 136.48,85.93 136.48,84.76 v2(135.15,83.43)
  TOP w0.102: RPC16.6 142.06,94.45 v2(141.88,94.28) 141.88,93.71 v1(141.82,93.65) 141.7,93.53 141.7,91.92
  IN2 w0.122: v2(141.88,94.28) 141.88,96.11 140.78,97.21 140.46,97.21 139.45,96.19 138.88,96.19 138.23,96.84 138.23,98.45 137.37,99.31 137.37,105.06 135.63,106.8 135.63,111.22 130.55,116.29 128.62,116.29 126.86,118.05 v2(126.86,121.24)
  BOTTOM w0.089: UC1.N7 134.88,83.16 v2(135.15,83.43)
  BOTTOM w0.102: v2(126.86,121.24) 126.86,121.25 126.63,121.49 QV7.2
3.3V_WWAN_EN: length 110.6
  TOP w0.102: UZ2.5 192.6,43.79 192.66,43.74 192.66,42.74 RZ40.2 v2(193.49,42.64) 193.91,42.64 v1(194.31,42.23) ; v2(185.74,100.24) 186.59,101.09 UE1.B42
  IN2 w0.122: v2(192.24,100.18) 191.92,99.86 191.74,99.86 190.97,99.09 190.97,96.9 191.71,96.16 191.71,93.79 190.89,92.96 189.98,92.96 187.68,90.65 187.68,89.44 186.26,88.02 186.26,86.76 188.27,84.74 188.27,82.01 190.16,80.13 190.16,79.38 187.35,76.57 184.54,76.57 182.91,74.95 178.9,74.95 175.94,71.98 172.07,71.98 170.54,70.46 170.54,67.53 169.71,66.7 169.71,65.21 171.46,63.46 171.46,49.85 v2(172.07,49.24)
  IN3 w0.122: v2(192.24,100.18) 191.84,99.77 189.98,99.77 189.74,100.02 189.74,100.47 189.54,100.68 187.31,100.68 187.03,100.96 186.46,100.96 v2(185.74,100.24) ; v2(172.07,49.24) 172.16,49.34 186.36,49.34 188,47.69 188,44.97 190.34,42.64 v2(193.49,42.64)
+0.9V_LAN: length 17.2
  TOP w0.203: UL1.40 204.08,116.24 v2(203.77,115.94) ; CL11.1 204.08,112.64 204.88,113.44 UL1.47 ; v2(208.47,113.2) 208.7,113.2 208.95,112.95 UL1.8 ; v2(204.12,113.4) 204.56,113.84 UL1.46 ; UL1.43 204.53,115.04 v2(204.47,114.99) ; v2(210.38,116.21) 210.81,116.64 UL1.22 ; v2(206.44,116.55) 206.44,117.21 206.21,117.44 UL1.37 ; CL8.1 211.29,110.47 211.29,110.56 210.15,111.7 UL1.11
  TOP w0.254: UL1.16 v2(212.23,114.24)
  TOP w0.508: CL8.1 211.91,110.38 211.91,110.81 v2(211.78,110.95) ; CL11.1 v2(203.34,113.31)
  BOTTOM w0.457: CL10.1 211.98,114.49 v2(212.23,114.24)
  vias: v1(210.04,110.04) v2(204.59,119.45) v2(205.22,119.45) v2(208.21,110.76) v2(210.06,110.73)
+0.675V_DDR_VTT: length 63.4
  TOP w1.524: 121.01,20.09 121.01,8.11 119.8,6.9 78.3,6.9 76.75,8.45 76.75,11.05
  BOTTOM w0.356: v2(120.73,30.36) 120.15,30.93 120.15,32.14 JDIMM1.203 ; JDIMM1.204 120.45,25.34
  vias: v2(76.1,12.49) v2(76.77,12.47) v2(77.42,12.46) v2(120.72,29.77) v2(121.16,25.45) v2(121.16,24.69) v2(195.18,30.48) v2(195.18,29.9) v2(195.77,30.53) v2(195.77,29.9) v2(195.71,27.8) v2(195.71,27.17) v3(120.65,21.39)
+0.675V_P:
  vias: v3(78.88,13.45)
+1.2V_LDO: length 30.1
  TOP w0.203: UR1.1 24.96,21.89 25.34,22.27 25.34,23.55 25.31,23.57 25.47,23.73 ; CR10.2 19.55,23.3 20.04,23.3 20.89,22.44 UR1.10 ; CR22.2 21.19,14.38 21.01,14.56 21.01,14.99 21.29,15.27 UR1.28 ; UR1.31 22.49,15.07 22.53,15.03 22.53,14.39 22.61,14.32 22.61,13.95 CR21.2 ; CR13.2 29.29,17.82 28.96,18.15 28.36,18.15 28.29,18.08 26.92,18.08 26.76,18.24 UR1.41 ; UR1.36 24.49,15.47 24.59,15.37 v2(24.96,15.37)
  TOP w0.508: v2(18.61,25.45) 18.67,25.45 19.24,24.88 CR9.2 19.04,24.55 CR10.2 ; CR13.2 29.47,17.69 29.07,17.3 v2(28.6,17.3) ; v2(24.06,13.29) 23.48,13.86 CR21.2 CR22.2
  IN2 w0.508: v2(28.6,17.3) 28.6,13.16 28.36,12.92 26.2,12.92 25.83,13.29 v2(24.06,13.29)
  vias: v1(26.85,23.89) v2(26.42,26.33) v2(26.39,25.66)
+1.05V_M: length 63.6
  TOP w0.508: RC18.2 77.74,75.54 78.74,74.54 v3(82.36,74.54) 87.32,74.54 v2(87.52,74.74) ; v2(146.66,77.07) 146.64,77.04 RC300.1
  IN2 w0.508: v2(87.52,74.74) 103.32,74.74 104.6,76.03 122.61,76.03 123.21,76.62 125.16,76.62 125.58,76.2 127.51,76.2 127.85,75.86 129.94,75.86 130.55,76.47 v2(130.55,76.56)
  BOTTOM w0.203: v2(132.57,77.14) 132.19,77.14 131.54,76.49 UC1.AG13 ; v2(130.55,76.56) 130.73,76.38 UC1.AG14
  BOTTOM w0.254: v2(132.57,76.51) 132.76,76.51 133.03,76.78 UC1.AE9 ; UC1.AF9 v2(134.41,75.83) 134.41,75.53 UC1.AG8
  BOTTOM w0.508: CC62.1 158.09,75.86 v2(157.53,76.42)
  vias: v2(131.19,99.57) v2(131.64,99.95) v2(132.15,99.35) v2(132.22,99.93) v2(168.85,61.66) v2(168.85,61.08) v2(169.04,63.73) v2(169.08,63.1) v2(169.43,61.66) v2(169.43,61.08) v2(169.62,63.73) v2(169.66,63.1) v2(170.02,61.66) v2(170.02,61.08) v2(170.21,63.73) v2(170.25,63.1)
+1.05V_MODPHY:
  vias: v2(132.81,102.73) v2(132.81,102.15) v2(135.81,98.62) v2(136.4,98.62) v3(129.73,102.48)
+1.05V_MODPHY_PCH: length 4.1
  TOP w0.508: v2(132.56,82.87) 132.36,83.06 CC44.1 ; v2(128.83,96.92) 128.37,97.37 CC43.1 ; v2(133.05,83.45) 133.09,83.49 CC40.1
  BOTTOM w0.127: v2(128.4,99.24) v1(127.43,99.24)
  vias: v2(128.4,100.13) v2(128.78,99.69)
+1.05V_MP: length 17.9
  IN2 w0.254: v2(193.06,62.27) 192.62,61.84 176.27,61.84 175.62,62.49 v2(175.61,62.49)
  vias: v1(193.56,62.08)
+1.5V_RUN: length 102.5
  TOP w0.089: v2(130.07,85.33) 130.28,85.33 v3(130.61,85.66)
  TOP w0.508: v2(208.27,77.89) 208.59,77.57 RA3.1
  IN2 w0.508: v2(208.79,85.78) 209.25,85.78 209.65,85.38 209.65,84.82 208.93,84.1 208.93,79.99 208.27,79.33 v2(208.27,77.89)
  IN3 w0.254: v2(130.07,85.33) 130.7,84.7 133.01,84.7 133.73,83.99 133.73,79.61 134.16,79.18 136.62,79.18 136.71,79.09 139.64,79.09 140.09,78.64
  IN3 w0.508: v2(208.79,85.78) 207.74,86.83 204.24,86.83 203.87,87.2 200.89,87.2 200.1,86.41 199.14,86.41 v2(198.36,85.64) 198.18,85.46 192.54,85.46 191.42,84.33 187.75,84.33 186.45,85.63 183.17,85.63 181.56,84.01 167.25,84.01 166.69,84.57 162.52,84.57 162.19,84.9 156.53,84.9 155.67,84.04 148.62,84.04 145.99,81.41 145.99,79.29 145.66,78.96 145.58,78.96 145.26,78.64 140.09,78.64
  BOTTOM w0.254: v2(130.07,85.33) 130.36,85.04 UC1.J15
+1.05V_RUN: length 289.4
  TOP w0.254: CE25.1 198.96,86.3 v2(199.9,87.24) 200.03,87.24 200.79,88 UE2.B51
  TOP w0.279: CC19.1 65.85,55.49 66.75,54.59 JXDP1.44 ; JXDP1.43 66.75,45.51 66.13,44.89 v2(66.11,44.89)
  TOP w0.457: RC117.1 68.77,57.13 v2(68.39,57.51)
  TOP w0.508: CC18.1 65.36,42.28 66.11,43.03 v2(66.11,44.89) ; CC70.1 128.65,84.52 129.15,85.03 v2(129.15,85.37) ; CC58.1 134.05,77.14 v2(134.41,76.78) ; v2(134.56,83.43) 133.74,82.62 CC53.1 ; CC79.1 124.59,102.48 124.91,102.8 v2(125.48,102.8) ; v2(100.78,96.26) 100.14,96.89 RC196.2 ; CC59.1 131.31,84.63 v2(132,85.32) ; CC85.1 127.04,95.3 v2(126.66,95.69) 126.62,95.72 CC60.1 ; v2(126.76,81.62) 126.33,82.05 CC71.1 ; v2(65.2,55.09) 65.2,55.33 CC19.1 65.23,55.98 64.85,56.37 RC197.1 ; RE70.1 199.08,102.1 v2(199.08,101.62)
  IN2 w0.508: v2(199.9,87.24) 200.56,87.9 200.56,97.42 200.09,97.89 200.09,100.61 v2(199.08,101.62) 199.08,102.37 199.9,103.19 199.9,105.25 198.5,106.65 198.5,108.39 195.9,110.99 192.79,110.99 192.4,110.6 v2(192.4,110.28) ; v2(126.15,54.38) 78.09,54.38 72.85,49.14 70.36,49.14 v2(66.11,44.89)
  IN3 w0.508: v2(129.51,75.1) 130.99,75.1 131.77,75.87 133.08,75.87 133.99,76.78 v2(134.41,76.78) ; v2(126.66,95.69) 127.19,95.69 127.64,95.24 127.38,94.99 124.78,94.99 122.94,96.83 111.57,96.83 111.06,97.34 106.68,97.34 105.6,96.26 v2(100.78,96.26) 99.63,95.11 97.41,95.11 93.96,91.66 93.96,86.74 v2(94.3,86.4) ; v2(66.11,44.89) 65.86,45.13 65.86,51.73 65.2,52.39 v2(65.2,55.09)
  IN4 w0.508: v2(126.66,95.69) 126.66,95.82 126.29,96.19 126.29,97.15 125.95,97.49 125.07,97.49 124.59,97.97 124.59,102.23 125.16,102.8 v2(125.48,102.8) ; v2(140.78,100.4) 140.78,98.16 141.2,97.74 141.2,91.68 139.81,90.29 138.03,90.29 136.4,88.66 136.4,84.41 136.03,84.03 135.46,84.03 135.44,84.01 134.84,84.01 134.56,83.74 134.56,83.65 134.56,83.64 v2(134.56,83.43) ; 143.2,100.07 145.48,100.07 149.42,96.13 156.21,96.13 157.42,94.92 160.4,94.92 161.55,96.07 161.55,97.15 163.5,99.1 163.5,100.52 167.94,104.96 169.03,104.96 175.71,111.64 181.24,111.64 181.84,112.23 186.89,112.23 188.2,110.93 192.03,110.93 192.4,110.55 v2(192.4,110.28)
  BOTTOM w0.254: UC1.AF22 126.44,75.93 v2(126.75,75.62) ; UC1.H11 132.1,86 v2(132,86) ; v2(134.41,76.78) 134.23,76.61 UC1.AE8 ; UC1.R21 127.13,81.99 v2(126.76,81.62) 127.13,81.25 UC1.T21 ; v2(130.09,86.03) 130.16,86.03 UC1.H15 ; UC1.P9 134.23,82.94 UC1.N8 134.23,83.1 v2(134.56,83.43) ; UC1.J11 132.28,85.04 v2(132,85.32) ; UC1.AG17 129.13,75.47 v2(129.51,75.1) 129.52,75.11 129.52,75.11 129.88,75.47 UC1.AG16 ; UC1.J17 129.48,85.04 v2(129.15,85.37)
  BOTTOM w0.457: v2(65.2,55.09) 65.97,55.09 v2(68.39,57.51)
  BOTTOM w0.508: RC126.1 v2(94.3,86.4) 93.39,86.4 92.93,86.86 RC127.1 RC125.1 RC124.1
  vias: v2(128.19,78.35) v2(128.19,77.71) v2(134.43,106.35) v2(134.43,105.72) v2(134.43,105.08) v2(137.8,108.13) v2(138.38,108.13) v2(138.97,108.13) v2(140.17,100.4) v2(141.39,100.4) v2(142,100.4) v2(142.59,100.4) v3(127.32,55.43)
+1.5V_RUN_AUDIO: length 4.8
  TOP w0.203: 207.97,74.92 207.97,74.74 207.77,74.55 207.77,74.54 207.48,74.26 UA1.40
  TOP w0.381: RA3.2 208.59,75.54 207.97,74.92
  TOP w0.508: CA16.1 210.02,77.11 209.43,76.51 209.43,76 209.16,75.73 RA3.2
+1.05V_RUN_UZ7:
  vias: v1(135.22,99.34)
+1.05V_RUN_VMM: length 17.7
  IN2 w1.016: 146.05,109.97 148.08,107.94 148.08,101.97 147.45,101.34
  IN3 w1.016: 155.51,116.96 147.58,116.96
  vias: v1(146.42,115.87) v2(146.14,116.31) v2(146.75,116.31) v2(146.88,100.64) v2(147.46,100.64) v2(160.78,115.12) v2(160.78,114.53)
+1.05V_VCCST: length 104.9
  TOP w0.508: v2(79.64,75.69) 79.64,81.26 ; 79.64,81.26 77.97,82.93 RC202.2 ; 79.64,81.26 81.55,81.26 83.78,79.03 v3(84.52,79.03) 87.9,79.03 ; 87.9,79.03 v2(87.9,80.88) ; 87.9,79.03 88.84,78.1 89.33,78.1 v2(90.26,77.17)
  IN1 w0.508: v2(90.26,77.17) 90.26,76.67 92.01,74.92 104.59,74.92 104.99,75.33 113.65,75.33 114.36,76.04 v2(124.59,76.04)
  IN3 w0.508: v2(82.43,101.84) 83.31,101.84 84.01,101.15 84.01,95.11 85.41,93.72 92.1,93.72 v2(92.89,92.93) 92.89,87.54 89.39,84.04 89.39,82.36 v2(87.9,80.88)
  BOTTOM w0.254: v2(126.73,76.79) 126.26,76.79 UC1.AE22 ; UC1.AC22 UC1.AE22 ; UC1.AE22 126.11,76.74 UC1.AE23 124.89,76.34 v2(124.59,76.04)
  BOTTOM w0.508: RC199.1 v2(92.89,92.93) 93.09,92.73 93.33,92.73 93.84,92.22 RC25.1 ; RC204.1 RC208.1 88.34,82.34 87.88,81.88 RC114.1 87.88,80.9 v2(87.9,80.88) ; PR529.1 PR528.1 PR527.1 83.11,101.84 v2(82.43,101.84) PC511.1 ; v2(79.64,75.69) 79.9,75.95 RC116.1
+1.5V_VIN: length 3.3
  BOTTOM w0.102: PU400.9 v3(192.39,81.86)
+1.05V_VMM_UV10:
  vias: v1(141.71,102.23)
+1.05V_VMM_VDD: length 7.8
  BOTTOM w0.203: UV8.C9 v5(154.75,113.68) ; UV8.G12 v5(151.5,115.63) ; UV8.H9 v5(150.85,113.68) ; v5(154.75,113.03) UV8.C8 ; UV8.E8 v5(153.45,113.03) ; v5(152.8,109.78) 153.12,109.46 UV8.E3 ; UV8.G3 v5(151.5,109.14) ; UV8.E9 v5(153.45,113.68) ; UV8.H6 v5(150.85,111.09) ; UV8.E6 v5(153.45,111.09) ; UV8.H7 v5(150.85,111.74) ; UV8.E7 v5(153.45,111.74) ; UV8.F12 v5(152.8,115.63) ; UV8.H8 v5(150.85,113.03)
  BOTTOM w0.254: UV8.D3 153.77,109.46 v5(153.45,109.14) ; UV8.E5 v5(153.45,110.44) ; UV8.J3 v5(150.85,109.79)
  vias: v1(157.33,113.96)
+1.05V_VMM_VDDTX: length 6.9
  TOP w0.508: CV91.1 152.8,107.81 v5(152.8,109.14) ; v5(154.75,111.09) 154.81,111.15 155.16,111.15 CV92.1
  BOTTOM w0.203: UV8.D12 153.77,115.31 v5(153.45,114.99) ; UV8.K8 v5(149.55,113.03) ; UV8.K9 v5(149.55,113.68) ; UV8.J10 v5(150.2,114.33) ; UV8.K10 v5(149.55,114.33)
  BOTTOM w0.216: UV8.J2 v5(150.85,109.14) ; UV8.E12 v5(153.45,115.63) ; v5(152.8,109.14) UV8.F3 ; UV8.C7 v5(154.75,111.74)
  BOTTOM w0.229: UV8.C6 v5(154.75,111.09)
  vias: v1(153.96,114.91)
+1.8V_RUN_CARD: length 60.4
  IN1 w1.016: 27.36,29.15 27.36,22.83 29.78,20.4 29.78,18.67 31.08,17.38 31.08,15.13 28.13,12.18 25.82,12.18
  IN2 w1.016: 24.83,30.22 7.2,30.22
  BOTTOM w1.016: 2.97,41 2.97,31.7 4.27,30.41 4.3,30.41 ; 24.64,11.27 21.3,11.27 20.69,11.88 17.77,11.88 17.02,12.63 15.66,12.63
  vias: v2(6.5,31.13) v2(7.17,31.12) v2(15.24,13.82) v2(15.88,13.82) v2(24.42,12.22) v2(25.01,12.22) v2(26.3,29.85) v2(26.34,28.85) v3(15.26,14.39)
+1.35V_MEM: length 105.8
  TOP w0.508: 80.08,23.47 RD18.1 RD2.1 ; v2(57.22,34.53) RD4.1
  BOTTOM w0.178: v2(118.65,71.79) 118.91,72.05 UC1.AN33
  BOTTOM w0.203: UC1.AY44 111.61,67.57 111.61,66.89 111.86,66.64 v2(112.1,66.64) ; UC1.AY40 114.78,67.6 114.78,67.1 v2(115.23,66.64) ; UC1.AY35 117.94,67.61 117.94,67.1 v2(118.4,66.64) ; UC1.AR48 109.64,70.42 v2(109.57,70.42)
  BOTTOM w0.229: v2(108.93,67.08) 108.52,67.49 UC1.AY50
  BOTTOM w0.254: v2(119.04,75.21) UC1.AJ33 ; v2(116.44,75.21) UC1.AJ37 ; UC1.AP43 112.75,71.4 v2(112.43,71.07) ; v2(122.95,75.21) 123.36,75.21 UC1.AH26 ; v2(120.35,75.21) UC1.AJ31
  BOTTOM w0.356: v2(92.46,33.77) 92.55,33.68 92.55,32.14 JDIMM1.111 ; v2(89.16,33.63) 88.95,33.42 JDIMM1.99 88.95,32.14 ; v2(83.47,33.59) 83.55,33.51 83.55,32.14 ; 165.24,25.58 165.25,25.57 JDIMM2.100 ; JDIMM1.117 94.35,33.2 v2(93.91,33.65) ; JDIMM1.87 85.35,33.73 v2(85.31,33.77) ; v2(166.68,33.71) 166.75,33.64 JDIMM2.105 ; JDIMM1.93 87.15,33.63 v2(87.19,33.67) ; JDIMM2.76 158.05,25.33 157.86,25.52 ; JDIMM2.93 163.15,33.25 v2(163.67,33.77) ; v2(94.65,22.57) JDIMM1.118 ; v2(89.25,22.55) 89.25,22.55 89.25,23.94 JDIMM1.100 ; JDIMM2.112 168.85,22.79 168.6,22.53 v2(168.6,22.47) ; v2(164.38,33.77) 164.95,33.2 JDIMM2.99 ; v2(91.05,22.55) JDIMM1.106 91.05,24.87 91.05,24.87 91.25,25.07 v2(91.25,25.64) ; JDIMM2.81 159.55,33.2 v2(159.08,33.67) ; v2(172,22.57) 172.45,23.02 JDIMM2.124 172.45,25.1 171.95,25.61 ; v2(85.65,22.55) JDIMM1.88 ; v2(92.85,22.55) 92.85,22.55 92.85,23.94 JDIMM1.112 ; 160.14,25.56 159.85,25.27 JDIMM2.82 ; v2(87.45,22.55) 87.45,22.55 87.45,23.94 JDIMM1.94 ; v2(90.26,33.67) 90.75,33.18 90.75,32.14 JDIMM1.105 ; JDIMM1.75 81.75,32.14 81.75,33.09 81.25,33.59 v2(81.1,33.59) ; JDIMM2.117 170.35,33.42 v2(170.04,33.72) ; v2(95.7,22.53) 96.07,22.53 96.45,22.92 JDIMM1.124 ; JDIMM2.123 172.15,33.44 v2(172.42,33.71) ; JDIMM1.76 v2(82.05,22.55) ; JDIMM1.82 83.85,23.94 v2(83.85,22.55) ; JDIMM2.87 161.35,33.53 v2(161.35,33.53) ; JDIMM2.94 163.45,24.9 163.21,25.13 v2(163.21,25.67) ; 168.56,33.72 168.55,33.71 JDIMM2.111 ; v2(96.56,33.71) 96.15,33.3 96.15,32.14 JDIMM1.123 ; v2(161.64,26.38) 161.65,26.38 JDIMM2.88
  BOTTOM w0.508: v2(57.22,34.53) 58.36,35.68 79.89,35.68 ; CD44.1 157.22,22.43 v2(157,22.65) ; v2(116.76,62.67) 116.96,62.67 117.34,63.05 CC27.1 ; v2(110.22,62.73) 109.9,63.05 CC28.1
  vias: v2(107.3,20.98) v2(107.29,20.4) v2(107.95,20.4) v2(107.99,20.98) v2(108.63,20.98) v2(108.63,20.4) v2(109.08,58.83) v2(109.08,58.27) v2(109.3,20.98) v2(109.31,20.4) v2(111.52,59.46) v2(111.52,58.91) v2(111.83,21) v2(111.81,20.41) v2(112.47,20.41) v2(112.51,21) v2(113.15,21) v2(113.15,20.41) v2(113.33,59.92) v2(113.33,59.36) v2(113.82,21) v2(113.83,20.41) v2(128.49,28.25) v2(156.8,25.76) v2(157.62,33.67) v2(167.05,22.53) v2(170.65,22.53) v3(121.54,49.33) v4(121.67,22.53) v4(121.67,21.9) v4(122.43,22.53) v4(122.43,21.9) v4(123.19,22.53) v4(123.19,21.9) v4(123.89,22.53) v4(123.89,21.9) v4(123.89,21.2) v4(124.65,22.53) v4(124.65,21.9) v4(124.65,21.2) v4(125.42,22.53) v4(125.42,21.9) v4(125.42,21.2)
+1.35V_MEN_P: length 88.6
  IN1 w0.508: v2(109.06,13.63) 109.06,13.16 108.53,12.63 86.24,12.63 85.69,12.08 82.49,12.08 81.88,12.69 v2(81.88,15.19)
  IN2 w0.254: v2(69.07,14.16) 68.98,14.07 68.98,12.56 69.57,11.97 108.98,11.97 110.26,13.25 110.26,14.02 109.51,14.77 v2(109.1,14.77)
  IN2 w0.508: 71.21,13.57 70.61,14.16 v2(69.07,14.16)
  IN2 w0.762: 71.21,13.57 75.76,13.57 76.08,13.88 v2(76.08,15.5)
  BOTTOM w0.254: PR205.2 PC213.2 PC214.1 69.9,14.16 v2(69.07,14.16)
  vias: v1(96.28,16.31)
+3.3V_ALW: length 315.9
  TOP w0.102: RPE9.5 195.87,102.17 195.87,100.77 v3(195.86,100.75)
  TOP w0.254: RPE5.7 215.39,87.08 v2(215.69,87.38) ; RPE3.8 213.32,89.09 v2(213.24,89.18) 213.66,89.59 RPE3.7 ; JIO1.19 220.29,68.2 220.09,68 219.34,68 CI34.1
  TOP w0.305: CZ28.1 199.68,57.13 199.68,55.93 199.85,55.77 JKBTP1.6
  TOP w0.356: CC35.1 76,81.88 UC8.5
  TOP w0.381: UZ11.5 178.2,111.12 178.57,111.48 180.66,111.48 181.05,111.09 RE87.2 ; UZ10.5 186.3,117.65 186.74,118.1 CZ48.1
  TOP w0.406: UZ6.5 183.72,88.42 183.15,88.99 CZ34.1
  TOP w0.508: RE9.1 185.61,109.97 185.27,110.32 v2(185.14,110.32) 184.72,109.9 RE10.1 ; RE74.1 188.7,83.19 v2(188.92,83.4) ; RE87.2 181.65,110.71 v2(182.07,110.29) ; RE63.1 206.58,79.1 v2(206.65,79.17) ; RE75.1 RE73.1 187.2,83.62 v2(187.01,83.81) ; v2(9.51,36.34) 9.29,36.55 PR895.1 ; v2(199.09,56.73) 199.39,57.04 CZ28.1 ; RE12.1 191.51,97.17 v2(191.51,97.72) ; v2(201.29,101.62) 201.14,101.48 RE69.1 ; v2(204.35,81.46) 204.21,81.32 RE37.1 ; RC217.1 RC213.1 130.62,56.06 130.81,55.87 v2(134.31,55.87) ; RE68.1 194.93,86.36 194.85,86.45 194.85,88.35 193.13,90.07 v2(193.13,90.07) ; v2(182.76,118.67) 183.01,118.93 CZ48.1 ; 79.95,125.48 79.71,125.72 71.67,125.72 71.26,125.31 71.26,121.5 72.16,120.6 PR8.2 ; RE72.1 185.37,83.25 185.59,83.47 RZ22.1 185.97,84.15 186.13,83.99 v2(186.41,83.99) ; RE43.1 203.9,84.92 v2(203.69,85.13) ; RE35.1 173.29,99.24 173.48,99.05 RE11.1 174.11,100.03 v2(174.15,100.07) ; v2(191.68,101.65) RE276.1 ; RE83.1 186.5,109.97 v2(186.12,110.35) ; v2(190.25,92.51) 189.56,93.2 RE5.1 189.16,93.4 CE1.1 187.26,92.51 186.57,91.81 185.61,91.81 184.93,92.5 RE36.1 ; RZ24.1 RZ31.1 v2(194.69,115.31) ; CZ34.1 v2(182.7,87.23) ; RE25.1 v2(185.49,115.18) ; RE79.1 v2(216.6,94.62) ; CI34.1 219.15,67.94 v2(219.15,67.36) ; CC35.1 v2(75.42,82.02) ; PR859.2 27.59,39.64 v2(28.08,39.14) ; v2(211.29,79.49) 210.84,79.95 RE81.1
  IN1 w0.508: v2(149.58,14.72) 150.98,16.12 155.6,16.12 156.62,15.1 174.35,15.1 179.64,20.4 179.64,24.77 179.49,24.92 179.49,40.48 184.98,45.96 184.98,47.69 v2(185.33,48.05)
  IN3 w0.508: v2(134.31,55.87) 136.05,55.87 144.63,47.29 184.57,47.29 v2(185.33,48.05) ; v2(174.15,100.07) 169.61,100.07 167.96,98.42 165.55,98.42 165.21,98.76 157.9,98.76 157.17,99.5 151.13,99.5 151.01,99.62 147.29,99.62 143.16,95.49 136.97,95.49 136.34,96.13 131.51,96.13 v2(131.3,96.35) ; v2(219.15,67.36) 219.15,66.13 216.26,63.24 216.26,62.39 214.1,60.23 v2(213.5,60.23) ; v2(205.29,15.61) 205.55,15.88 205.55,17.59 204.79,18.35 204.79,22.69 205.55,23.45 205.55,27.21 203.79,28.97 203.79,30.42 203.58,30.62 v2(203.58,32.93) ; v2(33.77,36.8) 30.83,36.8 29.09,38.54 28.69,38.54 v2(28.08,39.14) 27.27,39.14 26.41,38.28 13.4,38.28 12.7,38.98 v2(12,38.98)
  BOTTOM w0.508: RV701.1 172.06,118.34 171.62,118.79 v2(171.39,118.79) ; v2(194.69,115.31) 194.69,110.61 v2(194.34,110.25) ; PR315.1 190.12,63.12 190.4,63.4 PR306.1 v2(190.69,62.7) ; PR2.1 149.58,16.46 v2(149.58,14.72) ; v2(9.13,39.51) 10.33,39.51 10.67,39.17 10.67,36.86 10.15,36.34 v2(9.51,36.34) ; v2(33.77,36.8) 34.21,36.36 PR740.2
  vias: v2(33.78,30.7) v2(34.04,30.09) v2(34.42,30.7) v2(34.67,30.09) v2(35.05,30.72) v2(35.31,30.12) v2(35.69,30.72) v2(35.94,30.12) v2(36.32,30.72) v2(36.58,30.12) v2(36.96,30.72) v2(37.21,30.12) v2(54.61,49.14) v2(54.61,48.5) v2(54.61,47.87) v2(55.25,49.14) v2(55.25,48.5) v2(55.25,47.87) v2(58.78,62.41) v2(58.78,61.83) v2(59.31,62.79) v2(59.31,62.16) v2(59.38,61.52) v2(59.84,63.15) v2(59.84,62.51) v2(59.84,61.88) v2(78.34,84.08) v2(78.34,83.44) v2(78.97,84.08) v2(78.97,83.44) v2(79.15,82.88) v2(79.61,84.08) v2(79.61,83.44) v2(79.78,82.88) v2(80.27,84.06) v2(80.27,83.43) v2(80.44,82.87) v2(80.58,125.4) v2(81.28,125.34) v2(81.73,124.96) v2(172.13,97.48) v2(172.13,96.9) v2(173.6,105.05) v2(174.18,105.05) v2(180.83,84.86) v2(181.41,84.86) v2(187.2,87.24) v2(187.77,87.56) v2(189.89,44.61) v2(189.89,43.97) v2(190.53,44.61) v2(190.53,43.97) v2(192.95,66.63) v2(193.02,110.25) v2(193.04,107.38) v2(193.22,43.49) v2(193.63,110.25) v2(193.63,107.38) v2(193.87,44.36) v2(193.87,43.73) v2(194.5,44.36) v2(194.5,43.73) v2(196.54,104.02) v2(196.51,103.38) v2(202.97,33.58) v2(202.97,32.95) v2(203.01,36.12) v2(203.01,35.54) v2(203.58,33.57) v2(213.82,82.22) v2(213.82,81.64) v3(34.7,32.46) v3(82.04,125.53)
+3.3V_ALW2: length 472
  TOP w0.406: PU806.5 7.76,23.23 PC810.2
  TOP w0.508: PR846.1 PR864.1 23.29,28.3 23.83,28.83 v2(24.16,28.83) 24.16,29.59 PR855.1 ; v2(205.43,80.67) 205.11,80.99 RE57.2 ; PR819.2 v2(13.95,21.81) ; PR829.1 13.4,27.14 12.96,26.7 v2(12.52,26.7) ; RZ16.1 164.21,83.15 164.82,83.76 v2(165.19,83.76) ; v2(198.39,11.5) v3(195.51,14.38) 176.55,14.38 v2(172.62,18.3) ; PC810.2 7.7,23.14 6.99,23.14 v2(6.94,23.09)
  IN1 w0.508: v2(198.39,11.5) 204.82,11.5 207.05,13.73 207.05,18.35 204.08,21.33 204.08,24.79 202.43,26.44 202.43,27.74 203.3,28.61 204.19,29.5 v2(204.19,31.36) ; v2(172.62,18.3) 171.46,17.14 156.91,17.14 155.91,18.14 148.55,18.14 146.64,16.22 122.41,16.22 118.84,19.79 106.86,19.79 105.25,21.4 99.27,21.4 98.73,20.86 97.7,20.86 96.45,22.11 96.45,23.22 96.16,23.51 56.94,23.51 51.56,28.88 v2(46.51,28.88) 42.48,28.88 39.5,31.87 32.96,31.87 31.82,30.72 26.05,30.72 v2(24.16,28.83) ; v2(159.34,83.01) 159.51,82.85 161.05,82.85 161.23,83.03 163.81,83.03 164.54,83.76 v2(165.19,83.76) 166.49,82.46 169.01,82.46 170.06,81.41 170.74,81.41 175.39,76.76 176.43,76.76 176.96,76.24 176.96,75.33 177.4,74.88 178.21,74.88 178.5,75.17 184.66,75.17 185.42,74.41 188.19,74.41 190.77,71.83 196.13,71.83 198.05,69.92 198.05,68.53 199.07,67.51 199.07,67.05 197.23,65.21 197.23,64.44 197.68,64 v2(198.38,64)
  IN2 w0.508: v2(227.02,77.14) 226.88,77.14 226.38,76.65 226.38,74.45 226.67,74.16 226.67,64.54 224.28,62.16 221.68,62.16 220.8,61.27 220.8,59.36 220.22,58.79 208.41,58.79 207.33,57.71 207.33,56.51 v2(205.11,54.28)
  IN3 w0.508: v2(24.16,28.83) 23.28,29.71 18.52,29.71 15.51,26.7 v2(12.52,26.7) ; v2(227.02,77.14) 227.02,78.22 225.62,79.62 222.64,79.62 218.93,83.33 216.9,83.33 216.61,83.62 210.4,83.62 209.2,82.41 209.2,80.13 208.85,79.78 206.09,79.78 205.43,80.44 v2(205.43,80.67)
  IN4 w0.508: v2(177.82,124.01) 177.82,119.64 169.09,110.91 v2(168.43,110.91) ; v2(204.19,31.36) 204.19,34.93 204.55,35.28 204.55,49.74 204.04,50.25 204.04,52.05 205.11,53.12 v2(205.11,54.28)
  BOTTOM w0.381: v2(159.34,83.01) 159.33,83 UC6.5
  BOTTOM w0.508: v2(198.38,64) 198.46,64 200.81,66.35 200.81,66.36 202.13,67.68 202.39,67.68 203.12,68.42 203.12,75.93 205.43,78.24 v2(205.43,80.67) ; v2(168.43,110.91) 167.69,110.91 165.91,109.13 165.91,102.21 167.07,101.05 167.07,98.19 164.67,95.79 164.67,92.22 165.19,91.7 v2(165.19,83.76) ; v2(6.94,23.09) 6.94,20.81 8.82,18.93 10.19,18.93 11.53,20.27 11.55,20.27 12.94,21.67 13.81,21.67 v2(13.95,21.81) 13.95,22.23 13.49,22.69 13.49,22.7 12.45,23.74 12.45,26.62 v2(12.52,26.7) ; R272.2 v2(177.82,124.01)
+3.3V_ALW_PCH: length 488.1
  TOP w0.508: v2(83.78,55.74) 75.14,47.09 75.14,39.46 72.61,36.93 68.46,36.93 68.15,37.24 RC120.2 ; RC82.1 159.12,73.75 RC179.1 158.92,74.55 v2(159.08,74.72) ; CC57.1 130.14,74.37 v2(129.93,74.16) 129.42,73.65 129.42,71.91 129.68,71.66 129.68,68.66 130.6,67.74 130.6,61.02 130.83,60.8 RC212.1 RC216.1 ; CC63.1 130.96,78.41 v2(130.72,78.65)
  TOP w1.016: 169.42,53.94 167.41,51.93 154.12,51.93 152.02,54.03 138.95,54.03 136.32,56.66 ; 169.42,53.94 169.42,59.27 167.73,60.96 167.73,64.28 164.98,67.03 164.47,67.03 164.47,68.89 ; 169.42,53.94 177.13,53.94 177.75,54.56 ; 135.02,58.19 133.07,60.14 131.73,60.14
  IN1 w0.381: v2(128.15,77.12) 129.42,77.12 130.72,78.41 v2(130.72,78.65)
  IN1 w0.508: v2(124.32,17.55) 125.02,16.86 144,16.86 144.66,17.52 144.66,18.34 145.19,18.88 166.74,18.88 167.35,19.49 171.88,19.49 174.06,21.66 174.06,37.9 165.17,46.79 159.44,46.79 v2(157.86,48.36)
  IN2 w1.016: v2(150.69,76.19) 148.85,78.03 148.85,84.7 147.32,86.22 147.32,91.3 148.08,92.07 148.08,93.97 149.04,94.92
  IN3 w0.508: v2(208.68,41.48) 208.3,41.86 188.75,41.86 187.26,43.35 187.26,47.49 186.06,48.7 184.98,48.7 184.23,47.95 167.11,47.95 166.3,48.76 159.64,48.76 159.25,48.36 v2(157.86,48.36) 157.03,49.2 143.61,49.2 v2(135.58,57.24) ; v2(129.93,74.16) 129.68,74.41 129.33,74.41 128.89,74.86 128.89,76.7 128.47,77.12 v2(128.15,77.12)
  IN3 w1.016: 149.1,94.86 146.5,94.86 143.07,91.43 135,91.43 134.5,91.94
  IN4 w0.508: v2(222.13,39.58) 222.13,44.06 221.35,44.84 221.35,48.3 219.47,50.18 v2(219.47,53.27) 219.47,54.25 220.06,54.83 220.06,55.74 220.7,56.39 220.7,64.82 221.4,65.52 221.4,70.32 219.27,72.46 219.27,76.99 217.68,78.58 217.68,79.25 216.33,80.6 216.33,82.65 217.1,83.42 219,83.42 219.53,83.95 219.53,91.98 218.87,92.64 218.87,95.81 219.89,96.83 v2(219.89,97.76)
  BOTTOM w0.254: v2(129.93,74.16) 129.93,74.16 130,74.16 130.63,74.79 UC1.AH14 ; UC1.AE21 127.54,76.74 UC1.AE20 127.74,76.74 128.11,77.12 v2(128.15,77.12) ; 133.05,78.7 133.77,78.7 UC1.AA9 UC1.AC9 ; RC81.1 RC79.1
  BOTTOM w0.381: v2(130.72,78.65) 133,78.65 133.05,78.7
  BOTTOM w0.508: v2(208.68,41.48) 209.92,40.24 221.47,40.24 v2(222.13,39.58) ; RC34.1 RC33.1 158.27,71.53 v2(158.23,71.49) 158.02,71.28 157.1,71.28 155.88,70.05 155.88,67.6 155.43,67.15 155.43,62.6 RC81.1 ; RC2.1 121.57,15.87 122.41,16.7 123.47,16.7 v2(124.32,17.55) ; v2(135.58,57.24) 135.41,57.08 132.84,57.08 132.05,56.29 84.33,56.29 v2(83.78,55.74)
  vias: v2(133.16,94.1) v2(133.28,94.67) v2(149.93,95.11) v2(150.56,95.11) v2(153.58,76.19) v2(161.79,71.53) v2(162.19,71.96) v3(136.32,57.69)
+3.3V_ALW_PCH_UZ7: length 1.7
  TOP w0.089: 134.89,94.62 135.45,94.62 v1(136.26,93.81)
+3.3V_ALW_UE1: length 14.8
  TOP w0.102: CE6.1 175.28,93.93 v1(175.11,94.1)
  TOP w0.254: v2(178.49,103.33) 178.23,103.59 UE1.B5 ; CE5.1 183.49,108.41 183.49,107.88 183.69,107.69 UE1.A54 ; UE1.A43 188.83,102.84 189.98,103.99 CE3.1 ; UE1.A17 178.69,95.93 177.74,94.98 177.74,94.69 177.02,93.97 CE2.1
  TOP w0.305: v2(184.92,98.3) 184.65,98.3 184.4,98.05 184.4,97.48 184.44,97.44 UE1.B30
  TOP w0.508: v2(177.08,94.78) 176.75,94.78 176.13,94.16 CE6.1 CE2.1 ; CE5.1 184.03,108.56 v2(184.03,108.13) ; CE3.1 v2(189.23,104.07)
  vias: v2(173.69,103.1)
+3.3V_ALW_UE2: length 55.5
  TOP w0.254: CE23.1 212.41,93.46 v1(212.12,93.17) 211.5,93.17 211.41,93.25 UE2.A11 ; CE14.1 208.63,101.07 CE13.1 206.99,99.43 v2(206.92,99.43) 206.92,97.83 206.87,97.78 UE2.A22 ; v2(198.71,91.15) 198.71,91.32 199.02,91.63 199.63,91.63 199.75,91.75 UE2.A41
  TOP w0.279: UE2.B35 200.92,96 199.93,96.99 199.46,96.99 199.14,97.31 ; v2(206.54,85.68) 206.54,86 206.37,86.17 UE2.A58 ; UE2.A52 203.37,86.22 203.17,86.03 v2(203.17,85.45) 203.17,84.63 CE18.1
  TOP w0.305: UE2.B3 209.97,89 209.9,88.93 209.88,88.93 209.65,88.7 v2(209.57,88.7)
  TOP w0.508: v2(198.71,91.15) 198.26,90.71 CE17.1 ; CE15.1 CE20.1 206.54,85 v2(206.54,85.68)
  IN1 w0.457: v2(206.54,85.68) 206.54,85.87 205.99,86.42 203.48,86.42 203.11,86.05 203.11,85.51 v2(203.17,85.45)
  IN1 w0.508: v2(206.54,85.68) 207.28,86.41 209.34,86.41 209.61,86.15 209.61,85.49 210.69,84.4 210.82,84.4 211.24,83.99 212.77,83.99 213.04,84.25 v2(215.55,84.25)
  IN2 w0.508: v2(198.74,98.02) 198.74,97.15 197.17,95.57 197.17,93.08 198.71,91.54 v2(198.71,91.15)
  IN3 w0.508: 205.11,99.88 205.55,99.43 v2(206.92,99.43) 208.1,99.43 208.76,98.77 209.59,98.77 211.71,96.65 211.71,96.26 211.08,95.62 211.08,93.27 211.33,93.02 212.46,93.02 v2(212.68,92.8)
  vias: v2(199.35,98) v2(204.92,98.65) v2(213.29,92.8) v2(214.25,88.38)
+3.3V_ALWP: length 7.6
  TOP w0.508: PR100.1 44.77,29.45 v2(44.77,29.82)
  IN3 w0.254: v2(38.22,29.02) 38.24,29.05 44,29.05 v2(44.77,29.82)
  vias: v1(36.11,26.38) v2(34.32,27.6) v2(34.32,27.02) v2(34.95,27.6) v2(34.95,27.02) v2(35.55,27.6) v2(35.55,27) v2(36.15,27.58) v2(36.13,26.98) v2(36.77,26.98) v2(36.78,27.58) v2(37.42,27.58) v2(37.4,26.98)
+3.3V_CAM: length 1.8
  TOP w0.457: CZ1.1 101.47,116.82 v2(101.47,117.26)
  BOTTOM w0.254: v2(101.47,117.26) JEDP1.11
  vias: v3(102.5,119.08)
+3.3V_HDD: length 18.1
  IN4 w1.016: 201.58,105.78 202.21,106.42 205.51,106.42 206.97,107.88 214.63,107.88 216.03,109.27 218.19,109.27
  vias: v2(200.76,106.14) v2(200.76,105.55) v2(218.66,108.5) v2(219.45,110.28) v2(220.07,110.28) v3(201.3,105.9)
+3.3V_HDD_UL3: length 1.1
  TOP w0.102: CL23.1 196.69,105.59 v1(196.23,105.13)
+3.3V_LAN: length 127.4
  TOP w0.381: CL15.1 211.62,123.99 UL2.5
  TOP w0.457: v2(220.5,121.81) 220.53,121.78 220.53,121.35 RL30.1
  TOP w0.508: CL15.1 211.64,124.59 211.25,124.98 v2(210.51,124.98)
  IN3 w1.016: 222.44,124.52 223.78,123.18 232.88,123.18 235.17,125.47 255.83,125.47 ; JLOM1.12 302.14,127.93 302.96,127.1 302.96,123.43 301.95,122.42 288.48,122.42 287.44,123.47 JLOM1.9 286.41,127.93 285.7,127.22 284.37,127.22 283.25,128.34 283.25,129.94 281.88,131.31 262.3,131.31 257.66,126.67
  BOTTOM w0.254: UL4.4 218.72,121.86 v2(218.58,121.73) ; UL4.39 221.49,125.07 221.54,125.02 CL27.1 ; v2(210.51,124.98) 210.6,125.07 UL4.21 ; UL4.30 216.22,126.61 216.16,126.67 216.16,127.55 CL26.1 ; UL4.1 220.22,122.23 220.5,121.95 v2(220.5,121.81) ; UL4.14 213.72,122.14 213.51,121.93 v2(213.51,121.73) ; v2(216.72,121.72) UL4.8
  BOTTOM w0.508: v2(256.54,125.52) 257.29,124.77 CL19.1 ; v2(257.04,125.98) 257.29,125.72 CL18.1 ; v2(207.1,121.85) 207.1,120.02 205.15,118.06 v2(205.15,108.49) ; CL26.1 216.36,127.75 216.66,127.75 v2(216.92,128.01)
  vias: v2(196.42,112.7) v2(197,112.7) v2(204.51,108.49) v2(207.72,121.85) v2(221.99,125.82) v2(222.57,125.82) v3(204.29,107.84)
+3.3V_LAN_OUT: length 15.3
  TOP w0.203: v2(210.29,116.85) 209.97,117.17 209.39,117.17 208.95,117.61 UL1.29 ; UL1.19 210.46,115.44 v2(210.28,115.62) ; UL1.15 210.49,113.84 v2(210.32,114.01) ; UL1.5 207.75,113.19 v2(207.72,113.21) 207.35,112.83 UL1.4
  BOTTOM w0.102: v1(206.34,112.07) 207.48,113.21 v2(207.72,113.21)
  BOTTOM w0.508: 213.2,119.18 RL8.2 ; 213.2,119.18 213.58,118.8 214.71,118.8 215.14,119.23 CL7.1 ; 213.2,119.18 213.2,119.13 211.71,117.64 211.08,117.64 v2(210.29,116.85)
+3.3V_LAN_UL3: length 2
  TOP w0.102: CZ36.1 198.47,110.3 198.68,110.52 198.68,111.15 v1(199.26,111.73)
+3.3V_M: length 64.9
  TOP w1.016: 195.68,39.26 191.15,39.26 183.25,47.16
  IN2 w1.016: 174.42,64.87 174.42,57.09 175.02,56.49
  IN3 w1.016: 173.95,66.7 173.57,67.08 164.06,67.08 163.6,66.63 155.29,66.63 153.59,64.94 147.43,64.94 145.89,66.48 143.63,66.48
  IN4 w1.016: 182.97,49.7 177.34,55.34
  BOTTOM w0.254: UC1.Y8 134.23,79.46 v2(134.41,79.64)
  vias: v2(134.48,78.65) v2(142.12,66.87) v2(142.7,66.87) v2(173.84,65.75) v2(174.42,65.75) v2(175.94,56.44) v2(176.52,56.43) v2(183.44,48.82) v2(184.03,48.82) v3(175.01,55.49)
+3.3V_M_TPM: length 12.4
  TOP w0.381: CZ7.1 189.79,59.24 189.05,58.5 UZ1.24 186.37,58.5 ; CZ5.1 180.84,55.25 UZ1.10 183.67,55.25 ; CZ4.1 189.63,54.84 189.22,55.25 UZ1.19 186.29,55.25 ; 183.54,59.8 UZ1.3
  vias: v1(180.25,57.14)
+3.3V_M_UZ8: length 1.9
  TOP w0.102: RZ47.1 198.48,37.67 v1(198.26,37.89)
+3.3V_MMI: length 22.8
  TOP w0.203: CR8.2 19.07,22.91 19.95,22.91 20.49,22.38 UR1.11 ; UR1.13 18.77,21.04 18.42,21.39 17.54,21.39 RR15.1 ; CR4.1 27.56,19.55 26.65,18.64 UR1.42 ; UR1.27 20.89,15.34 20.58,15.03 20.58,13.26 20.3,12.98 ; UR1.9 21.29,22.68 21.4,22.79 21.4,23.35 CR2.1 ; UR1.23 v1(18.14,17.04) 17.32,17.04 CR6.1
  TOP w0.508: RR15.1 v2(16.51,23.09) ; RR6.1 v2(15.65,18.85) ; v2(17.05,25.34) 17.39,25.34 18.11,24.62 CR8.2 ; CR6.1 17.22,16.88 v2(17.66,16.45) ; CR2.1 v2(20.89,23.17) ; CR4.1 v2(28.7,19.56)
  vias: v2(20.21,10.54) v2(20.58,10.07)
+3.3V_RTC_LDO: length 176.5
  TOP w0.508: PR103.1 47.67,30.15 v1(48.69,31.18) v2(49.3,31.79)
  IN2 w0.508: v2(205.16,47.22) 204.4,47.98 199.85,47.98 198.17,46.31 198.17,43.96 193.02,38.8 76.4,38.8 72.11,34.51 66.26,34.51 64.63,32.88 50.39,32.88 v2(49.3,31.79)
  BOTTOM w0.508: v2(205.16,47.22) 207.38,47.22 212.4,52.24 PD3.3
+3.3V_RUN: length 727.1
  TOP w0.203: v2(138.95,111.42) 138.95,111.7 139.22,111.96 UV600.21 ; CV61.1 118.33,113.11 118.82,113.11 119.1,113.39 119.1,114.19 119.29,114.38 UV7.14 ; UV600.5 136.91,119.11 CV600.1 ; v2(143.44,111.46) 143.44,111.56 143.07,111.93 142.89,111.93 142.82,112 UV600.30 ; UV600.57 140.42,122.38 CV604.1 ; CV603.1 144.53,121.15 144.28,121.4 UV600.51 ; RV610.1 127.76,119.18 UV7.41
  TOP w0.254: CI30.1 227.83,81.02 227.27,80.46 UI7.13 ; 125.93,111.5 UV7.28 ; RPC16.1 143.06,96.76 v2(142.81,97.01) 142.56,96.75 RPC16.2 ; RPC16.4 141.56,96.75 v2(141.81,97.01) 142.06,96.76 RPC16.3 ; RPE3.6 213.37,90.09 213.24,90.22 v2(213.24,90.73) 213.37,90.59 RPE3.5
  TOP w0.305: JUSH1.8 222.3,47.79 CZ11.1 ; UN1.1 223.61,115.36 223.84,115.13 v2(223.84,114.8) ; v2(224.06,69.12) 223.97,69.2 220.7,69.2 JIO1.21 220.19,69.2 220.09,69.1 219.43,69.1 CI35.1 ; 221.43,113.34 221.43,114.1 221.38,114.14 221.38,114.88 UN1.14
  TOP w0.381: CV511.1 236.41,126.29 236.54,126.17 UV502.14
  TOP w0.432: 138.89,122.94 v2(138.43,122.48)
  TOP w0.457: v2(147.85,81.44) 147.16,81.44 RC68.1 ; RV603.1 135.99,120.21 136.45,119.75 v2(136.91,119.75) CV600.1 ; v2(145.02,121.92) 145.02,121.61 145.28,121.35 CV603.1 ; CA7.1 102.06,116.65 v2(102.06,117.28) 102.06,117.73 102.4,118.08 ; RV58.1 114.32,115.71 v2(114.32,114.96) 114.32,114.51 RV68.1 ; v2(143.44,111.46) 143.93,111.46 144.35,111.04 CV602.1
  TOP w0.508: RC160.1 158.55,83.28 158.9,83.63 v2(159.86,83.63) ; RC247.1 145.95,88.22 v2(146.04,88.31) ; RI34.1 218.98,80.63 v2(218.58,81.03) ; RI16.1 v2(218.58,85.97) ; v2(142.67,108.78) 142.67,109.58 RV604.1 ; v2(131.02,83.39) 130.73,83.39 130.41,83.06 CC66.1 ; v2(228.67,125.4) 228.67,124.96 225.87,122.16 225.87,120.07 ; CZ11.1 222.38,49.68 221.13,50.92 221.13,53.35 220.51,53.98 220.51,55.16 220.94,55.59 220.94,56.93 224.01,59.99 224.01,61.76 225.29,63.05 225.29,66.4 v2(224.91,66.78) ; RV611.1 142.42,127.37 RV612.1 RV613.1 RV614.1 139.39,127.37 139.03,127.02 139.03,125.7 138.64,125.3 138.64,123.89 138.89,123.64 138.89,122.94 CV604.1 ; CV601.1 138.95,110.72 v2(138.95,111.42) ; RZ46.1 196.82,35.64 196.4,35.22 196.4,34.2 195.77,33.58 v2(195.07,33.58) 193.86,33.58 193.3,34.14 RD27.2 CD64.1 CD63.1 191.18,34.39 189.61,35.96 189.61,39.54 v2(185.05,44.1) ; RV56.1 121.34,110.05 v2(121.54,109.85) ; CV511.1 v2(235.28,127.5) ; 225.87,120.07 222.76,120.07 221.68,118.99 ; 225.87,120.07 RN3.1 RN4.1 ; CI29.1 v2(221.12,85.51) ; v2(117.73,111.83) 117.73,112.41 CV61.1 ; RI38.1 v2(222.84,88.23) ; v2(146.55,85) 146.15,85.4 RC302.1 ; RE51.1 205.87,101.27 v2(206.12,101.02) RE48.1 ; CV510.1 254.7,126.48 UV501.1 253.2,125.9 251.54,124.24 v2(250.82,124.24) ; RV57.1 RV555.1 120.54,124.32 121.68,125.47 121.88,125.47 123.76,127.35 v2(123.76,127.5) ; v2(106.1,112.84) 106.1,114.68 104.19,116.59 CA7.1 ; v2(220.22,113.34) CN1.1 221.43,113.34 ; v2(218.59,84.19) RI18.1 RI25.1 ; RV507.1 240.04,127.13 v2(240.04,127.94) ; 127.71,124.18 127.5,124.18 v2(126.98,124.7) ; 127.71,124.18 RV51.1 CV66.1 ; 127.71,124.18 127.83,124.07 130.69,124.07 131.26,123.5 131.26,121.91 131.71,121.45 133.19,121.45 RV615.1 RV601.1 ; RI36.1 v2(229.93,81.92) ; v2(118.95,30.75) 118.95,32.18 CD31.1 CD32.1 ; RV605.1 140.81,109.17 v2(140.59,108.96) ; RV551.1 v2(125.05,123.93) ; RI19.1 219.26,78.65 v2(219.71,78.2) ; 102.4,118.08 104.87,118.08 106.82,120.03 QZ1.3 106.82,121.95 106.81,121.96 v2(106.81,123.18) ; v2(228.55,80.09) 228.41,80.23 CI30.1 ; RV55.1 v2(124.15,109.78) ; CV62.1 126.48,112.04 v2(126.48,112.28) ; CC85.2 128.29,94.89 127.74,95.43 127.74,96.23 127.55,96.42 v2(127.55,96.65) ; RV602.1 v2(129.96,112.58) RV54.1 ; v2(196.4,74.84) 196.4,76.95 194.96,78.39 RE67.1 ; v2(218.1,112.67) 218.1,111.65 217.6,111.15 CN2.1 217.57,110.65 RN2.1 ; v2(163.27,87.52) RC156.2 ; RC155.2 168.65,82.95 RC95.1 168.62,78.75 167.43,77.55 v2(167.43,77.09) ; RV610.1 v2(128.53,119.09) ; RV60.1 115.79,120.57 115.41,120.96 v2(115.41,121.69)
  IN1 w0.508: 117.73,118.74 v2(117.73,111.83) ; 117.73,118.74 115.41,121.06 v2(115.41,121.69) ; 117.73,118.74 118.63,119.64 118.63,120.45 ; 122.43,120.07 123.32,119.18 v2(125.92,119.18) 128.44,119.18 v2(128.53,119.09) ; 122.43,120.07 122.05,120.45 118.63,120.45 ; 122.43,120.07 122.43,121.91 124.45,123.93 v2(125.05,123.93) ; v2(118.63,121.64) 118.63,120.45 ; v2(132.7,81.02) 132.57,80.89 131.93,80.89 131.6,81.22 131.6,83.07 131.29,83.39 v2(131.02,83.39) ; v2(88.64,96.98) 88.64,96.77 88.92,96.5 90.52,96.5 v2(91.14,97.12) ; v2(147.85,81.44) 147.81,81.44 146.83,82.41 139.19,82.41 138.76,81.98 137.14,81.98 136.87,81.72
  IN2 w0.457: 136.97,120.45 136.91,120.39 v2(136.91,119.75) ; v2(145.02,121.92) 145.02,121.2
  IN2 w0.508: v2(220.41,118.54) 219.07,118.54 218.76,118.23 218.76,114.87 219.66,113.97 v2(220.47,113.97) ; v2(118.95,30.75) 123.9,35.7 192.95,35.7 v2(195.07,33.58) ; 136.97,120.45 137.42,120.89 138.5,120.89 ; 138.5,120.89 138.43,120.96 v2(138.43,122.48) ; 138.5,120.89 144.72,120.89 145.02,121.2 ; v2(240.04,127.94) 248.12,127.94 248.81,127.26 248.81,126.25 249.63,125.43 250.23,125.43 250.82,124.83 v2(250.82,124.24) ; 219.2,88.22 219.2,90.28 217.43,92.05 217.43,93.37 217.54,93.49 217.54,97.48 v2(216.28,98.73) 216.28,101.21 217.3,102.23 217.3,105.34 216.35,106.29 216.35,107.24 216.79,107.69 216.79,110.81 218.13,112.14 218.13,112.64 v2(218.1,112.67)
  IN2 w1.016: 199.76,61.81 199.61,61.97 199.61,69.4 198.91,70.09 198,70.09 196.7,71.39 196.7,73.71
  IN3 w0.508: v2(220.47,113.97) 221.06,113.97 221.88,114.8 v2(223.84,114.8) ; v2(137.85,99.49) 135.66,99.49 134.9,98.73 131.03,98.73 130.62,98.33 130.62,96.6 130.05,96.03 128.88,96.03 128.6,96.31 127.89,96.31 v2(127.55,96.65) ; v2(228.67,125.4) 233.19,125.4 v2(235.28,127.5) 236.11,126.67 238.77,126.67 v2(240.04,127.94) ; v2(179.8,86.19) 178.33,86.19 177.08,84.94 167.66,84.94 165.08,87.52 v2(163.27,87.52) ; v2(224.91,66.78) 225.02,66.89 225.02,68.53 224.44,69.12 v2(224.06,69.12) 223.22,69.12 222.9,68.8 ; v2(216.28,98.73) 215.59,98.73 215.27,98.42 211.19,98.42 209.95,99.66 209.13,99.66 208.41,100.37 206.52,100.37 206.12,100.77 v2(206.12,101.02)
  IN3 w0.762: 201.49,60.57 203.3,58.76 213.71,58.76 217.16,62.21 217.16,63.05 218,63.88 218,63.9 222.9,68.8 222.9,72.08 223.64,72.81
  IN3 w1.016: 196.13,106.65 198.21,106.65 200.14,108.58 201.26,108.58 ; 212.98,110.04 211.52,110.04 211.14,109.66 208.85,109.66 208.63,109.88 206.99,109.88 206.63,109.53 204.22,109.53 203.48,108.79 ; 166.18,114.54 173.48,114.54 176.81,111.22 189.58,111.22 192.51,108.28 ; 223.64,72.81 224.93,74.11 224.93,75.62 ; 30.61,13.14 30.61,13.52 32.45,15.36 32.45,16.32 29.97,18.8 29.97,24.88 30.6,25.51 30.6,29.02 33.58,31.99 41.85,31.99 43.08,30.76 46.9,30.76 49.47,33.33 49.47,34.73 52.68,37.94 54.76,37.94 56.08,36.63 59.18,36.63 61.28,38.73 61.28,39.42
  IN4 w0.508: v2(159.17,71.09) 158.73,71.09 157.93,70.29 157.93,69.33 157.59,68.99 v2(157.29,68.99) ; v2(138.43,122.48) 139.79,121.12 139.79,115.33 138.85,114.39 138.85,113.63 137.99,112.77
  BOTTOM w0.203: PU500.21 88.55,97.07 v2(88.64,96.98) 88.95,97.29 PU500.20
  BOTTOM w0.254: UC1.K16 UC1.K14 130.98,83.43 v2(131.02,83.39) ; v2(102.06,117.28) 101.97,117.18 JEDP1.10 ; v2(139.83,97.15) 139.83,97.02 139.75,96.94 RPC20.8 ; v2(134.44,80.6) 134.44,80.32 UC1.V8 134.23,80.11 133.79,79.67 UC1.W9 ; v2(138.62,97.08) 138.75,96.95 RPC20.6 ; UC1.U8 134.23,81.1 UC1.T9 133.16,81.55 132.7,81.08 v2(132.7,81.02)
  BOTTOM w0.305: JLPDE1.2 161.76,77.41 v2(161.9,77.55) 161.54,77.91 JLPDE1.1
  BOTTOM w0.356: v2(118.95,30.75) JDIMM1.199 ; v2(195.07,33.58) 195.07,33.29 194.95,33.18 JDIMM2.199
  BOTTOM w0.381: UC4.5 159.75,85.54 159.58,85.72 159.58,85.97 v2(159.77,86.16)
  BOTTOM w0.406: v2(159.17,71.09) 159.25,71.09 159.95,70.39 160.16,70.39 160.59,69.95 160.59,69.33 160.34,69.08 QC1.5 ; v2(157.29,68.99) 157.38,69.08 QC1.2
  BOTTOM w0.508: v2(213.24,90.73) 213.93,91.43 213.93,93.15 213.05,94.03 213.05,97.97 213.81,98.73 v2(216.28,98.73) ; RC122.1 164.42,85.94 163.27,87.09 v2(163.27,87.52) ; v2(118.63,121.64) 120.59,123.6 120.59,124.58 121.54,125.53 121.8,125.53 v2(123.76,127.5) ; v2(199.96,60.32) 199.96,56.63 198.63,55.3 197.55,55.3 196.84,54.59 196.84,51.07 195.05,49.28 188.59,49.28 186.69,47.39 186.69,45.74 v2(185.05,44.1) ; PR400.1 191.57,77.28 191.77,77.08 193.42,77.08 193.8,76.7 193.8,74.92 194.63,74.1 195.58,74.1 ; RC180.1 162.56,81.18 162.14,81.6 161.75,81.6 v2(161.46,81.89) 161.8,82.24 UC5.5 ; v2(92.18,104.14) 92.18,104.69 91.81,105.06 89.8,105.06 89.08,104.33 PR516.2 87.28,104.33 PR519.1 ; v2(106.81,123.18) 105.86,122.23 103.58,122.23 102.03,123.78 92.43,123.78 89.23,126.98 RV8.2 ; RC163.1 156.58,94.26 v2(156.19,94.66) ; v2(250.82,124.24) RV501.1
  vias: v2(30.34,12.17) v2(30.98,12.17) v2(60.9,40) v2(61.41,40.5) v2(66.55,64.54) v2(66.55,63.96) v2(66.55,63.38) v2(67.13,64.54) v2(67.13,63.96) v2(67.13,63.38) v2(67.77,64.01) v2(67.77,63.38) v2(76.62,59.69) v2(76.62,59.11) v2(77.26,60.43) v2(77.26,59.85) v2(77.26,59.26) v2(77.83,60.8) v2(77.83,60.21) v2(77.83,59.63) v2(137.7,112.17) v2(137.78,100.46) v2(138.31,112.24) v2(138.31,111.62) v2(138.46,99.49) v2(139.04,99.49) v2(145.93,97.4) v2(146.45,97.67) v2(146.45,97.08) v2(150.67,83.18) v2(150.65,82.16) v2(150.65,80.31) v2(150.69,79.41) v2(153.55,83.16) v2(153.53,82.16) v2(164.98,114.48) v2(165.42,114.04) v2(166.96,76.17) v2(167.49,76.46) v2(167.49,75.85) v2(194.35,106.63) v2(194.93,106.63) v2(196.4,74.22) v2(196.4,73.64) v2(196.98,73.64) v2(199.96,60.97) v2(202.17,108.93) v2(202.52,108.45) v2(221.05,118.54) v2(225.05,77.26) v2(225.05,76.62) v3(157.39,92.85)
+3.3V_RUN_AUDIO: length 32.2
  TOP w0.203: UA1.3 202.72,72.17 v2(202.38,72.52) ; UA1.9 202.7,69.77 202.05,69.12 CA11.1
  TOP w0.254: RA29.1 v2(209.96,60.34) 209.41,59.79 209.41,59.44 209.74,59.11 210.51,59.11 211.05,59.66 RA45.2 ; RA26.1 204.27,61.06 RA38.2 203.41,62.09 v2(203.72,62.41)
  TOP w0.457: v2(202.12,68.48) 202,68.61 CA11.1 ; RA18.1 200.28,77.59 v2(199.84,78.03)
  IN3 w0.508: v2(209.96,60.34) 209.53,60.77 206.82,60.77 205.18,62.41 v2(203.72,62.41) ; v2(214.38,77.91) 210.47,77.91 209.33,76.77 206.51,76.77 206.13,77.16 206.11,77.16 203.35,79.91 202.94,79.91
  vias: v1(197.83,74.81) v2(198.14,74.17) v2(198.12,73.59) v2(198.14,72.99) v2(198.14,72.39) v2(199.84,78.61) v2(202.38,73.12)
+3.3V_RUN_CARD: length 15.2
  IN2 w1.016: 19.51,17.99 20.4,18.88 20.4,20.72 21.16,21.49 26.51,21.49 27.36,22.33 27.36,26.79
  vias: v2(17.87,17.55) v2(18.46,17.55) v2(28.23,26.95) v2(28.51,27.5)
+3.3V_RUN_UZ9: length 1.4
  TOP w0.102: v1(53.6,63.25) 53.6,63.17 CZ47.1
+3.3V_RUN_VDDA: length 4.4
  TOP w0.457: v5(150.85,115.63) 150.85,116.2 CV98.1
  TOP w0.508: v5(154.75,114.33) 154.83,114.42 155.38,114.42 CV99.1
  BOTTOM w0.203: UV8.J4 v5(150.85,110.44)
  BOTTOM w0.216: v5(149.55,111.09) UV8.K6 ; v5(150.85,115.63) UV8.H12 ; UV8.H5 v5(150.85,110.44) ; v5(154.75,114.33) UV8.C10 ; v5(149.55,111.74) UV8.K7
  vias: v1(149.84,112.23)
+3.3V_RUN_VDDIO: length 34.6
  TOP w0.457: CV95.1 149.55,116.08 v5(149.55,115.63) v5(149.55,114.98)
  IN4 w0.508: v5(149.55,109.79) 148.44,109.79 147.87,110.35 147.87,114.38 148.47,114.98 v5(149.55,114.98) ; v5(154.75,109.79) 154.38,109.79 154.13,109.54 154.13,108.73 153.63,108.23 150.08,108.23 149.55,108.76 v5(149.55,109.14) ; v5(149.55,115.63) 149.55,116.07 150.07,116.59 154.13,116.59 154.75,115.97 v5(154.75,115.63)
  BOTTOM w0.152: 157.15,110.01 156.92,110.25 156.74,110.25 155.9,111.09 155.39,111.09 UV8.B6 ; 156.48,110.04 156.29,110.04 155.9,110.43 155.4,110.43 UV8.B5
  BOTTOM w0.216: UV8.C4 v5(154.75,109.79) 154.42,109.46 UV8.C3 ; v5(149.55,115.63) UV8.K12 ; UV8.C11 v5(154.75,114.98) ; v5(149.55,109.14) UV8.K3 ; v5(149.55,114.98) UV8.K11 ; v5(149.55,109.79) UV8.K4
  BOTTOM w0.229: v5(154.75,115.63) UV8.C12
  BOTTOM w0.254: 157.15,110.01 157.57,110.01 v2(157.91,110.35) 158.12,110.35 158.32,110.15 158.32,109.72 158.1,109.5 157.01,109.5 156.48,110.04
  vias: v1(155.98,109.3)
+3.3V_RUN_VMM: length 110.1
  TOP w0.508: RV90.1 137.19,126.71 137.45,126.44 v2(138.39,126.44) ; LV25.2 147.74,110.11 LV24.1 ; LV24.1 147.74,105.87 149.93,103.69 156.71,103.69 v2(157.38,103.01) 157.38,104.28 158.74,105.64 RV517.1 158.74,108.12 160.49,109.87 v2(160.78,109.87) ; LV24.1 v1(145.6,108.19) 143.45,108.19 142.81,107.56 v2(142.81,107.31)
  IN3 w0.508: v2(141.15,122.32) 141.63,122.8 149.86,122.8 150.5,122.16 v2(150.5,121.91)
  IN4 w0.508: v2(155.45,98.23) 157.38,100.16 v2(157.38,103.01) 157.38,103.27 157.86,103.75 159.68,103.75 v2(160.29,103.14) ; v2(137.25,122.08) 137.25,122.06 139.16,120.16 139.16,115.92 137,113.76 137,111.1 138.31,109.8 138.31,109.66 140.66,107.31 v2(142.81,107.31)
  BOTTOM w0.254: 141.13,121.17 CV124.1
  BOTTOM w0.381: CV121.1 159.79,99.51 UV12.14 159.79,102.64 v2(160.29,103.14)
  BOTTOM w0.457: v2(157.38,103.01) 157.23,103.17 157.23,103.74 RV83.2
  BOTTOM w0.508: v2(160.98,112.05) 160.48,111.55 RV516.2 ; RV86.1 153.58,96.36 v2(155.45,98.23) 155.83,97.84 UV9.8 158.57,97.84 CV114.1 ; RV87.1 159.79,98.62 CV121.1 160,99.71 RV91.1 ; RV85.2 160.16,115.75 v2(161.55,115.75) ; RV518.1 RV519.1 163.81,120.74 164.94,119.61 164.94,117.75 164.91,117.72 ; RV83.2 RV84.2 ; RV88.1 144.19,108.26 143.39,108.26 142.81,107.69 v2(142.81,107.31) 140.59,107.31 140.4,107.5 136.15,107.5 ; v2(150.5,121.91) 150.5,121.42 RV82.2 ; CV124.1 v2(141.15,122.32)
  vias: v2(164.4,115.81) v2(164.59,115.24) v2(164.85,116.26)
+3.3V_SPI: length 34.8
  TOP w0.102: v3(175.52,67.69) RC231.2
  TOP w0.508: RC231.2 v2(174.31,68.47) ; RC31.1 v2(176.18,76.15) 176.16,76.14 RC29.1 CC6.1
  IN4 w0.508: v2(174.31,68.47) 174.31,69.21 175.26,70.16 175.26,75.25 176.16,76.15 v2(176.18,76.15) 187.14,76.15 187.79,75.5 v2(187.79,75.11)
  BOTTOM w0.508: v2(187.79,75.11) 187.79,75.5 187.04,76.25 UC3.8 183.94,76.25 183.52,76.67 CC7.1 ; UC2.8 176.08,76.25 v2(176.18,76.15) ; v2(174.31,68.47) 173.38,69.39 JSPI1.15
+3.3V_SUS: length 282.9
  TOP w0.203: UI4.9 v2(130.93,128.16) ; 133.29,128.9 133.29,129.58 133.15,129.72 UI4.12 ; UI4.29 126.25,130.92 125.97,131.2 v2(125.87,131.2) ; UI4.3 v2(128.53,128.16) ; UI4.16 133.15,131.32 133.33,131.5 133.33,132.05 ; UI4.20 130.53,132.58 130.63,132.68 130.63,133.02 130.41,133.25 130.41,133.96 CI418.1
  TOP w0.508: 133.29,128.9 133.37,128.82 CI416.1 133.37,126.56 v2(133.04,126.23) ; v2(131.57,134.39) 130.84,134.39 CI418.1 ; 133.33,132.05 133.33,133.91 CI417.1 132.59,134.14 v2(132.34,134.39)
  IN2 w1.016: 129.82,129.15 127.42,129.15 126.62,128.35 126.62,126.67 128.08,125.21 128.08,124.2 127.69,123.8 126.15,123.8 125.31,122.96 123.27,122.96 123.09,123.14 109.53,123.14 107.04,125.63 103.6,125.63 100.78,128.45 99.19,128.45 98.71,127.97 94.43,127.97 93.7,127.24 85.98,127.24 79.7,120.96 79.7,114.61 77.18,112.09
  IN2 w2.032: 200.64,30.74 200.6,30.74 199.16,32.17 199.16,37.69 198.64,38.2 198.64,41.52 200.38,43.26
  IN3 w1.016: 75.06,110.48 73.23,108.65 73.23,105.26 73.88,104.61 74.62,104.61 75.31,103.91 75.31,98.86 80.43,93.74 80.43,88.13 83.76,84.8 83.76,80.51 92.75,71.52 92.75,60.94 105.62,48.07 140.77,48.07 142.7,46.14 176.55,46.14 182.83,39.86 196.98,39.86 199.71,37.13 199.71,32.31 200.92,31.11
  vias: v2(77.26,111.14) v2(77.89,111.14) v2(200.95,45.36) v2(200.93,44.77) v2(201.56,45.38) v2(201.53,44.8) v2(202.11,30.19) v2(202.11,29.61) v2(202.69,30.19) v2(202.69,29.61) v2(220.09,46.79) v2(220.09,46.21) v2(220.68,46.79) v2(220.68,46.21) v3(201.64,28.65)
+3.3V_SUS_UZ8:
  vias: v1(199.28,30.75)
+3.3V_TP: length 5.1
  TOP w0.102: RZ19.1 205.7,57.73 v3(206.42,57.73)
  TOP w0.508: 202.14,59.21 202.36,58.98 204.87,58.98 205.12,58.73 RZ19.1
+3.3V_VMM_UV10: length 3.7
  BOTTOM w0.102: v1(139.11,106.96) 139,107.06 137.18,107.06 137.07,106.96 137.07,106.28 137.61,105.74 CV118.2
