# Allegro board LAA961PR10-1007A.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PS8338_HPD: length 16.7
  TOP w0.102: UV7.32 126,115.58 v2(125.92,115.5) ; v2(137.49,119.75) 137.66,119.91 UV600.3
  IN3 w0.122: v2(125.92,115.5) 126.02,115.5 128.71,118.18 129.14,118.18 129.36,117.97 134.46,117.97 135.05,118.56 137.19,118.56 137.49,118.87 v2(137.49,119.75)
  BOTTOM w0.102: v2(137.49,119.75) v1(137.98,119.27)
PS8338_N0: length 5
  TOP w0.102: UV7.39 127.49,118.38 127.57,118.46 127.87,118.46 127.94,118.38 128.73,118.38 128.74,118.37 129.28,118.37 129.29,118.38 130.83,118.38 130.9,118.46 131.16,118.46 CV607.1
PS8338_N0_C: length 6.2
  TOP w0.102: CV607.2 132.85,118.41 133.39,118.41 133.4,118.39 133.94,118.39 133.95,118.41 v4(134.95,118.41) 137.86,118.41 137.95,118.31 UV600.7
PS8338_N1: length 3.1
  TOP w0.102: CV609.1 129.35,117.08 128.73,117.08 128.46,117.35 127.88,117.35 127.87,117.36 127.62,117.36 127.44,117.18 UV7.36
PS8338_N1_C: length 8.4
  TOP w0.102: CV609.2 130.85,117.19 v4(133.81,117.19) 135.66,117.19 135.89,116.96 136.1,116.96 136.11,116.94 136.64,116.94 136.65,116.96 137.44,116.96 137.67,117.19 137.93,117.19 138,117.11 UV600.10
PS8338_N2: length 5.1
  TOP w0.102: UV7.33 127.49,115.98 127.58,116.07 128.1,116.07 128.11,116.06 128.64,116.06 128.65,116.07 131.28,116.07 CV611.1
PS8338_N2_C: length 6.4
  TOP w0.102: UV600.13 137.95,115.91 137.86,116.01 v4(137.24,116.01) 135.77,116.01 135.42,115.66 133.42,115.66 133.03,116.04 132.93,116.04 CV611.2
PS8338_N3: length 3.1
  TOP w0.102: CV613.1 129.26,114.87 v4(128.4,114.87) 127.58,114.87 127.49,114.78 UV7.30
PS8338_N3_C: length 8.1
  TOP w0.102: CV613.2 130.89,114.76 v4(132.15,114.76) 137.98,114.76 138.02,114.71 UV600.16
PS8338_P0: length 5
  TOP w0.102: UV7.40 127.49,118.78 127.59,118.67 127.96,118.67 128.03,118.6 v4(129.01,118.6) 130.74,118.6 130.81,118.67 131.26,118.67 CV606.1
PS8338_P0_C: length 6.2
  TOP w0.102: UV600.6 137.95,118.71 137.86,118.62 135.23,118.62 135.22,118.64 134.69,118.64 134.67,118.62 v4(133.67,118.62) 132.85,118.62 CV606.2
PS8338_P1: length 3.1
  TOP w0.102: UV7.37 v4(128.15,117.58) 128.54,117.58 128.82,117.3 129.14,117.3 CV608.1
PS8338_P1_C: length 8.4
  TOP w0.102: CV608.2 130.86,117.4 133.53,117.4 133.54,117.41 134.08,117.41 134.09,117.4 135.75,117.4 135.98,117.17 v4(136.38,117.17) 137.35,117.17 137.58,117.4 137.84,117.4 137.95,117.51 UV600.9
PS8338_P2: length 5
  TOP w0.102: UV7.34 127.49,116.38 127.58,116.28 v4(128.37,116.28) 131.32,116.28 CV610.1
PS8338_P2_C: length 6.5
  TOP w0.102: CV610.2 132.95,116.26 133.12,116.26 133.5,115.88 135.33,115.88 135.68,116.22 136.96,116.22 136.97,116.23 137.5,116.23 137.52,116.22 137.86,116.22 137.95,116.31 UV600.12
PS8338_P3: length 3.1
  TOP w0.102: CV612.1 129.33,115.09 128.68,115.09 128.67,115.1 128.13,115.1 128.12,115.09 127.58,115.09 127.49,115.18 UV7.31
PS8338_P3_C: length 8.2
  TOP w0.102: UV600.15 137.95,115.11 137.81,114.98 132.42,114.98 132.41,114.99 131.88,114.99 131.87,114.98 131.08,114.98 CV612.2
PS8338_SW: length 8
  TOP w0.102: UV600.18 138.53,113.91 136.19,113.91 134.33,112.06 v1(133.58,112.06) 132.04,112.06 RV602.2
PS8338B_P0: length 6.9
  TOP w0.102: RV615.2 133.73,121.09 136.06,121.09 136.3,121.33 v1(136.59,121.33) 138.39,121.33 139,121.94 139.09,121.94 139.22,121.81 UV600.60
PS8338B_P1: length 6.8
  TOP w0.102: v1(132.39,120.04) 133.81,120.04 RV100.1 134.63,120.86 136.34,120.86 136.79,120.4 RV603.2 137.55,120.4 137.86,120.71 UV600.1
PS8338B_PC10: length 6.2
  TOP w0.102: UV600.56 140.82,121.87 140.7,121.99 140.7,122.87 RV620.1 141.23,123.4 141.23,124.26 140.93,124.55 140.68,124.55 v1(140.17,125.06) 140.17,125.25 140.3,125.38 140.3,125.86 RV614.2
PS8338B_PC11: length 5.9
  TOP w0.102: RV613.2 141.46,125.62 v1(141.46,125.21) 141.46,123.4 RV619.1 141.91,122.51 141.22,121.81 UV600.55
PS8338B_PC20: length 6.5
  TOP w0.102: RV612.2 v1(142.9,125.09) 143.28,124.7 143.28,123.4 RV618.1 142.71,122.94 141.62,121.84 UV600.54
PS8338B_PC21: length 8
  TOP w0.102: UV600.53 142.02,121.88 142.61,122.47 143.88,122.47 144.27,122.86 v1(144.27,123.73) 144.27,125.52 RV617.1 RV611.2
PS8338B_PEQ: length 11.4
  TOP w0.102: v2(137.61,117.81) 137.71,117.91 UV600.8 ; v2(130.23,119.05) 130.23,119.43 130.29,119.49 RV616.1 RV610.2
  BOTTOM w0.102: v2(137.61,117.81) 137.33,117.53 137.18,117.53 136.87,117.22 v1(135.18,117.22) 134.53,117.22 134.2,116.89 132.39,116.89 v2(130.23,119.05)
PS8339B_DP_CFG0: length 3.3
  TOP w0.102: RV51.2 RV52.1 125.53,121.01 UV7.44
PS8339B_DP_CFG1: length 3.8
  TOP w0.102: UV7.29 127.41,114.38 RV61.1 RV54.2 128.32,111.75 v1(128.18,111.61)
PS8339B_IN_CA_DET: length 4.9
  TOP w0.102: RV68.2 115.67,114.27 116.14,114.73 118.05,114.73 v1(118.64,115.31) 118.9,115.58 UV7.11
PS8339B_INPUT_EQ: length 5.5
  TOP w0.102: UV7.8 v1(118.65,116.78) 118.52,116.78 118.27,116.53 116.05,116.53 RV58.2 RV65.1
PS8339B_MODE: length 5.6
  TOP w0.102: UV7.53 121.93,121.8 RV57.2 121.88,122.76 121.88,123.9 v1(122.2,124.22) 123.08,125.1 RV63.1
PS8339B_MODE_SW: length 2.8
  TOP w0.102: UV7.45 125.13,121.85 125.05,121.94 RV551.2 RV550.1
PS8339B_OUT_CA_DET: length 2.5
  TOP w0.102: UV7.42 127.45,119.58 127.8,119.93 127.8,120.25 RV67.2
PS8339B_TMDS_DDCBUF: length 3.7
  TOP w0.102: UV7.2 119.23,119.18 v1(118.66,119.75) 118.41,120 118.23,120 RV60.2 RV66.1
PS8339B_TMDS_PRE: length 4.3
  TOP w0.102: v1(120.4,111.01) 120.83,111.45 RV56.2 RV64.1 122.44,111.65 122.44,112.78 122.73,113.07 UV7.20
PS8339B_TMDS_RT: length 3.1
  TOP w0.102: UV7.23 123.93,112.84 123.84,112.75 123.84,112.14 124.15,111.83 RV55.2 RV62.1
PS_ID: length 166.3
  TOP w0.102: v2(206.57,95.94) 206.62,95.99 UE2.B24
  TOP w0.254: v2(70.64,121.61) 69.96,120.92 PU1.4
  IN3 w0.122: v2(201.3,117.4) 201.11,117.59 186.91,117.59 182.88,121.63 172.09,121.63 168.91,124.81 152.28,124.81 151.53,125.55 149.56,125.55 148.29,126.81 142.32,126.81 139.46,123.96 134.01,123.96 133.91,123.85 128.71,123.85 124.82,119.96 105.77,119.96 104.37,121.36 70.88,121.36 v2(70.64,121.61)
  BOTTOM w0.102: v2(201.3,117.4) 201.77,116.94 201.77,108.33 PT3.1 202.77,107.33 202.77,103.42 204.6,101.59 205.17,101.59 205.59,101.17 205.59,100.06 206.85,98.8 206.85,96.22 v2(206.57,95.94)
PS_USBP0_D+: length 4.3
  TOP w0.102: LI3.1 61.2,124.11 61.13,124.17 61.13,124.55 61.08,124.6 60.91,124.6 60.52,124.21 60.52,122.37 60.65,122.24 UI3.10
PS_USBP0_D-: length 4.3
  TOP w0.102: UI3.11 60.15,122.26 60.3,122.42 60.3,124.3 60.82,124.82 61.06,124.82 61.2,124.96 LI3.4
PSID_DISABLE#: length 136.8
  TOP w0.102: UE1.A37 188.4,99.84 v2(188.72,100.17) 188.97,99.93 v1(188.97,99.6)
  TOP w0.254: PR13.2 v2(71.24,115.5)
  IN3 w0.122: v2(188.72,100.17) 188.68,100.12 187.71,100.12 187.4,99.82 184.66,99.82 183.95,100.52 182.1,100.52 181.92,100.71 178.51,100.71 178.19,101.03 171.21,101.03 169.36,102.88 169.36,103.38 167.73,105.02 165.92,105.02 164.52,106.42 159.87,106.42 158.47,105.02 148.69,105.02 145.99,107.71 145.99,113.72 145.26,114.45 143.62,114.45 143.41,114.66 128.71,114.66 127.1,113.05 118.11,113.05 116.62,114.55 113.89,114.55 112.89,115.55 101.68,115.55 100.69,116.55 100.29,116.55 98.6,118.24 91.55,118.24 90.07,116.76 83.57,116.76 81.82,118.51 73.68,118.51 71.24,116.07 v2(71.24,115.5)
PWM1: length 15.9
  TOP w0.102: v2(95.89,112.86) 95.89,112.69 v1(96.19,112.39)
  IN3 w0.254: v2(95.89,112.86) 94.52,112.86 94.05,112.39 94.05,111.52 93.47,110.95 92.64,110.95 92.36,110.67 92.36,110.07 91.96,109.68 91.07,109.68 89.39,108 v2(89.39,103.64)
  BOTTOM w0.203: v2(89.39,103.64) 89.42,103.64 89.35,103.57 PU500.6
PWR_SRC_ON:
  vias: v1(91.07,113.91)
RED_DOCK: length 29
  TOP w0.102: v1(157.3,125.66) 157.3,125.74 v2(155.81,127.23) 155.81,127.91 RV76.1
  IN2 w0.122: v2(155.81,127.23) 155.39,126.8 154.26,126.8 153.64,126.18 152.99,126.18 152.52,125.7 152.52,118.74 150.07,116.29 149.64,116.29 149.06,115.71 149.06,112.44 147.43,110.81 v2(146.92,110.81)
  BOTTOM w0.102: v2(146.92,110.81) 147.37,110.81 147.97,111.41 UV8.M6 ; JDOCK1.53 155.75,127.29 v2(155.81,127.23)
REGCTL_PNP10: length 1
  TOP w0.203: UL1.7 208.55,111.6 v2(208.75,111.4)
  vias: v1(208.17,111.61)
REM_DIODE1_N: length 139
  TOP w0.254: v2(212.22,94.92) 212.61,95.32 CE24.1 213.12,95.32 213.59,94.85 v2(213.68,94.85) ; v2(209.46,94.26) 209.55,94.26 209.81,94 UE2.B13 ; QE3.3 116.83,81.34 CE35.1 117.29,80.87 123.37,80.87 123.67,80.57 124.44,80.57 v2(124.57,80.7)
  IN1 w0.254: v2(209.46,94.26) 209.74,94.26 210.33,94.85 212.14,94.85 v2(212.22,94.92)
  IN4 w0.254: v2(213.68,94.85) 213.67,94.85 213.17,95.35 213.17,96.73 209.92,99.98 209.32,99.98 208.88,100.42 203.39,100.42 202.73,101.08 200.16,101.08 199.1,100.03 197.62,100.03 197.28,99.69 186.5,99.69 186.44,99.75 185.04,99.75 184.34,100.45 181.17,100.45 180.33,99.61 178.51,99.61 176.6,97.7 176.6,95.7 175.16,94.26 175.16,92.49 173.1,90.43 173.1,89.57 172.02,88.49 172.02,82.43 171.25,81.66 166.72,81.66 164.95,79.89 164.95,79.23 164.36,78.64 161.53,78.64 157.86,74.98 157.86,74.83 157.26,74.22 156.32,74.22 154.92,72.83 147.22,72.83 146.23,71.83 140.47,71.83 136.07,67.43 134.22,67.43 133.58,68.06 131.9,68.06 131.57,68.4 131.57,69.07 130.97,69.66 130.08,69.66 129.46,70.29 129.46,74.48 128.89,75.05 128.89,75.43 128.28,76.03 128.03,76.03 127.62,76.44 127.62,79.6 126.88,80.33 124.94,80.33 v2(124.57,80.7)
REM_DIODE1_P: length 138.3
  TOP w0.254: QE3.1 114.6,80.04 QE3.2 116.34,80.04 116.54,80.24 CE35.2 117.14,80.37 v4(120.39,80.37) 123.16,80.37 123.46,80.06 124.38,80.06 v2(124.57,79.87) ; v2(213.68,94.26) 213.44,94.26 213.3,94.4 CE24.2 212.46,94.4 212.31,94.25 UE2.A13
  IN4 w0.254: v2(213.68,94.26) 213.6,94.34 213.46,94.34 212.66,95.14 212.66,96.52 209.71,99.47 209.11,99.47 208.67,99.91 203.18,99.91 202.52,100.57 200.37,100.57 199.31,99.52 197.83,99.52 197.49,99.18 186.29,99.18 186.23,99.24 184.83,99.24 184.13,99.94 181.38,99.94 180.54,99.1 178.72,99.1 177.1,97.49 177.1,95.49 175.67,94.05 175.67,92.28 173.61,90.22 173.61,89.36 172.53,88.28 172.53,82.22 171.47,81.16 166.93,81.16 165.46,79.68 165.46,79.02 164.57,78.13 161.74,78.13 158.37,74.77 158.37,74.62 157.47,73.71 156.53,73.71 155.13,72.32 147.43,72.32 146.44,71.33 140.68,71.33 136.28,66.92 134.01,66.92 133.37,67.55 131.69,67.55 131.06,68.19 131.06,68.86 130.76,69.15 129.87,69.15 129.08,69.95 129.08,74.32 128.51,74.89 128.51,75.27 128.13,75.65 127.87,75.65 127.24,76.29 127.24,79.44 126.73,79.95 124.78,79.95 124.73,80 124.7,80 v2(124.57,79.87)
REM_DIODE2_N: length 107.5
  TOP w0.254: UE2.B14 209.97,94.5 209.62,94.86 v2(209.43,94.86) ; v2(215.06,96.21) CE26.1 v2(213.68,96.21)
  IN1 w0.254: v2(213.68,96.21) 212.87,96.21 212.16,95.49 210.06,95.49 v2(209.43,94.86)
  IN4 w0.254: v2(201.36,47.16) 201.2,47.16 200.31,48.05 200.31,49.56 200.95,50.21 200.95,61.46 200.32,62.09 200.32,73.98 197.92,76.38 197.92,77.8 196.03,79.69 196.03,89.7 v2(196.08,89.76) 196.08,89.76 196.08,90.32 197.44,91.67 200.67,91.67 201,91.34 202.88,91.34 203.51,90.71 207.53,90.71 207.83,90.4 209.8,90.4 210.74,89.46 212.28,89.46 212.54,89.72 213.68,89.72 215.1,91.13 215.1,91.14 215.5,91.54 215.5,91.54 215.81,91.84 215.81,94.01 216.12,94.32 216.12,95.47 215.65,95.94 215.33,95.94 v2(215.06,96.21)
  BOTTOM w0.254: v2(201.36,47.16) 201.36,47.03 202.85,45.54 202.85,43.35 204.37,41.82 v4(204.37,40.62) 204.37,38.9 CE37.2 204.56,38.03 QE5.3 ; QE7.1 195.82,103.08 196.47,102.43 QE7.2 196.47,101.34 CE46.2 196.03,100.89 196.03,100.07 195.07,99.11 195.07,97.29 196.02,96.34 196.02,94.19 195.86,94.03 195.86,90.26 196.08,90.04 v2(196.08,89.76)
REM_DIODE2_P: length 104.1
  TOP w0.254: UE2.A14 211.41,94.75 211.69,95.02 211.69,95.21 212.35,95.88 213.29,95.88 213.59,95.57 214.04,95.57 CE26.2 v2(215.06,95.29)
  IN4 w0.254: v2(200.78,46.7) 200.78,46.86 199.8,47.84 199.8,49.77 200.45,50.42 200.45,61.25 199.81,61.88 199.81,73.77 197.41,76.17 197.41,77.59 195.52,79.48 195.52,89.73 v2(195.5,89.76) 195.5,89.95 195.57,90.02 195.57,90.53 197.23,92.18 200.88,92.18 201.21,91.85 203.09,91.85 203.72,91.21 207.74,91.21 208.04,90.91 210.01,90.91 210.95,89.97 212.07,89.97 212.33,90.22 213.47,90.22 214.59,91.35 214.59,91.35 215.28,92.04 215.29,92.04 215.3,92.05 215.3,94.22 215.61,94.53 215.61,95.26 215.44,95.43 215.2,95.43 v2(215.06,95.29)
  BOTTOM w0.254: v2(200.78,46.7) 200.97,46.7 202.34,45.33 202.34,43.14 203.86,41.61 203.86,38.93 CE37.1 203.78,38.58 QE5.2 203.78,36.87 204.43,36.22 QE5.1 ; QE7.3 195.17,101.29 CE46.1 195.52,100.94 195.52,100.28 194.57,99.32 194.57,97.08 195.52,96.13 195.52,94.4 195.35,94.24 195.35,89.9 v2(195.5,89.76)
REM_DIODE4_N: length 151.5
  TOP w0.254: UE2.A16 211.51,95.75 212.19,96.43 CE27.1 213.22,96.43 v2(213.68,96.89) ; v2(91.29,93.04) 91.34,93.09 91.34,93.25 90.33,94.26 87.57,94.26 86.72,95.11 85.97,95.11 85.77,94.91 CE39.1 82.53,94.91 QE6.3
  IN1 w0.254: v2(213.68,96.89) 213.67,96.9 211.81,96.9 207.21,101.5 204.39,101.5 201.33,104.56 195.63,104.56 195.45,104.74 193.89,104.74 193.71,104.56 188.22,104.56 188.07,104.41 175.48,104.41 174.69,103.62 171.91,103.62 168.99,100.7 165.19,100.7 163.28,98.8 156.62,98.8 156.03,99.38 146.73,99.38 145.85,98.5 137.25,98.5 136.6,99.15 135.66,99.15 135.09,98.58 134.24,98.58 133.94,98.29 131.81,98.29 131.52,98.58 131.11,98.58 130.83,98.3 130.83,96.21 129.28,94.66 127.07,94.66 125.95,93.54 125.95,90.03 125.18,89.26 105.36,89.26 104.32,90.3 98.61,90.3 97.07,91.84 91.87,91.84 91.35,92.36 91.35,92.98 v2(91.29,93.04)
REM_DIODE4_P: length 152.9
  TOP w0.254: UE2.B17 210.5,96 210.77,96.27 211.29,96.27 212.37,97.35 CE27.2 213.22,97.53 v2(213.68,97.53) ; QE6.2 83.26,96.21 83.91,95.56 QE6.1 84.7,95.82 CE39.2 86.15,95.82 86.35,95.62 86.93,95.62 87.78,94.77 90.54,94.77 91.85,93.46 91.85,93.1 v2(91.9,93.04)
  IN1 w0.254: v2(91.9,93.04) 91.86,93 91.86,92.57 92.08,92.35 97.28,92.35 97.97,91.66 98.82,90.81 104.53,90.81 105.57,89.76 124.97,89.76 125.44,90.24 125.44,93.75 126.86,95.17 129.07,95.17 130.32,96.42 130.32,98.51 130.9,99.09 131.73,99.09 132.02,98.8 133.73,98.8 134.03,99.09 134.88,99.09 135.45,99.66 136.81,99.66 137.46,99 145.64,99 146.52,99.89 156.25,99.89 156.83,99.31 163.07,99.31 164.98,101.21 168.78,101.21 171.7,104.13 174.48,104.13 175.27,104.92 187.86,104.92 188.01,105.07 193.5,105.07 193.68,105.25 195.66,105.25 195.84,105.07 201.54,105.07 204.6,102.01 207.42,102.01 212.02,97.41 213.57,97.41 v2(213.68,97.53)
RES_BIAS: length 4.1
  TOP w0.102: RL13.1 212.56,110.55 212.56,111.01 v1(212.48,111.08) 212.13,111.43 210.84,111.43 210.55,111.72 UL1.12
RESET_OUT#: length 268.1
  TOP w0.102: v2(73.93,78.07) 74.1,77.9 v3(74.68,77.9) 76.45,77.9 76.65,78.1 UC8.2 ; v2(202.76,93.81) 202.74,93.82 201.52,93.82 201.34,94 UE2.B39 ; RE56.2 191.57,94.48 v2(192.83,93.22)
  IN1 w0.084: v2(202.76,93.81) 202.75,93.81 200.23,93.81 199.79,93.37 198.71,93.37 198.19,93.89 195.96,93.89 195.68,93.61 194.5,93.61 193.97,93.08 192.97,93.08 v2(192.83,93.22) ; v2(173.05,48.56) 172.72,48.23 167.26,48.23 163.78,51.71 155.17,51.71 153.28,53.59 145.48,53.59 137.42,61.66 v2(137.42,61.74) ; v2(60.56,44.17) 60.23,44.17 58.48,45.92 58.48,49.74 58.35,49.87 58.35,67.61 69.14,78.4 73.6,78.4 v2(73.93,78.07)
  IN2 w0.089: v2(137.42,61.74) 136.44,60.76 136.44,58.64
  IN2 w0.122: 136.44,58.64 136.44,55.15 133.58,52.28 85.57,52.28 84.97,52.89 79.09,52.89 69,42.79 61.94,42.79 v2(60.56,44.17) ; v2(192.83,93.22) 192.36,93.22 190.69,91.56 189.64,91.56 189.02,90.94 189.02,89.3 189.63,88.69 190.58,88.69 191.25,88.02 191.25,85.34 191.83,84.77 191.83,78.96 189.9,77.03 189.9,74.96 188.02,73.08 177.74,73.08 176.15,71.49 172.27,71.49 171.63,70.84 171.63,67.16 170.82,66.35 170.82,64.8 171.95,63.67 171.95,51.14 173.05,50.04 v2(173.05,48.56)
  BOTTOM w0.089: v2(137.42,61.74) 138.01,62.33 138.01,63.18 134.69,66.5 UC1.AY7
RING2: length 5.8
  IN1 w1.016: 215.81,71.68 213.17,71.68 212.16,70.67 212.16,68.99
  vias: v1(218.35,71.59) v2(210.54,69.51) v2(210.97,69.08) v2(217.71,71.96) v2(217.71,71.33)
RSMRST#: length 33.2
  TOP w0.102: RZ51.2 171.71,78.65 178.49,78.65 179.25,79.41 179.25,84.56 v2(179.5,84.81) ; UZ6.2 185.79,89.07 185.43,88.71 185.43,85.22 RZ22.2 186.01,85.07 186.84,85.91 v2(187.73,85.91) 187.94,85.7 187.94,85.06 188.2,84.79 UZ5.3
  IN3 w0.122: v2(179.5,84.81) 179.94,85.25 180.19,85.25 181.4,86.46 186.75,86.46 187.3,85.91 v2(187.73,85.91)
RUN_ON: length 323.9
  TOP w0.102: v3(193.39,84.66) 192.96,84.66 192.68,84.38 192.68,84.1 192.56,83.99 192.56,83.78 192.98,83.37 193.12,83.37 193.47,83.02 v2(193.47,83) 193.59,83.11 QE2.2 ; v2(212.45,84.79) 212.9,84.33 RE279.2 RE280.2 ; v2(204.88,102.53) 204.87,102.54 RPE10.1
  TOP w0.203: v2(58.79,60.32) 58.77,60.33 UZ9.3 ; UZ9.5 58.76,61.13 v2(58.79,61.17) ; UZ7.3 131.49,97.91 v2(131.31,98.1)
  IN1 w0.254: v2(58.79,61.17) v2(58.79,60.32)
  IN2 w0.122: v2(185.5,63.14) 190.16,63.14 190.63,63.6 194.02,63.6 194.77,64.35 194.77,66.09 193.63,67.23 193.63,68 192.57,69.05 192.57,70.6 191.43,71.74 191.43,77.09 193.47,79.13 v2(193.47,83)
  IN3 w0.122: v2(131.31,98.1) 132.47,98.1 132.54,98.17 138.98,98.17 139.58,98.77 139.58,99.69 139.26,100 137.66,100 137.37,100.29 137.37,100.64 138.06,101.33 138.61,101.33 139.32,102.04 140.08,102.04 ; v2(204.88,102.53) 204.85,102.56 198.44,102.56 197.78,101.9 195.25,101.9 192.16,98.81 191.01,98.81 189.57,97.36 188.22,97.36 187.14,98.44 187.14,98.73 186.57,99.3 184.79,99.3 184.47,98.99 181.36,98.99 181,99.34 178.6,99.34 177.44,100.51 167.56,100.51 166.5,101.56 155.61,101.56 155.13,102.04 140.08,102.04 ; 140.08,102.04 140.08,104.13 138.8,105.41 135.85,105.41 134.98,104.54 134.98,103.84 134.66,103.52 133.05,103.52 132.58,103.99 132.58,107.76 131.09,109.25 130.2,109.25 129.54,109.91 127.19,109.91 126.05,111.05 119.41,111.05 116.41,114.05 113.69,114.05 112.68,115.05 101.48,115.05 100.48,116.05 98.13,116.05 96.76,114.67 93.79,114.67 92.42,116.05 83.58,116.05 81.62,118.01 75.81,118.01 70.55,112.76 70.55,102.23 70.74,102.04 70.74,102.04 71.54,101.23 71.54,97.03 76.58,92 v2(77.35,92)
  IN4 w0.084: v2(193.47,83) 194.82,84.35 194.82,90.73 196.99,92.9 199.1,92.9 199.25,93.06 200.32,93.06 200.39,92.99 201.26,92.99 201.42,92.83 202.82,92.83 202.97,92.68 207.67,92.68 v2(208.51,93.53)
  BOTTOM w0.102: v2(212.45,84.79) 212.09,85.14 212.09,85.89 210.39,87.59 210.39,88.98 207.89,91.48 207.89,92.9 v2(208.51,93.53) 208.61,93.63 209.59,93.63 209.97,94.01 209.97,96.09 208.79,97.27 208.79,98.45 208.18,99.07 208.18,100.89 206.1,102.97 205.32,102.97 v2(204.88,102.53) ; RZ41.1 v2(185.5,63.14)
  BOTTOM w0.254: v2(58.79,61.17) 59.2,60.76 60.77,60.76 67.5,67.49 67.5,68.94 76.3,77.74 76.3,83.58 75.76,84.13 75.28,84.13 75.06,84.35 75.06,89.72 v2(77.35,92)
RUN_ON#: length 3.8
  TOP w0.102: 196.6,83.76 v1(197.04,83.76) ; 196.6,83.76 196.6,83.24 196.47,83.11 QE2.5 ; 196.6,83.76 QE2.6 ; 196.6,83.76 196.6,84.51 196.28,84.83 RE68.2
RUN_ON_EC: length 17.2
  TOP w0.102: v2(209.58,92.22) 209.75,92.22 209.97,92 UE2.B9 ; RE279.1 v2(212.9,81.83)
  BOTTOM w0.102: v2(212.9,81.83) 213.32,82.25 213.32,86.17 212.72,86.77 211.8,86.77 210.62,87.95 210.62,89.08 208.12,91.58 208.12,92.21 208.55,92.64 209.17,92.64 v2(209.58,92.22)
RUNPWROK: length 291.7
  TOP w0.102: UC7.10 61.57,69.11 61.23,69.45 v2(61.23,69.88) ; UC7.4 65.41,68.61 v2(65.5,68.7) ; UC7.13 61.77,67.61 61.64,67.48 v2(61.64,67.06) ; UE1.A4 176.36,103.84 176.15,103.64 v2(176.15,103.03) ; UE2.B26 v2(205.62,95.94) ; v2(192.53,83.13) 192.53,82.77 192.84,82.46 QE2.3 194.12,81.48 RE67.2 v1(194.05,80.24) ; v2(64.59,66.09) 64.01,66.09 63.6,66.51 UC7.1
  IN1 w0.084: v2(58.04,37.52) 58.93,38.41 58.93,38.6 60.71,40.38 60.71,41.81 61.49,42.59 61.49,43.87 61.58,43.96 61.58,46.62 60.79,47.41 60.79,49.94 60.01,50.72 60.01,52.57 60.43,52.99 60.43,55.78 63.64,58.99 63.64,59.23 64.59,60.18 v2(64.59,66.09) 65.22,66.72 65.22,68.42 v2(65.5,68.7) ; v2(205.62,95.94) 204.16,97.4 204.16,98.9 203.56,99.49 190.63,99.49 190.35,99.77 185.21,99.77 184.87,100.11 182.65,100.11 180.81,101.95 177.23,101.95 v2(176.15,103.03) ; v2(204.53,84.01) 204.48,84.06 200.59,84.06 200.4,84.26 196.03,84.26 195.31,83.53 192.94,83.53 v2(192.53,83.13) ; v2(61.23,69.88) 60.92,69.88 60.5,69.45 60.5,68.48 61.64,67.34 v2(61.64,67.06)
  IN2 w0.122: v2(192.53,83.13) 192.53,79.31 190.26,77.04 190.26,74.97 188.12,72.83 177.84,72.83 176.25,71.24 172.38,71.24 171.87,70.73 171.87,67.2 172.47,66.6 172.47,50.98 174.37,49.08 174.37,46.48 173.68,45.78 159.8,45.78 155.92,49.66 139.74,49.66 135.61,45.53 79.4,45.53 71.11,37.23 58.33,37.23 v2(58.04,37.52) ; v2(61.64,67.06) 63.63,67.06 v2(64.59,66.09) ; v2(205.62,95.94) 205.87,95.94 206.12,95.69 206.12,94.92 206.31,94.74 206.31,86.53 206.1,86.33 206.1,84.94 205.35,84.19 204.71,84.19 v2(204.53,84.01)
SATA2_PCIE6_L1: length 72.2
  TOP w0.089: 146.46,79 v1(146,79) 145.84,78.83 140.44,78.83 139.02,80.25 137.3,80.25 136.57,80.97 135.96,80.97 135.76,80.77 v2(135.76,80.57)
  TOP w0.102: RPC9.8 146.46,79 ; UE1.A62 179.69,107.57 v2(179.28,107.98)
  IN4 w0.084: v2(179.28,107.98) 178.22,106.93 176.62,106.93 175.39,105.7 173.61,105.7 171.31,103.4 171.31,102.13 156.57,87.39 155.32,87.39 151.98,84.04 148.74,84.04 145.69,80.99 140.15,80.99 139.8,81.34 138.59,81.34 138.17,81.76 136.96,81.76 135.77,80.57 v2(135.76,80.57)
  BOTTOM w0.089: UC1.V6 135.76,80.34 v2(135.76,80.57)
SATA_ACT#: length 74.5
  TOP w0.102: v2(189.74,107.83) v1(189.74,108.7) 189.74,110.61 190.57,111.43 190.57,115.56 190.35,115.78 QZ3.4
  IN4 w0.084: v2(189.74,107.83) 189.39,108.17 188.07,108.17 187.24,109 177.71,109 174.62,105.91 173.52,105.91 171.1,103.49 171.1,102.21 156.68,87.79 155.42,87.79 151.89,84.26 147.64,84.26 145.96,82.58 141.57,82.58 v2(140.38,81.38)
  BOTTOM w0.076: v2(140.38,81.38) 140.17,81.18 139.09,81.18 139.01,81.09 138.7,81.09 138.52,80.92 138.52,80.74 138.29,80.5 137.77,80.5 UC1.U3
SATA_COMP: length 6.6
  TOP w0.305: v2(132.59,92.52) 132.07,92.52 v1(131.66,92.93) 131,93.59 RC17.1
  BOTTOM w0.203: UC1.C12 131.72,89.09 131.72,89.76 132.09,90.13 132.09,91.08 132.33,91.32 132.33,92.26 v2(132.59,92.52)
SATA_LED: length 71
  TOP w0.102: v2(255.51,124.23) 255.51,125.39 257,126.87 LED6.2 ; v2(199.39,119.43) 199.39,117.74 198.29,116.64 v1(197.86,116.64) RZ36.2
  IN3 w0.122: v2(199.39,119.43) 200.1,120.15 212.78,120.15 213.9,119.03 214.27,119.03 216.23,121 219.21,121 219.61,121.39 240.97,121.39 242.34,122.76 250.43,122.76 250.95,123.28 254.56,123.28 v2(255.51,124.23)
SATA_LED#: length 2.3
  TOP w0.102: QZ12.2 196.7,120.13 QZ14.6 195.51,120.93 v1(195.25,121.19)
SATA_PRX_DKTX_N0: length 8
  TOP w0.102: C313.2 151.96,134.43 152.87,134.43 v4(153.49,135.06) 154.14,135.7 156,135.7 156.29,135.41 v2(156.29,134.8)
  BOTTOM w0.102: v2(156.29,134.8) 156.11,134.98 156.11,135.66 156.25,135.8 JDOCK1.56
SATA_PRX_DKTX_N0_C: length 66.9
  TOP w0.102: v2(148.18,134.14) 148.36,134.33 148.36,134.5 148.67,134.8 149.35,134.8 149.79,134.37 150.62,134.37 C313.1
  IN4 w0.091: v2(135.79,85.38) 135.79,85.49 135.69,85.59 135.49,85.59 135.25,85.82 135.25,87.33 134.72,87.87 134.72,93.82 134.05,94.49 134.05,97.99 134.49,98.43 134.49,100.24 134.9,100.65 134.9,108.49 134.19,109.2 134.19,114.03 132.8,115.41 132.8,118.05 133.76,119.01 133.76,124.63 134.95,125.81 138.9,125.81 139.3,126.21 141.34,126.21 145.86,130.74 148.72,130.74 148.99,131.01 148.99,131.41 148.9,131.5 148.9,133.35 148.18,134.07 v2(148.18,134.14)
  BOTTOM w0.089: UC1.J5 136.13,85.04 v2(135.79,85.38)
SATA_PRX_DKTX_P0: length 8
  TOP w0.102: v2(155.71,134.8) 156.08,135.17 156.08,135.32 155.91,135.49 154.23,135.49 153.84,135.1 153.84,135.08 153.47,134.71 153.45,134.71 152.96,134.22 152.28,134.22 C312.2
  BOTTOM w0.102: v2(155.71,134.8) 155.89,134.99 155.89,135.66 155.75,135.8 JDOCK1.54
SATA_PRX_DKTX_P0_C: length 66.8
  TOP w0.102: v2(148.76,134.14) 148.58,134.33 148.58,134.41 148.76,134.59 149.26,134.59 149.7,134.15 151.01,134.15 151.07,134.09 151.07,133.92 C312.1
  IN4 w0.091: v2(135.82,86.02) 135.82,85.86 135.73,85.77 135.56,85.77 135.43,85.9 135.43,87.4 134.89,87.94 134.89,93.89 134.22,94.56 134.22,97.92 134.66,98.36 134.66,100.17 135.07,100.57 135.07,108.56 134.36,109.27 134.36,114.1 132.97,115.48 132.97,117.97 133.94,118.94 133.94,124.55 135.02,125.63 138.97,125.63 139.38,126.04 141.41,126.04 145.93,130.56 148.79,130.56 149.16,130.94 149.16,131.48 149.07,131.58 149.07,133.43 148.71,133.78 148.71,134.09 v2(148.76,134.14)
  BOTTOM w0.089: UC1.H5 136.15,85.69 v2(135.82,86.02)
SATA_PRX_DTX_N1: length 145.4
  IN1 w0.084: 139.99,94.92 139.98,94.94 139.97,94.94 139.97,94.95 139.46,95.46 136.56,95.46 136.18,95.84 132.62,95.84 131.88,95.1 131.36,95.1 129.69,93.43 129.69,90.4 129.34,90.05 129.34,88.55 129.69,88.19 129.69,85.18 129.93,84.95 134.07,84.95 134.31,85.18 134.31,85.49 134.15,85.64 133.96,85.64 133.9,85.58 v2(133.9,85.36)
  IN1 w0.091: v2(218.01,79.87) 217.78,80.1 217.08,80.1 216.19,81 209.97,81 208.83,79.86 204.99,79.86 203.81,81.04 198.6,81.04 197.98,81.66 191.78,81.66 190.62,82.82 186.7,82.82 185.69,83.83 185.69,85.17 182.91,87.94 179.84,87.94 178.32,89.46 176.15,89.46 175.26,90.35 175.1,90.35 171.67,93.78 168.21,93.78 166.6,95.39 157.41,95.39 156.54,96.25 148.74,96.25 147.21,94.72 140.19,94.72 139.99,94.92
  BOTTOM w0.089: v2(133.9,85.36) 133.78,85.24 133.78,84.98 133.87,84.89 134.16,84.89 UC1.J8
  BOTTOM w0.102: CN36.1 221.38,108.68 221.38,104.69 220.84,104.16 220.84,97.83 219.38,96.37 219.38,80.65 218.78,80.04 218.18,80.04 v2(218.01,79.87)
SATA_PRX_DTX_N1_RP_C: length 1.9
  BOTTOM w0.102: CN36.2 221.51,110.16 221.51,110.87 221.65,111.01 JSATA1.5
SATA_PRX_DTX_P1: length 145.4
  IN1 w0.084: 140.11,95.05 140.1,95.06 140.09,95.06 140.06,95.09 139.53,95.62 136.63,95.62 136.25,96 132.55,96 131.81,95.27 131.3,95.27 129.53,93.5 129.53,90.47 129.17,90.11 129.17,88.48 129.53,88.12 129.53,85.11 129.86,84.79 134.14,84.79 134.47,85.11 134.47,85.56 134.22,85.81 134.11,85.81 v2(133.9,86.01)
  IN1 w0.091: v2(218.01,80.46) 217.83,80.27 217.16,80.27 216.26,81.17 209.9,81.17 208.76,80.03 205.06,80.03 203.88,81.21 198.67,81.21 198.05,81.83 191.85,81.83 190.69,82.99 186.77,82.99 185.86,83.9 185.86,85.24 182.98,88.12 179.91,88.12 178.39,89.63 176.22,89.63 175.33,90.52 175.17,90.52 171.74,93.95 168.29,93.95 166.68,95.56 157.48,95.56 156.61,96.43 148.67,96.43 147.14,94.9 140.26,94.9 140.11,95.05
  BOTTOM w0.089: v2(133.9,86.01) 134.22,85.69 UC1.H8
  BOTTOM w0.102: v2(218.01,80.46) 218.21,80.26 218.69,80.26 219.17,80.74 219.17,96.46 220.63,97.92 220.63,104.25 221.17,104.78 221.17,108.68 CN35.1
SATA_PRX_DTX_P1_RP_C: length 2
  BOTTOM w0.102: CN35.2 221.29,110.42 221.29,110.87 221.15,111.01 JSATA1.6
SATA_PTX_DKRX_N0: length 13
  TOP w0.102: C315.1 150.29,132.68 151.83,132.68 153.04,131.47 156.3,131.47 157.67,132.84 157.67,134.94 v2(157.79,135.06)
  BOTTOM w0.102: v2(157.79,135.06) 157.61,135.24 157.61,135.66 157.75,135.8 JDOCK1.62
SATA_PTX_DKRX_N0_C: length 58.9
  TOP w0.102: C315.2 148.77,132.71 148.53,132.71 v2(148.37,132.54)
  IN4 w0.091: v2(131.86,94.15) 132.05,94.34 132.21,94.34 132.46,94.59 132.46,95.81 133.34,96.69 133.34,97.95 134.02,98.62 134.02,100.48 134.31,100.77 134.31,103.33 134.03,103.61 134.03,108.58 133.71,108.89 133.71,113.74 132.27,115.18 132.27,119.62 133.29,120.64 133.29,124.82 134.88,126.41 137.78,126.41 138.45,127.07 141.42,127.07 145.02,130.67 145.02,131.28 146.46,132.72 148.19,132.72 v2(148.37,132.54)
  BOTTOM w0.089: UC1.B15 130.06,89.62 130.44,90 130.44,90.39 130.85,90.81 130.85,91.67 130.91,91.72 130.91,93.79 131.27,94.16 131.84,94.16 v2(131.86,94.15)
SATA_PTX_DKRX_P0: length 12.8
  TOP w0.102: v2(157.21,135.06) 157.46,134.81 157.46,133.39 157.44,133.38 v4(157.44,133.15) 157.44,132.92 156.21,131.69 153.13,131.69 151.92,132.9 150.38,132.9 C314.1
  BOTTOM w0.102: v2(157.21,135.06) 157.39,135.24 157.39,135.66 157.25,135.8 JDOCK1.60
SATA_PTX_DKRX_P0_C: length 59.3
  TOP w0.102: v2(148.37,133.13) 148.57,132.92 148.73,132.92 149.09,133.28
  IN4 w0.091: v2(148.37,133.13) 148.14,132.9 146.39,132.9 144.85,131.35 144.85,130.75 141.35,127.24 138.38,127.24 137.71,126.58 134.8,126.58 133.12,124.89 133.12,120.71 132.1,119.7 132.1,115.11 133.54,113.67 133.54,108.82 133.86,108.5 133.86,103.53 134.13,103.26 134.13,100.84 133.84,100.55 133.84,98.7 133.17,98.02 133.17,96.76 132.29,95.88 132.29,94.66 132.14,94.51 132.07,94.51 v2(131.86,94.73)
  BOTTOM w0.089: UC1.A15 129.76,90.15 129.76,89.91 129.84,89.82 129.97,89.82 130.23,90.08 130.23,90.48 130.65,90.9 130.65,91.76 130.7,91.81 130.7,93.88 131.19,94.36 131.49,94.36 v2(131.86,94.73)
SATA_PTX_DRX_N1: length 139.8
  IN1 w0.091: v2(130.32,92.95) 130.41,93.04 131.15,93.04 131.23,92.95 132.83,92.95 134.14,94.27 136.32,94.27 136.84,94.79 137.54,94.79 137.85,94.48 139.51,94.48 140.39,93.6 143.97,93.6 144.41,94.05 147.45,94.05 149,95.61 155.86,95.61 156.72,94.75 166.34,94.75 167.99,93.09 171.45,93.09 173.83,90.71 173.83,89.5 174.6,88.73 178.11,88.73 179.58,87.26 181.84,87.26 182.52,86.57 183.29,86.57 185.04,84.82 185.04,83.56 186.44,82.17 190.35,82.17 191.51,81.01 197.52,81.01 198.14,80.39 203.45,80.39 205.35,78.49 208.43,78.49 209.88,79.95 215.98,79.95 216.51,79.42 217.25,79.42 217.83,78.83 220.64,78.83 v2(220.84,78.63)
  BOTTOM w0.089: v2(130.32,92.95) 129.94,93.33 129.63,93.33 129.29,92.99 129.29,91.2 128.8,90.71 128.8,90 128.87,89.93 128.96,89.93 129.12,90.09 UC1.A17
  BOTTOM w0.102: CN37.1 223,108.71 223,104.82 221.99,103.81 221.99,92.23 220.08,90.33 220.08,79.07 220.33,78.82 220.58,78.82 220.65,78.82 v2(220.84,78.63)
SATA_PTX_DRX_N1_RP_C: length 2
  BOTTOM w0.102: CN37.2 222.93,110.25 222.93,110.5 222.79,110.64 222.79,110.99 222.65,111.12 JSATA1.3
SATA_PTX_DRX_P1: length 139.5
  IN1 w0.091: v2(220.84,79.21) 220.64,79 217.9,79 217.32,79.59 216.58,79.59 216.05,80.12 209.81,80.12 208.36,78.67 205.43,78.67 203.53,80.57 198.21,80.57 197.59,81.19 191.58,81.19 190.42,82.35 186.51,82.35 185.22,83.64 185.22,84.89 183.37,86.74 182.59,86.74 181.91,87.43 179.66,87.43 178.18,88.9 174.67,88.9 174.01,89.57 174.01,90.78 171.52,93.26 168.06,93.26 166.41,94.92 156.79,94.92 155.93,95.78 148.93,95.78 147.38,94.22 144.34,94.22 143.89,93.78 140.46,93.78 139.58,94.65 137.92,94.65 137.61,94.96 136.77,94.96 136.25,94.44 134.07,94.44 132.75,93.13 131.3,93.13 131.22,93.21 130.65,93.21 v2(130.32,93.54)
  BOTTOM w0.089: v2(130.32,93.54) 129.55,93.54 129.09,93.08 129.09,91.29 128.59,90.79 128.59,89.92 128.77,89.74 UC1.B17
  BOTTOM w0.102: v2(220.84,79.21) 220.67,79.04 220.42,79.04 220.3,79.16 220.3,90.24 222.2,92.14 222.2,103.72 223.21,104.73 223.21,108.71 CN38.1
SATA_PTX_DRX_P1_RP_C: length 2
  BOTTOM w0.102: CN38.2 223.15,110.38 223.15,110.59 223.01,110.73 223.01,110.95 223.15,111.09 JSATA1.2
SATACLK_REQ#: length 142
  TOP w0.089: v2(142.26,81.39) 142.74,81.87 143.5,81.87 143.69,81.68 v1(144.41,81.68) 145.54,81.68 RC68.2
  IN3 w0.122: v2(226.88,88.08) 226.48,88.47 226.48,89.41 224.26,91.64 221.12,91.64 220.59,92.16 214.06,92.16 213.86,92.36 212.41,92.36 212.2,92.58 211.15,92.58 210.47,93.26 210.47,96.36 209.56,97.26 198.54,97.26 197.32,98.48 197.32,100.41 196.87,100.86 196.32,100.86 195.93,100.47 195.93,99.78 192.96,96.8 190.77,96.8 189.39,95.42 184.16,95.42 183.96,95.62 177.7,95.62 176.44,96.88 175.11,96.88 174.25,96.03 173.26,96.03 172.37,95.14 162.31,95.14 159.13,91.95 159.13,88.91 155.34,85.13 148.15,85.13 144.87,81.85 142.72,81.85 v2(142.26,81.39)
  BOTTOM w0.076: v2(142.26,81.39) 141.5,82.15 139.32,82.15 139.01,81.84 138.7,81.84 138.4,81.54 UC1.T2
  BOTTOM w0.102: JNGFF2.44 216.95,66.51 217.24,66.79 217.24,67.49 219.5,69.75 221.29,69.75 227.78,76.24 227.78,78.69 226.86,79.61 226.86,88.07 v2(226.88,88.08)
SD/MMCCD#: length 61.4
  TOP w0.102: v2(17.88,18.43) 18.28,18.04 18.59,18.04 18.79,17.84 UR1.21 ; v2(31.71,21.24) 31.96,21.48 33.51,21.48 33.63,21.35 33.63,16.96 32.62,15.94 v1(32.62,15.04) RR11.1 CR35.1
  BOTTOM w0.102: JSD1.18 30.47,30.55 31.05,29.96 32.07,29.96 32.6,29.43 32.6,22.13 v2(31.71,21.24) 31.71,16.88 31.35,16.51 31.35,14.63 30.02,13.3 29.6,13.3 25.85,9.55 18.42,9.55 16.46,11.51 14.66,11.51 14.24,11.93 14.24,17.92 14.75,18.43 v2(17.88,18.43)
SD/MMCCLK: length 32
  TOP w0.102: v2(31.71,21.99) 31.23,21.5 31.23,20.77 30.98,20.51 CR23.1 28.6,20.51 RR1.2
  IN1 w0.084: v2(31.71,21.99) 31.31,22.39 31.31,23.03 31.22,23.12 29.09,23.12 29.01,23.2 29.01,23.45 29.09,23.54 31.22,23.54 31.31,23.62 31.31,23.87 31.22,23.95 29.09,23.95 29.01,24.04 29.01,24.29 29.09,24.37 31.22,24.37 31.31,24.46 31.31,24.71 31.22,24.79 29.09,24.79 29.01,24.88 29.01,25.13 29.09,25.21 31.22,25.21 31.31,25.3 31.31,25.55 31.22,25.63 29.09,25.63 29.01,25.71 29.01,25.97 29.09,26.05 31.22,26.05 31.31,26.13 31.31,26.6 31.44,26.72 v2(31.94,26.72)
  BOTTOM w0.102: v2(31.94,26.72) 32.25,27.03 32.25,28.15 31.24,29.15 JSD1.5
SD/MMCCLK_R: length 3.2
  TOP w0.102: UR1.43 25.85,19.04 25.91,18.98 26.44,18.98 v1(26.59,19.12) 26.59,19.64 27.38,20.44 RR1.1
SD/MMCCMD: length 30.1
  TOP w0.102: v2(26.29,19.99) 26,19.99 25.85,19.84 UR1.45
  BOTTOM w0.102: JSD1.2 28.63,23.45 28.43,23.65 26.44,23.65 26.23,23.45 26.23,23.32 26.35,23.2 28.3,23.2 28.42,23.08 28.42,22.91 28.3,22.79 26.34,22.79 26.22,22.67 26.22,22.5 26.34,22.38 28.2,22.38 28.32,22.26 28.32,22.1 28.2,21.98 26.24,21.98 26.12,21.86 26.12,21.69 26.24,21.57 28.16,21.57 28.31,21.42 28.31,21.21 28.16,21.06 25.38,21.06 25.26,20.95 25.26,20.78 25.38,20.66 27.89,20.66 28.08,20.46 28.08,17.65 27.91,17.48 27.66,17.48 27.49,17.65 27.49,19.79 27.28,19.99 v2(26.29,19.99)
SD/MMCDAT0: length 43.4
  TOP w0.089: UR1.30 22.09,15.35 21.96,15.22 21.96,14.93 v2(22.08,14.81) ; v2(32.44,21.05) 32.65,21.05 32.9,20.8 32.9,17.68 v4(30.47,15.26) 29.83,14.61 27.96,14.61 27.74,14.83 v2(27.74,14.91) ; UR1.38 26.01,17.04 v2(26.88,16.17)
  IN1 w0.084: v2(27.74,14.91) 27.68,14.98 27.46,14.98 27.36,14.88 27.36,14.44 26.99,14.07 22.25,14.07 21.87,14.46 21.87,14.61 v2(22.08,14.81) 21.99,14.9 21.99,15.72 22.19,15.93 25.35,15.93 25.63,15.65 26.36,15.65 v2(26.88,16.17)
  BOTTOM w0.089: v2(32.44,21.05) 32.65,21.05 32.9,21.29 32.9,21.75 32.95,21.81 32.95,29.84 32.41,30.38 32.41,33.58 31.6,34.39 31.36,34.39 30.31,33.35 JSD1.7
SD/MMCDAT1: length 42.4
  TOP w0.089: v2(27.74,14.28) 27.76,14.3 29.96,14.3 33.21,17.55 v2(33.21,21.05) ; UR1.29 21.69,15.4 21.64,15.35 21.64,14.97 v2(21.49,14.81) ; UR1.37 25.77,16.64 v2(26.24,16.17)
  IN1 w0.084: v2(26.24,16.17) 26.24,16.07 26.2,16.03 25.78,16.03 25.5,16.31 22.04,16.31 21.61,15.88 21.61,14.93 v2(21.49,14.81) 21.49,14.3 22.09,13.69 27.15,13.69 27.73,14.28 v2(27.74,14.28)
  BOTTOM w0.089: v2(33.21,21.05) 33.21,21.62 33.27,21.68 33.27,29.97 32.73,30.51 32.73,33.71 31.73,34.71 30.41,34.71 30.37,34.75 JSD1.8
SD/MMCDAT2: length 6.1
  TOP w0.102: UR1.48 25.71,21.04 25.91,21.24 25.91,22.49 26.04,22.62 26.29,22.62 26.42,22.49 v1(26.42,22.13) 26.42,21.24 26.55,21.11 26.8,21.11 26.93,21.24 26.93,22.22 27.05,22.34 RR4.1
SD/MMCDAT2_R: length 27.4
  TOP w0.102: v2(31.73,22.66) 32.26,22.13 32.26,21.97 32.39,21.85 33.47,21.85 33.59,21.97 33.59,25.14 33.28,25.45 31.41,25.45 31.31,25.56 31.31,27.63 31.21,27.73 30.9,27.73 30.8,27.63 30.8,25.56 30.7,25.45 30.39,25.45 30.29,25.56 30.29,27.56 30.19,27.66 29.88,27.66 29.78,27.56 29.78,25.56 29.68,25.45 29.33,25.45 29.2,25.33 29.2,24.14 29.07,24.01 v1(28.77,24.01) 28.4,24.01 28.27,23.88 28.27,23.51 28.15,23.39 27.5,23.39 27.37,23.26 27.37,23.01 27.5,22.88 28.43,22.88 28.53,22.78 RR4.2
  BOTTOM w0.102: v2(31.73,22.66) 31.23,22.16 31.23,21.69 30.94,21.4 30.81,21.4 30.06,20.65 JSD1.9
SD/MMCDAT3: length 2.6
  TOP w0.102: RR3.1 26.94,20.71 v1(26.62,20.71) 26.57,20.71 26.5,20.64 UR1.47
SD/MMCDAT3_R: length 31.7
  TOP w0.102: v2(30.88,22.63) 30.88,22.44 31,22.32 31.16,22.32 31.27,22.21 31.27,22.05 31.15,21.92 31,21.92 30.88,21.79 30.88,21 30.75,20.87 30.53,20.87 30.41,21 30.41,24.36 30.53,24.49 30.94,24.49 31.07,24.36 31.07,23.23 31.19,23.1 31.45,23.1 31.57,23.23 31.57,24.37 31.7,24.5 32.6,24.5 32.73,24.37 32.73,24.12 32.63,24.02 32.13,24.02 32.03,23.92 32.03,23.71 32.13,23.61 32.63,23.61 32.73,23.51 32.73,22.34 32.86,22.22 33.11,22.22 33.24,22.34 33.24,24.99 33.13,25.1 v1(31.08,25.1) 29.94,25.1 29.81,24.97 29.81,23.6 29.71,23.5 28.72,23.5 28.6,23.38 28.6,23.21 28.72,23.09 29.77,23.09 29.9,22.96 29.9,22.58 29.77,22.46 29.15,22.46 29.02,22.33 29.02,22.03 29.15,21.9 29.72,21.9 29.85,21.77 29.85,21.52 29.72,21.39 RR3.2
  BOTTOM w0.102: v2(30.88,22.63) 30.88,21.87 30.76,21.76 30.52,21.76 30.23,22.05 JSD1.1
SD_REXT: length 2.1
  TOP w0.102: RR5.1 v1(20.08,14.77) 20.08,14.98 20.49,15.39 UR1.26
SD_UHS2_D0N: length 51.2
  TOP w0.089: UR1.34 23.69,15.32 24.53,14.47 v2(26.7,14.47)
  IN4 w0.084: v2(14.83,20.6) 13.84,20.6 13.41,20.17 13.41,19.28 13.84,18.85 14.59,18.85 14.8,18.64 14.8,18 14.59,17.8 14.28,17.8 13.85,17.36 13.85,16.61 14.3,16.16 16.7,16.16 16.78,16.08 16.78,15.86 17.21,15.43 19.03,15.43 19.34,15.74 19.34,20.31 19.54,20.51 19.86,20.51 20.06,20.31 20.06,15.58 20.49,15.15 21.11,15.15 21.54,15.58 21.54,16.33 21.62,16.41 22.17,16.41 22.26,16.33 22.26,15.74 22.57,15.43 23.85,15.43 24.08,15.21 24.08,14.89 24.49,14.47 v2(26.7,14.47)
  BOTTOM w0.089: v2(14.83,20.6) 13.25,20.6 9.48,16.82 6.01,16.82 4.35,15.16 JSD1.12
SD_UHS2_D0P: length 51.1
  TOP w0.089: v2(26.7,15.06) 26.57,14.93 26.57,14.92 26.45,14.81 26.2,14.81 26.03,14.98 25.89,14.98 25.72,14.81 25.49,14.81 25.34,14.95 25.16,14.95 25.01,14.81 24.65,14.81 24.09,15.37 UR1.35
  IN4 w0.084: v2(26.7,15.06) 26.51,14.87 26.36,14.87 26.28,14.95 26.28,15.18 26.18,15.28 26.04,15.28 25.94,15.18 25.94,14.95 25.86,14.87 25.69,14.87 25.6,14.95 25.6,15.09 25.51,15.19 25.37,15.19 25.27,15.09 25.27,14.95 25.19,14.87 24.64,14.87 24.46,15.05 24.46,15.36 24.01,15.81 22.72,15.81 22.64,15.9 22.64,16.49 22.33,16.79 21.47,16.79 21.16,16.49 21.16,15.74 20.96,15.54 20.64,15.54 20.44,15.74 20.44,20.47 20.01,20.89 19.39,20.89 18.96,20.47 18.96,15.9 18.88,15.81 17.36,15.81 17.16,16.02 17.16,16.23 16.86,16.54 14.46,16.54 14.23,16.77 14.23,17.21 14.44,17.42 14.75,17.42 15.18,17.84 15.18,18.8 14.75,19.23 14,19.23 13.79,19.43 13.79,20.01 14,20.22 14.63,20.22 14.81,20.03 14.81,20.03 v2(14.83,20.01)
  BOTTOM w0.089: v2(14.83,20.01) 14.56,20.28 13.39,20.28 9.61,16.5 6.14,16.5 4.67,15.03 4.67,14.21 4.74,14.14 5.3,14.14 5.45,13.99 JSD1.11
SD_UHS2_D1N: length 51.1
  TOP w0.089: UR1.33 23.29,15.39 23.55,15.13 23.55,14.74 v2(23.62,14.67)
  BOTTOM w0.089: JSD1.15 4.35,43.09 4.47,43.21 4.47,43.77 4.87,44.17 6.03,44.17 7.52,42.68 7.52,41.16 8.03,40.66 11.13,40.66 11.55,40.24 12.19,40.24 13.33,39.09 23.08,39.09 24.15,38.03 24.15,34.84 25.39,33.6 25.39,30.75 25.72,30.42 25.72,27.04 25.62,26.94 25.62,22.19 24.66,21.24 24.66,16.08 23.62,15.03 v2(23.62,14.67)
SD_UHS2_D1P: length 51.1
  TOP w0.089: v2(23.03,14.67) 23.23,14.87 23.23,15 22.89,15.34 UR1.32
  BOTTOM w0.089: v2(23.03,14.67) 23.3,14.94 23.3,15.29 23.25,15.34 23.25,15.47 23.38,15.59 23.5,15.59 23.55,15.54 23.68,15.54 23.8,15.67 23.8,15.79 23.75,15.84 23.75,15.97 23.88,16.1 24.01,16.1 24.06,16.05 24.18,16.05 24.34,16.21 24.34,21.37 25.3,22.33 25.3,27.07 25.4,27.17 25.4,30.29 25.07,30.62 25.07,33.47 23.83,34.71 23.83,37.9 22.95,38.78 13.2,38.78 12.05,39.92 11.42,39.92 11,40.34 7.9,40.34 7.2,41.03 7.2,42.55 5.9,43.86 v4(5.48,43.86) 5.01,43.86 4.79,43.64 4.79,43.44 5.45,42.78 JSD1.16
SDWP: length 60.5
  TOP w0.102: v2(18.48,18.44) 18.69,18.44 18.89,18.24 UR1.20
  BOTTOM w0.102: JSD1.19 30.94,36.15 31.14,36.35 v1(31.41,36.35) 32.53,36.35 33.08,35.8 33.08,30.66 33.62,30.12 33.62,17.66 31.94,15.98 31.94,14.72 30.17,12.94 29.75,12.94 26,9.2 17.01,9.2 15.22,10.99 14.42,10.99 13.54,11.87 13.54,17.91 14.98,19.35 17.58,19.35 v2(18.48,18.44)
SIO_EXT_SCI#: length 84
  TOP w0.102: v2(161.41,86.22) v1(161.41,87.75) 161.41,88.19 162.37,89.16 RC156.1 ; UE2.A33 200,95.75 v2(199.52,96.23)
  IN1 w0.084: 138.79,83.45 139.36,84.03 147.32,84.03 149.79,81.55 150.9,81.55 151.11,81.76 154,81.76 157.3,85.06 160.36,85.06 161.41,86.11 v2(161.41,86.22)
  IN1 w0.089: v2(136.36,83.45) 138.79,83.45
  IN3 w0.122: v2(199.52,96.23) 198.97,95.69 197.45,95.69 196.27,96.86 194.78,96.86 193.47,95.56 191.31,95.56 190.38,94.63 190.38,94.19 189.08,92.89 185.69,92.89 185.14,92.33 181.7,92.33 181.55,92.18 180.51,92.18 180.26,91.93 176.75,91.93 174.77,93.91 174.55,93.91 174.2,93.56 162.14,93.56 160.12,91.54 160.12,88.81 161.41,87.52 v2(161.41,86.22)
  BOTTOM w0.076: UC1.N5 136.18,83.27 v2(136.36,83.45)
SIO_EXT_SMI#: length 130.2
  TOP w0.102: UE2.A6 211.57,90.75 v2(211.78,90.54) ; RPC19.2 152.18,77.05 152.28,77.14 152.28,77.78 152.49,77.99 153.33,77.99 153.61,77.71 v2(153.61,77.21)
  IN1 w0.084: v2(204.47,56.76) 203.81,57.42 199.49,57.42 198.23,58.68 188.31,58.68 188.06,58.92 184.66,58.92 183.35,60.23 173.32,60.23 171.48,62.07 168.56,62.07 166.95,63.68 166.95,63.89 165.73,65.11 165.73,65.62 164.09,67.26 164.09,73.7 162.95,74.84 162.45,74.84 161.95,74.35 160.99,74.35 158.3,77.04 157.25,77.04 156.9,76.69 155.46,76.69 155.18,76.97 154.27,76.97 154.03,77.21 v2(153.61,77.21) 153.27,77.21 151.39,75.33 148.21,75.33 147.34,74.45 144,74.45 143.4,75.06 138.95,75.06 138.07,75.94 136.47,75.94 v2(136.37,75.83)
  IN2 w0.122: v2(211.78,90.54) 211.41,90.17 211.41,87.03 211.91,86.53 211.91,85.28 211.17,84.53 211.17,80.78 210.63,80.24 210.63,78.1 208.77,76.25 203.92,76.25 203.78,76.11 203.78,74.25 203.94,74.1 203.94,65.6 205.45,64.09 205.45,62.75 205.74,62.47 205.74,58.03 v2(204.47,56.76)
  BOTTOM w0.089: v2(136.37,75.83) 136.18,75.64 UC1.AG5
  BOTTOM w0.102: v2(204.47,56.76) v1(204.47,56.18)
SIO_EXT_WAKE#: length 100.8
  TOP w0.102: RPC1.6 161.1,67.65 v2(160.95,67.49) 160.05,67.49 158.86,66.3 157.04,66.3 155.74,65 155.74,63.94 154.69,62.89 148.87,62.89 144.13,67.63 144.13,68.02 143.74,68.41 141.5,68.41 v2(140.88,69.02) ; UE2.B5 209.83,90 209.69,89.87 209.17,89.87 v2(208.98,89.68) ; v1(165.74,86.03) 165.74,85.39 v2(165.8,85.32)
  IN2 w0.122: v2(165.8,85.32) 165.84,85.32 166.88,84.28 166.88,83.56 166.63,83.3 166.63,81.24 165.83,80.45 165.83,77.95 165.2,77.32 165.2,74.32 163.36,72.48 163.36,71.39 162.2,70.22 161.24,70.22 160.66,69.64 160.66,67.78 v2(160.95,67.49)
  IN3 w0.122: v2(208.98,89.68) 208.6,89.68 207.67,90.61 203.8,90.61 203.04,91.37 201.05,91.37 199.82,90.15 199.21,90.15 199.01,90.36 194.79,90.36 193.03,88.6 189.22,88.6 188.6,87.97 182.21,87.97 179.99,85.75 178.6,85.75 177.35,84.5 167.47,84.5 166.65,85.32 v2(165.8,85.32)
  BOTTOM w0.076: v2(140.88,69.02) 140.51,69.4 140.14,69.4 139.61,69.94 138.48,69.94 UC1.AU2
SIO_PWRBTN#: length 191.8
  TOP w0.102: UE2.B58 204.62,88.15 v2(204.54,88.23) ; JXDP1.41 66.25,48.07 67.34,49.15 v2(67.34,49.99)
  IN1 w0.076: v2(135.21,74) 134.75,74.46 134.75,74.92 133.8,75.87
  IN1 w0.084: v2(67.34,49.99) 68.68,49.99 68.87,50.18 68.87,54.49 82.32,67.94 82.32,69.56 86.03,73.27 93.88,73.27 95.15,74.54 104.83,74.54 105.23,74.95 113.81,74.95 114.44,75.58 123.16,75.58 123.95,74.79 125.58,74.79 125.75,74.96 126.89,74.96 128.03,76.09 132.51,76.09 132.73,75.87 133.8,75.87
  IN4 w0.084: v2(135.21,74) 135.69,73.52 136,73.52 136.89,74.41 138.05,74.41 138.19,74.55 138.19,78.23 139.06,79.1 145.45,79.1 146.06,79.71 149.76,79.71 149.86,79.81 151.24,79.81 152.02,80.59 152.73,80.59 154.08,81.93 154.08,82.98 160.63,89.54 163.1,89.54 166.34,92.78 168.58,92.78 170.77,94.97 170.77,96.22 171.23,96.68 171.23,98.49 171.94,99.2 171.94,100.53 173.37,101.96 174.16,101.96 176.74,104.54 186.89,104.54 187.44,105.09 199.51,105.09 v2(200.71,103.88)
  BOTTOM w0.076: v2(135.21,74) 135.21,73.62 UC1.AL7
  BOTTOM w0.102: v2(200.71,103.88) 200.89,103.71 200.89,100.23 201.81,99.3 202.43,99.3 202.95,98.78 202.95,95.3 203.75,94.5 203.75,91.63 204.47,90.91 204.47,89.78 205.02,89.23 205.02,88.38 204.87,88.23 v2(204.54,88.23)
SIO_RCIN#: length 106.6
  TOP w0.089: 146.46,78.11 146.2,78.11 145.96,78.35 140.33,78.35 139.41,79.27 137.54,79.27 v2(137.17,79.64)
  TOP w0.102: UE2.A27 204.37,97.81 203.98,98.2 203.98,98.52 203.66,98.83 203.66,102.48 203.94,102.76 v2(203.94,103.89) ; 146.46,78.11 v1(147.4,78.11) 151.58,78.11 152.23,78.77 152.23,79.34 152.08,79.5 RPC17.7
  IN4 w0.084: v2(203.94,103.89) 203.39,103.89 202.47,104.81 200.59,104.81 199.85,105.55 193.85,105.55 193.45,105.95 192.03,105.95 191.63,105.55 187.25,105.55 186.7,105 176.55,105 173.97,102.42 173.18,102.42 171.48,100.73 171.48,99.39 170.77,98.68 170.77,96.87 170.31,96.41 170.31,95.16 169.17,94.02 166.92,94.02 162.91,90 160.44,90 156.94,86.5 155.69,86.5 152.64,83.45 152.64,82.08 151.61,81.05 149.86,81.05 148.98,80.17 140.1,80.17 140.01,80.07 137.36,80.07 137.17,79.88 v2(137.17,79.64)
  BOTTOM w0.089: v2(137.17,79.64) 136.87,79.94 UC1.V4
SIO_SLP_A#: length 165.2
  TOP w0.102: UE2.B28 v2(204.62,95.94) ; JAPS1.6 220.07,100.7 218.72,99.36 218.72,90.02 217.22,88.52 217.22,86.44 v2(217.21,86.43) ; v1(159.11,80.65) 159.11,80.76 v2(158.69,81.18)
  IN1 w0.084: v2(201.67,58.54) 200.42,58.54 197.17,61.79 185.92,61.79 184.1,63.6 173.41,63.6 172.59,64.42 172.59,66.45 171.22,67.82 169.1,67.82 168.85,68.07 168.85,76.95 165.96,79.84 164.73,79.84 163.94,80.63 162.22,80.63 161.76,81.09 160.58,81.09 160.38,81.3 158.8,81.3 v2(158.69,81.18) ; v2(217.21,86.43) 216.88,86.76 215.37,86.76 214.41,87.72 211.69,87.72 210.9,88.51 210.9,89.8 209.91,90.79 208.66,90.79 208.27,91.18 207.12,91.18 206.55,91.75 206.55,94.26 206,94.82 205.29,94.82 205.11,94.99 205.11,95.65 204.82,95.94 v2(204.62,95.94)
  IN2 w0.122: v2(204.62,95.94) 204.62,95.94 205.04,95.52 205.04,95.24 206.05,94.24 206.05,87.42 205.23,86.61 205.23,85.13 204.54,84.44 204.37,84.44 204.11,84.18 204.11,83.66 204.76,83.01 204.76,81.28 204.51,81.03 204.51,79.81 202.04,77.34 202.04,74.53 201.26,73.75 201.26,72.03 201.46,71.83 201.46,66.47 201.76,66.17 201.76,58.63 v2(201.67,58.54)
  IN3 w0.089: 146.46,75.17 145.83,74.53 137.2,74.53 136.64,73.98 v2(135.92,73.98)
  IN3 w0.122: 146.46,75.17 147.43,76.13 147.43,78.24 150.17,80.97 158.48,80.97 v2(158.69,81.18)
  BOTTOM w0.089: v2(135.92,73.98) UC1.AL5
  BOTTOM w0.102: v2(158.69,81.18) 159.16,81.18 159.33,81.01 UC6.1
SIO_SLP_LAN#: length 123.8
  TOP w0.102: v2(202.35,94.23) 201.95,94.63 201.63,94.63 201.26,95 UE2.B37 ; v2(200.45,113.77) 200.36,113.86 195.09,113.86 194.74,113.52 194.74,111.2 194.3,110.76 191.54,110.76 191.34,110.56 191.34,109.35 191.72,108.97 v1(192.29,108.97) 193.8,108.97 193.99,108.78 UL3.3
  IN2 w0.122: v2(202.35,94.23) 202.93,94.23 203.24,93.92 203.24,89.27 203.26,89.24 203.26,87.97 201.64,86.34 201.64,84.85 v2(201.26,84.47)
  IN3 w0.089: v2(135.22,74.86) 135.22,74.7 135.47,74.44 136.72,74.44 137.08,74.8 145.64,74.8 146.46,75.62
  IN3 w0.122: v2(201.26,84.47) 200.81,84.47 199.64,83.29 198.58,83.29 197.24,81.96 183.31,81.96 182.2,83.07 173.26,83.07 172.33,82.14 164.34,82.14 163.21,81.01 160.35,81.01 159.76,81.6 156.55,81.6 156.19,81.24 150.09,81.24 147.18,78.34 147.18,76.34 146.46,75.62
  BOTTOM w0.076: v2(135.22,74.86) 135.22,74.74 UC1.AJ7
  BOTTOM w0.102: v2(200.45,113.77) 200.45,108.89 200.23,108.68 200.23,103.29 200.4,103.11 200.4,98.83 200.83,98.41 200.83,95.09 201.28,94.63 201.95,94.63 v2(202.35,94.23)
SIO_SLP_S0#: length 108.3
  TOP w0.102: v2(216.51,87.47) 216.51,88.13 v1(216.6,88.22) 218.49,90.11 218.49,99.45 218.86,99.82 218.86,104.57 219.5,105.2 JAPS1.15
  IN3 w0.122: v2(142.34,76.12) 142.99,76.76 145.29,76.76 146.66,78.13 146.66,78.53 149.88,81.74 155.98,81.74 156.34,82.1 159.81,82.1 160.35,82.64 172.12,82.64 173.05,83.57 181.98,83.57 182.26,83.84 183.86,83.84 184.62,83.08 187.58,83.08 188.33,83.82 191.64,83.82 192.45,84.63 197.41,84.63 197.72,84.32 199.1,84.32 200.75,85.97 200.75,86.43 201.07,86.76 203.69,86.76 204.05,86.39 206.42,86.39 207.14,85.67 207.14,85.02 207.66,84.5 209.57,84.5 211.03,85.96 211.57,85.96 211.81,85.72 213.04,85.72 214.19,86.86 215.9,86.86 v2(216.51,87.47)
  BOTTOM w0.076: UC1.AF3 137.77,76.01 138.29,76.01 138.52,76.24 138.52,76.42 138.7,76.59 139.01,76.59 139.1,76.69 141.78,76.69 v2(142.34,76.12)
SIO_SLP_S3#: length 137.7
  TOP w0.102: RE280.1 v2(212.01,81.83) ; JAPS1.2 219.72,98.7 219.41,98.39 219.41,89.55 v1(219.34,89.49) 218.09,88.23 218.09,85.63 v2(218,85.54) ; v2(198.71,96.21) 198.71,95.97 199.92,94.75 UE2.A35
  IN1 w0.084: v2(198.71,96.21) 198.71,96.09 199.04,95.76 201.39,95.76 201.62,95.53 202.83,95.53 203.75,94.61 205.91,94.61 206.34,94.17 206.34,91.66 207.03,90.97 208.18,90.97 208.58,90.58 209.82,90.58 210.4,90 210.4,88.44 211.98,86.87 214.61,86.87 215.52,85.96 217.58,85.96 v2(218,85.54)
  IN2 w0.122: v2(199.28,82.26) 199.28,84.15 199.87,84.75 199.87,86.25 199.2,86.92 199.2,87.62 200.12,88.54 200.12,94.68 198.71,96.09 v2(198.71,96.21)
  IN3 w0.089: 146.46,71.97 146.05,71.56 140.21,71.56 139.77,71.11 137.63,71.11 v2(137.2,70.68)
  IN3 w0.122: v2(199.28,82.26) 198.81,82.26 197.51,80.96 169.34,80.96 167.46,79.09 165.22,79.09 164.32,78.19 160.11,78.19 159.46,77.54 158.26,77.54 157.16,78.63 154.56,78.63 153.93,78 149.97,78 149.35,77.38 149.35,74.85 146.46,71.97
  IN4 w0.084: v2(212.01,81.83) 213.23,83.05 216.13,83.05 218,84.91 v2(218,85.54)
  BOTTOM w0.076: v2(137.2,70.68) 136.87,70.34 UC1.AT4
SIO_SLP_S4#: length 315.1
  TOP w0.089: v2(135.77,74.87) 136.21,75.3 136.53,75.3 136.77,75.55 138.7,75.55 139.08,75.18 140.53,75.18 140.57,75.21 T9.1
  TOP w0.102: UE2.B36 201.34,95.5 v2(201.77,95.08) ; v2(216.92,85.14) 217.2,85.42 217.2,85.76 217.62,86.17 217.62,88.59 218.95,89.92 218.95,99.26 219.89,100.2 JAPS1.5
  IN1 w0.084: v2(216.92,85.14) 216.91,85.13 216.05,85.13 214.52,86.66 211.89,86.66 210.19,88.35 210.19,89.91 209.73,90.37 208.49,90.37 208.1,90.76 206.94,90.76 206.13,91.57 206.13,94.09 205.82,94.39 203.67,94.39 202.76,95.3 202,95.3 v2(201.77,95.08) ; v2(135.77,74.87) 136.16,75.25 136.56,75.25 137.19,74.62 137.74,74.62 139.69,72.67 139.69,71.27 141,69.97 144.9,69.97 146.01,68.86 146.01,66.48 148.55,63.94 154.02,63.94 155.49,65.41 159.63,65.41 164,61.04 165.44,61.04 166.13,60.35 166.37,60.35 170.7,56.01 182.51,56.01 182.75,56.25 188.74,56.25 188.94,56.45 189.36,56.45 189.48,56.33 192.43,56.33 192.7,56.59 194.12,56.59 194.75,55.96 194.75,55.75 197.23,53.27 197.73,53.27 198.38,53.92 v2(198.38,54.09)
  IN2 w0.089: 134.79,58.64 134.79,66.34 134.61,66.53 134.61,74.04 134.99,74.43 135.33,74.43 v2(135.77,74.87)
  IN2 w0.122: v2(201.77,95.08) 202.01,95.31 202.52,95.31 203.48,94.35 203.48,89.88 204.09,89.27 204.09,88.15 203.47,87.52 203.39,87.52 201.88,86.02 201.88,84.36 201.14,83.61 201.14,80.47 201.01,80.34 201.01,77.02 201.79,76.24 201.79,74.64 201.01,73.86 201.01,71.93 201.21,71.73 201.21,66.36 201.51,66.06 201.51,59.1 200.89,58.48 200.89,57.04 198.38,54.52 v2(198.38,54.09) ; v2(62.17,44.25) 62.85,43.57 69.42,43.57 78.99,53.14 85.14,53.14 85.65,52.63 133.33,52.63 134.79,54.09 134.79,58.64
  IN3 w0.122: v2(56.14,22.41) 53.28,25.26 53.28,33.96 55.25,35.93 59.47,35.93 62.55,39.01 62.55,43.87 v2(62.17,44.25)
  IN4 w0.254: v2(71.38,19.89) 70,21.26 57.15,21.26 56.14,22.28 v2(56.14,22.41)
  BOTTOM w0.076: v2(135.77,74.87) 135.77,74.65 UC1.AJ6
  BOTTOM w0.254: RE282.1 v2(71.38,19.89)
