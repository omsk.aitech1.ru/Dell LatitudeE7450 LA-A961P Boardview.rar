# Allegro board LAA961PR10-1007A.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
WIGIG_LANE_N0: length 61.6
  TOP w0.102: CV156.1 178.59,89.26 178.67,89.34 178.67,89.79 176.47,91.99 174.78,91.99 170.84,95.92 170.84,101.89 170.72,102.02 170.72,106.32 171.38,106.98 171.38,114.68 164.55,121.51 v4(163.62,121.51) 160.53,121.51 160.52,121.5 159.99,121.5 159.97,121.51 150.99,121.51 149.88,120.41 144.26,120.41 144.17,120.31 UV600.49
WIGIG_LANE_N0_C: length 2.6
  TOP w0.102: v2(178.26,87.4) 178.53,87.66 178.53,88.02 CV156.2
  BOTTOM w0.102: JNGFF1.24 178.05,87.61 v2(178.26,87.4)
WIGIG_LANE_N1: length 61.7
  TOP w0.102: CV152.1 176.67,89.27 176.75,89.35 176.75,90.06 v4(176.15,90.66) 175.64,91.16 174.43,91.16 170.02,95.58 170.02,100.58 170,100.59 170,101.12 170.02,101.13 170.02,101.48 169.89,101.6 169.89,106.67 170.51,107.29 170.51,110.83 170.41,110.93 170.03,110.93 169.79,111.17 169.79,111.66 170,111.87 170.41,111.87 170.51,111.98 170.51,112.28 170.41,112.38 170.02,112.38 169.79,112.61 169.79,113.09 170.02,113.32 170.41,113.32 170.51,113.42 170.51,114.38 164.26,120.63 151.31,120.63 150.21,119.52 145.53,119.52 145.24,119.23 144.29,119.23 144.17,119.11 UV600.46
WIGIG_LANE_N1_C: length 2.2
  TOP w0.102: CV152.2 176.72,87.92 176.72,87.73 v2(176.55,87.56)
  BOTTOM w0.102: v2(176.55,87.56) 176.55,87.56 JNGFF1.18
WIGIG_LANE_N2: length 65.1
  TOP w0.102: CV147.1 176.67,84.1 176.77,84.2 176.77,85.27 175.31,86.73 174.34,86.73 173.45,87.62 173.45,89.82 168.09,95.18 168.09,105.01 167.17,105.92 167.17,107.67 168.86,109.36 168.86,112.11 168.69,112.28 168.27,112.28 167.91,112.64 167.91,113.29 168.66,114.04 168.66,114.76 167.96,115.46 167.94,115.46 167.57,115.83 167.57,115.85 163.62,119.8 152.07,119.8 150.72,118.45 v4(147.61,118.45) 144.27,118.45 144.13,118.31 UV600.44
WIGIG_LANE_N2_C: length 5
  TOP w0.102: CV147.2 176.68,82.84 176.68,82.17 176.49,81.98 v4(176.49,81.38) 176.49,80.08 v2(176.32,79.91)
  BOTTOM w0.102: v2(176.32,79.91) 176.48,80.07 176.48,80.27 176.3,80.45 JNGFF1.17
WIGIG_LANE_N3: length 67.9
  TOP w0.102: UV600.41 144.01,117.11 144.19,117.3 144.36,117.3 144.52,117.15 146.88,117.15 147.29,117.56 151.03,117.56 152.44,118.98 163.27,118.98 163.74,118.51 163.74,118.49 164.12,118.11 164.14,118.11 166.33,115.92 166.33,114.4 166.56,114.17 166.98,114.17 167.08,114.07 167.08,113.77 166.98,113.67 166.56,113.67 166.33,113.44 166.33,112.95 166.56,112.73 166.98,112.73 167.08,112.62 167.08,112.32 166.98,112.22 166.56,112.22 166.33,111.99 166.33,111.51 166.56,111.28 167.3,111.28 167.4,111.18 167.4,110.87 167.3,110.77 166.56,110.77 166.33,110.54 166.33,110.06 166.56,109.83 167.65,109.83 167.75,109.73 167.75,109.42 167.65,109.32 166.56,109.32 166.33,109.09 166.33,101.03 167.21,100.16 167.21,94.89 172.62,89.47 172.62,86.4 v4(173.1,85.93) 173.54,85.49 174.75,85.49 174.98,85.26 174.98,84.22 174.87,84.1 CV145.1
WIGIG_LANE_N3_C: length 2.4
  TOP w0.102: v2(174.77,82.43) 174.91,82.56 174.91,82.83 CV145.2
  BOTTOM w0.102: JNGFF1.11 174.8,81.94 174.95,82.1 174.95,82.24 v2(174.77,82.43)
WIGIG_LANE_P0: length 61.7
  TOP w0.102: UV600.50 144.17,120.71 144.26,120.62 149.79,120.62 150.9,121.73 v4(160.25,121.73) 163.34,121.73 163.35,121.74 163.88,121.74 163.9,121.73 164.64,121.73 171.59,114.77 171.59,106.89 170.93,106.23 170.93,102.11 171.06,101.98 171.06,96.01 174.87,92.21 176.56,92.21 178.88,89.88 178.88,89.53 CV157.1
WIGIG_LANE_P0_C: length 2.6
  TOP w0.102: v2(178.85,87.4) 178.74,87.5 178.74,87.93 CV157.2
  BOTTOM w0.102: JNGFF1.26 178.55,87.7 v2(178.85,87.4)
WIGIG_LANE_P1: length 61.7
  TOP w0.102: CV153.1 176.96,89.52 176.96,90.15 176.49,90.62 176.49,90.64 176.12,91.01 176.1,91.01 175.73,91.38 174.52,91.38 170.23,95.67 v4(170.23,100.85) 170.23,101.57 170.11,101.69 170.11,106.58 170.73,107.2 170.73,110.92 170.5,111.15 170.12,111.15 170,111.26 170,111.57 170.09,111.66 170.5,111.66 170.73,111.89 170.73,112.37 170.5,112.6 170.11,112.6 170,112.7 170,113 170.11,113.11 170.5,113.11 170.73,113.33 170.73,114.47 164.35,120.84 151.22,120.84 150.12,119.74 145.44,119.74 145.15,119.45 144.24,119.45 144.17,119.51 UV600.47
WIGIG_LANE_P1_C: length 2.2
  TOP w0.102: v2(177.13,87.56) 176.96,87.73 176.96,88.06 CV153.2
  BOTTOM w0.102: JNGFF1.20 177.05,87.64 v2(177.13,87.56)
WIGIG_LANE_P2: length 65.1
  TOP w0.102: CV148.1 176.98,84.34 176.98,85.36 175.4,86.95 174.43,86.95 173.66,87.71 173.66,89.91 168.3,95.27 168.3,105.1 167.39,106.01 167.39,107.59 169.08,109.27 169.08,112.2 168.78,112.49 168.36,112.49 168.13,112.73 168.13,113.2 168.87,113.95 168.87,114.85 v4(167.92,115.81) 163.71,120.02 151.98,120.02 150.63,118.67 147.89,118.67 147.88,118.68 147.35,118.68 147.34,118.67 144.21,118.67 144.17,118.71 UV600.45
WIGIG_LANE_P2_C: length 5
  TOP w0.102: v2(176.91,79.91) 176.71,80.11 176.71,81.11 176.72,81.12 176.72,81.65 176.71,81.66 176.71,81.89 176.9,82.08 176.9,82.86 CV148.2
  BOTTOM w0.102: JNGFF1.19 176.8,80.43 176.7,80.33 176.7,80.12 v2(176.91,79.91)
WIGIG_LANE_P3: length 67.9
  TOP w0.102: CV146.1 175.2,84.34 175.2,85.35 174.84,85.7 173.63,85.7 173.45,85.88 173.45,85.9 173.07,86.27 173.05,86.27 172.84,86.49 172.84,89.56 167.42,94.98 167.42,100.25 166.55,101.12 166.55,109.01 166.65,109.11 167.74,109.11 167.97,109.33 167.97,109.82 167.74,110.05 166.65,110.05 166.55,110.15 166.55,110.45 166.65,110.55 167.39,110.55 167.62,110.78 167.62,111.27 167.39,111.49 166.65,111.49 166.55,111.6 166.55,111.9 166.65,112 167.07,112 167.3,112.23 167.3,112.71 167.07,112.94 166.65,112.94 166.55,113.04 166.55,113.35 166.65,113.45 167.07,113.45 167.3,113.68 167.3,114.16 167.07,114.39 166.65,114.39 166.55,114.49 166.55,116.01 v4(164.09,118.46) 163.36,119.19 152.35,119.19 150.94,117.78 147.2,117.78 146.79,117.36 144.6,117.36 144.45,117.51 UV600.42
WIGIG_LANE_P3_C: length 2.3
  TOP w0.102: v2(175.35,82.43) 175.16,82.62 175.16,82.91 CV146.2
  BOTTOM w0.102: JNGFF1.13 175.3,81.97 175.17,82.1 175.17,82.24 v2(175.35,82.43)
WIGIGCLK_REQ#: length 83.4
  TOP w0.102: RPC3.8 148.39,81.96 147.89,82.45 145.54,82.45 145.38,82.28 138.8,82.28 138.34,81.82 136.33,81.82 v2(136.05,81.54)
  IN3 w0.089: v2(136.05,81.54) 136.87,80.71 139.02,80.71 140.19,81.88 140.19,83.33 140.67,83.81 145.98,83.81 146.46,84.3
  IN3 w0.122: v2(186.82,96.37) 178.01,96.37 176.75,97.63 174.8,97.63 173.94,96.78 172.95,96.78 172.06,95.89 161.53,95.89 158.63,92.99 158.63,89.12 155.14,85.63 147.79,85.63 146.46,84.3
  BOTTOM w0.089: UC1.U5 136.18,81.41 v2(136.05,81.54)
  BOTTOM w0.102: JNGFF1.60 187.05,96.14 v2(186.82,96.37)
WIRELESS_LED#: length 210.4
  TOP w0.102: v2(190.88,127.44) 191.33,126.99 QZ7.1 ; RZ31.2 194.06,111.43 193.93,111.31 191.14,111.31 190.46,110.63 190.46,107.39 v1(190.09,107.02) 189.07,106 v2(188.55,106) 188.55,104.97 188.42,104.84 UE1.A47
  IN2 w0.122: v2(171.5,49.1) 171.21,49.4 171.21,63.36 169.82,64.75 169.66,64.75 168.86,65.55 168.86,66.6 169.71,67.45 169.71,71.09 173.09,74.47 175.48,74.47 175.75,74.74 177.97,74.74 178.43,75.19 182.81,75.19 185.76,78.15 185.76,88.23 187.18,89.64 187.18,90.86 189.84,93.52 189.84,105.29 189.13,106 v2(188.55,106)
  IN3 w0.122: v2(188.55,106) 188.13,106.42 187.7,106.42 187.48,106.19 182.75,106.19 181.51,104.95 177.03,104.95 175.79,106.19 174.2,106.19 171.99,108.41 171.99,108.48 170.03,110.44 v2(165.67,110.44)
  BOTTOM w0.102: v2(171.5,49.1) 171.5,48.34 176.64,43.2 185.89,43.2 187.73,45.04 187.73,46.89 189.23,48.39 197.53,48.39 198.88,49.74 205.56,49.74 206.16,50.33 QZ11.6 ; QZ2.3 161.99,93.85 161.36,93.21 161.36,91.49 161.74,91.11 163.61,91.11 164.24,91.75 164.24,94.75 163.85,95.14 QZ2.6 163.85,96.45 165.2,97.8 165.2,109.97 v2(165.67,110.44) ; v2(188.55,106) 188.55,107.77 189.55,108.77 189.55,115.76 189.92,116.13 189.92,118.69 188.18,120.43 188.18,127.28 188.79,127.88 190.44,127.88 v2(190.88,127.44)
WLAN_DISBL#: length 64.1
  TOP w0.102: UL2.4 212.92,121.94 212.46,121.48 210.93,121.48 v2(210.56,121.85) ; v2(175.07,123.81) v1(172.75,121.5) 172.2,120.95 172.2,109.73 174.44,107.5 177.49,107.5 178.44,106.54 UE1.B68
  IN3 w0.122: v2(210.56,121.85) 209.11,120.4 199.32,120.4 196.16,123.56 190.31,123.56 190.14,123.39 176.85,123.39 176.43,123.81 v2(175.07,123.81)
WLAN_LED: length 83.8
  TOP w0.102: v2(254.56,122.57) 254.79,122.57 263.69,131.47 275.23,131.47 LED5.2 ; RZ33.2 201.71,121.46 v1(201.71,121.16) v2(201.71,119.46)
  IN3 w0.122: v2(254.56,122.57) 253.77,122.57 253.34,122.13 251.42,122.13 251.08,122.47 242.41,122.47 241.08,121.14 219.71,121.14 219.32,120.75 216.34,120.75 214.37,118.78 213.8,118.78 212.72,119.86 202.12,119.86 v2(201.71,119.46)
WLAN_LED#: length 13.9
  TOP w0.102: v2(170.75,87.43) v1(171.35,87.43)
  IN3 w0.122: v2(163.71,91.88) 163.71,91.07 167.34,87.43 v2(170.75,87.43)
  BOTTOM w0.102: QZ2.1 163.85,92.96 RZ14.1 163.53,92.05 v2(163.71,91.88) ; v2(170.75,87.43) 171.07,87.43 171.55,87.91 JNGFF1.6
WLAN_WIGIG60GHZ_DIS#: length 5.7
  TOP w0.102: UE1.A1 176.64,105.34 176.02,105.96 176.02,106.61 175.78,106.85 RE8.2 173.88,106.85 DZ1.1 173.87,107.44 v1(173.18,108.13)
WLAN_WIGIG60GHZ_DIS#_R: length 27
  TOP w0.102: DZ1.2 v2(172.47,105.73) v1(171.85,105.73)
  BOTTOM w0.102: v2(172.47,105.73) 172.47,103.94 172.98,103.43 172.98,96.42 175.87,93.53 179.33,93.53 180.15,92.7 182.5,92.7 183.78,91.42 183.78,89.71 184.05,89.44 JNGFF1.48
WLANCLK_REQ#: length 58.8
  IN1 w0.084: v2(141.99,83.24) 142.36,83.6 147.14,83.6 149.62,81.13 151.08,81.13 151.29,81.34 154.17,81.34 157.48,84.64 161.28,84.64 161.59,84.95 165.62,84.95 165.99,84.58 166.63,84.58 167.77,83.43 168.94,83.43 170.33,82.04 171.33,82.04 174.52,78.85 176.98,78.85 v2(178.97,76.86)
  BOTTOM w0.089: UC1.N1 138.91,83.14 139.84,83.14 140.55,83.85 141.38,83.85 v2(141.99,83.24) 142.74,82.49 143.91,82.49 144.36,82.03 RPC6.8
  BOTTOM w0.102: JNGFF1.45 183.3,80.23 182.32,79.25 v1(182.03,79.25) 180.47,79.25 180.06,78.84 180.06,77.57 179.36,76.86 v2(178.97,76.86)
WWAN_LED#: length 12.7
  BOTTOM w0.102: QZ11.1 206.16,55.3 206.03,55.43 RZ37.1 v1(206.99,56.79) 207.56,57.36 207.56,58.49 208.37,59.3 208.37,60.93 206.45,62.85 JNGFF2.10
WWAN_PWR_EN: length 10.9
  BOTTOM w0.102: RZ50.2 199.85,61.66 200.92,60.59 v1(201.18,60.59) 202.14,60.59 202.3,60.75 204.84,60.75 205.45,61.36 JNGFF2.6
WWAN_RADIO_DIS#: length 126.5
  TOP w0.102: RE10.2 185.11,108.36 v2(185.11,108.09) 184.88,108.09 184.19,107.4 UE1.A53
  IN2 w0.122: v2(185.11,108.09) 186.04,107.16 189.37,107.16 192.15,104.38 192.15,101.02 192.68,100.49 192.68,99.83 191.96,99.11 191.96,93.59 190.44,92.07 189.44,92.07 188.52,91.14 188.52,89.1 189.42,88.19 190.38,88.19 190.76,87.81 190.76,85.14 191.33,84.56 191.33,80.21 187.45,76.32 184.64,76.32 181.65,73.33 177.64,73.33 176.04,71.74 172.17,71.74 170.79,70.36 170.79,67.28 169.96,66.44 169.96,65.31 171.7,63.57 171.7,50.29 172.53,49.46 v2(172.53,48.82)
  BOTTOM w0.102: DZ5.1 200.6,56.3 198.82,54.52 v1(198.82,53.53) 198.82,51.81 195.86,48.85 189.04,48.85 187.25,47.06 187.25,45.2 185.7,43.65 176.83,43.65 172.53,47.95 v2(172.53,48.82)
WWAN_RADIO_DIS#_R: length 10.9
  BOTTOM w0.102: JNGFF2.8 205.95,61.54 204.93,60.52 202.4,60.52 v1(201.2,59.31) 200.6,58.72 DZ5.2
WWAN_WAKE#: length 131.7
  TOP w0.102: v2(189.36,102.35) 190.03,101.68 RE276.2 ; UE1.B43 186.63,101.59 186.39,101.35 186.03,101.35 v2(185.6,101.78)
  IN2 w0.122: v2(185.6,101.78) 185.6,101.76 187.29,100.07 187.29,94.21 186.28,93.2 186.28,92.3 185.35,91.37 185.35,89.8 183.87,88.31 183.87,83.49 184.15,83.2 184.15,79.14 181.2,76.19 177.81,76.19 176.61,77.39 173.62,77.39 172.3,76.08 172.3,74.73 168.28,70.72 168.28,69.93 166.98,68.62 166.98,66.89 166.86,66.77 166.86,65.37 167.32,64.91 167.32,61.93 170.46,58.79 170.46,49.67 v2(169.87,49.08)
  IN3 w0.122: v2(185.6,101.78) 185.6,102.02 185.82,102.24 187.51,102.24 187.84,101.91 188.92,101.91 v2(189.36,102.35)
  BOTTOM w0.102: JNGFF2.15 209.7,57.37 210.51,56.57 v1(210.51,52.77) 210.51,51.81 206.78,48.09 200.35,48.09 194.07,41.81 177.01,41.81 169.87,48.95 v2(169.87,49.08)
XDP_DBRESET#: length 160.4
  TOP w0.102: v2(68.2,50.46) 67.75,50.91 JXDP1.48 67.75,55.93 CC21.1 ; v2(163.02,86.12) v1(163.02,86.72)
  IN2 w0.122: v2(163.02,86.12) 162.03,85.13 162.03,84.23 160.07,82.27 160.07,81.4 160.45,81.02 160.45,77.64 158.41,75.59 158.41,74.28 157.54,73.42 157.54,70.25 157.97,69.83 157.97,68.92 155.92,66.87 155.92,57.3 149.85,51.22 138.2,51.22 134.57,47.6 79.36,47.6 70.49,38.73 65.41,38.73 63.69,40.44 62.73,40.44 v2(62.09,41.08)
  IN4 w0.084: v2(68.2,50.46) 66.48,50.46 65.98,49.97 65.98,45.76 62.93,42.72 62.93,41.91 v2(62.09,41.08)
  BOTTOM w0.102: RC77.1 158.74,84.89 160.72,84.89 161.37,85.54 UC4.1 163.02,85.54 163.03,85.53 RC122.2 163.5,86.05 163.43,86.12 v2(163.02,86.12)
XDP_OBS0_R: length 68.2
  TOP w0.102: v2(61.47,48.57) 61.25,48.35 JXDP1.21
  IN1 w0.084: v2(61.47,48.57) 61.66,48.76 61.66,55.45 65.69,59.48 65.69,65.59 66.71,66.61 66.71,70.82 71.33,75.44 75.06,75.44 77.68,78.05 80.05,78.05 80.63,78.64 82.06,78.64 85.74,82.31 91.54,82.31 92.97,83.75 95.8,83.75 96.87,84.82 v2(96.87,84.94)
  BOTTOM w0.076: UC1.J60 101.85,85 101.37,85 101.33,85.04 100.54,85.04 100.38,84.87 99.88,84.87 99.4,84.87 99.1,85.17 99.1,85.17 98.91,85.37 97.3,85.37 v2(96.87,84.94)
XDP_OBS1_R: length 72.8
  TOP w0.102: JXDP1.23 61.75,48 62.17,48.41 62.17,48.89 61.96,49.1 60.35,49.1 v2(60.33,49.08)
  IN1 w0.084: v2(60.33,49.08) 59.5,49.91 59.5,52.86 59.82,53.18 59.82,55.82 63.18,59.18 63.18,59.42 64.13,60.37 64.13,66.29 64.75,66.91 64.75,70.21 70.91,76.37 74.68,76.37 77.54,79.23 79.66,79.23 80.19,79.76 81.87,79.76 85.68,83.57 89.69,83.57 92.07,85.95 93.19,85.95 94.09,86.85 99.07,86.85 99.53,86.39 101.16,86.39 v2(101.84,85.71)
  BOTTOM w0.076: UC1.H60 102.14,86.01 v2(101.84,85.71)
XDP_OBS2_R: length 11.1
  TOP w0.102: T10.1 92.91,84.1 94.29,85.49 97.46,85.49 v2(98.43,86.46)
  BOTTOM w0.076: v2(98.43,86.46) 98.43,86.15 98.64,85.94 99.26,85.94 99.34,86.01 99.84,86.01 99.92,85.94 100.07,85.79 100.31,85.79 100.48,85.96 100.48,86.14 100.72,86.37 101.24,86.37 UC1.H61
XDP_OBS3_R: length 11.3
  TOP w0.102: T11.1 92.18,85.97 96.66,85.97 v2(97.14,86.45)
  BOTTOM w0.076: UC1.H62 100.39,85.63 100.39,85.63 100.38,85.62 100,85.62 99.85,85.77 99.78,85.85 99.45,85.85 99.37,85.77 97.82,85.77 97.52,86.07
  BOTTOM w0.102: 97.52,86.07 v2(97.14,86.45)
XDP_OBS4_R: length 11.7
  TOP w0.089: 99.39,91.66 99.39,88.88 100.4,87.87 100.4,87.11 101.16,86.35 102.43,86.35 103.21,85.57 v2(103.21,84.93)
  TOP w0.102: 99.39,91.66 99.39,92.52 T12.1
  BOTTOM w0.089: v2(103.21,84.93) 103.1,84.93 UC1.K59
XDP_OBS5_R: length 10.2
  TOP w0.089: 97.45,87.05 98.37,87.05 99.07,86.35 v2(99.07,86.33)
  TOP w0.102: T13.1 94.6,91.44 94.6,89.7 97.25,87.05 97.45,87.05
  BOTTOM w0.076: v2(99.07,86.33) 99.22,86.18 100.09,86.18 UC1.H63
XDP_OBS6_R: length 9.4
  TOP w0.089: v2(101.84,84.21) 101.35,84.7 99.23,84.7 98.43,83.9 95.29,83.9
  TOP w0.102: T14.1 93.77,83.38 94.29,83.9 95.29,83.9
  BOTTOM w0.076: UC1.K60 102.14,84.51 v2(101.84,84.21)
XDP_OBS7_R: length 9.7
  TOP w0.089: v2(101.19,85.71) 99.57,87.33 99.57,88.13 98.91,88.79 98.91,91.66
  TOP w0.102: T15.1 98.91,93.78 98.91,91.66
  BOTTOM w0.076: UC1.J61 101.49,85.41 v2(101.19,85.71)
XDP_RST#_R: length 3.6
  TOP w0.102: JXDP1.46 v1(67.25,54.89) 67.25,55.47 RC106.2
XTAL24_IN: length 16
  TOP w0.102: RC63.2 CC8.2 124.64,101.35 124.76,101.23 YC2.3
  TOP w0.109: v2(124.8,92.89) 124.61,93.08 124.2,93.08 123.55,93.73 123.55,94.73 122.66,95.62 v1(122.66,96.19) 122.66,98.76 122.9,99 122.9,100.89 RC63.2
  BOTTOM w0.076: UC1.A25 124.23,90.39 124.23,90.56 125.23,91.56 125.23,93.01 125.09,93.15 125.05,93.15 v2(124.8,92.89)
XTAL24_OUT: length 13.1
  TOP w0.109: v2(124.8,93.53) 124.68,93.41 124.29,93.41 123.83,93.87 v1(123.83,94.89) 123.83,95.62 122.9,96.56 122.9,98.67 RC65.1 RC63.1
  BOTTOM w0.076: v2(124.8,93.53) 125.01,93.31 125.16,93.31 125.39,93.08 125.39,91.49 124.4,90.5 124.4,90.14 124.1,89.85 UC1.B25
XTAL24_OUT_R: length 4.8
  TOP w0.109: RC65.2 CC11.2 124.48,98.21 125.02,97.67 v1(125.53,97.67) 125.98,97.67 YC2.1
XTALI: length 10.5
  TOP w0.102: UL1.10 209.75,111.71 210.97,110.48 210.97,109.67 RL11.2 210.87,108.83 CL14.2 210.14,107.59 209.06,107.59 208.93,107.45 208.93,105.12 YL1.1
XTALO: length 3.2
  TOP w0.102: RL11.1 RL10.2 209.62,111.06 v1(209.6,111.08) 209.35,111.33 UL1.9
XTALO_R: length 4.6
  TOP w0.102: RL10.1 210.01,108.8 CL13.2 210.01,107.9 209.92,107.81 208.97,107.81 208.7,107.55 208.7,106.67 208.57,106.54 YL1.3
Z2805: length 4
  TOP w0.102: v2(270.78,123.92) 270.61,123.92 RL18.1 269.23,123.17 v1(268.93,122.86)
  BOTTOM w0.102: v2(270.78,123.92) 270.81,123.89 TL1.22
Z2806: length 2.9
  TOP w0.102: v1(278.22,124.46) 278.43,124.26 v2(278.43,123.8) 278.44,123.79 RL16.1
  BOTTOM w0.102: TL1.16 v2(278.43,123.8)
Z2807: length 4.4
  TOP w0.102: RL17.1 271.3,123.17 v2(272.05,123.92) 272.05,124.07 271.77,124.35 v1(271.11,124.35)
  BOTTOM w0.102: TL1.21 272.08,123.89 v2(272.05,123.92)
Z2808: length 2.8
  TOP w0.102: RL15.1 279.71,123.77 v2(279.7,123.78) v1(279.7,124.41)
  BOTTOM w0.102: TL1.15 v2(279.7,123.78)
N15115: length 1.3
  TOP w0.089: v2(137.17,76.67) 137.63,76.21 T16.1
  BOTTOM w0.076: v2(137.17,76.67) 136.87,76.97 UC1.AD4
N19253: length 8.2
  BOTTOM w0.089: 95.66,65.8 96.39,65.8 99.52,68.93 UC1.AV63
  BOTTOM w0.102: T28.1 95.66,65.8
N19255: length 8.6
  BOTTOM w0.089: UC1.AU63 99.67,69.59 96.76,66.68 95.66,66.68
  BOTTOM w0.102: 95.66,66.68 94.72,66.68 T29.1
N19263: length 5
  BOTTOM w0.089: 97.66,89.03 100.1,89.03 UC1.C63
  BOTTOM w0.102: 97.66,89.03 95.64,89.03 T30.1
N19267: length 5
  BOTTOM w0.076: 97.45,88.8 99.67,88.8 99.86,88.62 100.58,88.62 UC1.C62
  BOTTOM w0.102: T31.1 96.45,88.05 97.2,88.8 97.45,88.8
N19275: length 7.1
  TOP w0.089: 108.45,95.69 108.74,95.39 108.74,93.39 107.79,92.43 v2(107.69,92.43)
  TOP w0.102: T33.1 108.45,95.69
  BOTTOM w0.076: UC1.A51 107.93,90.96 107.32,91.57 107.32,92.06 v2(107.69,92.43)
N19277: length 3.7
  TOP w0.089: v2(107.69,91.77) 107.18,92.29 T34.1
  BOTTOM w0.076: UC1.B51 107.93,89.85 108.23,90.14 108.23,90.89 107.69,91.43 v2(107.69,91.77)
N19281: length 6.1
  TOP w0.089: 97.45,81.84 97.6,81.84 99.01,83.25 98.99,83.25 v2(99.36,83.62)
  TOP w0.102: T35.1 97.45,81.84
  BOTTOM w0.076: v2(99.36,83.62) 99.6,83.38 100.38,83.38 100.54,83.54 101.32,83.54 101.37,83.49 101.83,83.49 UC1.L60
N21871: length 10.3
  TOP w0.102: v2(94.57,82.62) 93.69,81.75 T74.1
  BOTTOM w0.076: 97.45,81.64 98.64,81.64 98.75,81.75 99.94,81.75 100.07,81.88 100.38,81.88 100.54,82.04 101.33,82.04 101.37,82 101.85,82 UC1.P60
  BOTTOM w0.102: 97.45,81.64 95.55,81.64 v2(94.57,82.62)
N21873: length 3.7
  TOP w0.089: v2(101.19,82.71) 100.31,81.83 T75.1
  BOTTOM w0.076: UC1.P61 101.49,82.41 v2(101.19,82.71)
N21875: length 9.3
  TOP w0.089: T76.1 95.24,83.24 98.29,83.24 99.24,84.19 100.63,84.19 101.39,83.43 v2(103.2,83.43)
  BOTTOM w0.076: UC1.N59 102.89,83.12 v2(103.2,83.43)
N21877: length 8
  TOP w0.102: v2(96.52,82.62) 95.63,81.74 T77.1
  BOTTOM w0.076: UC1.N61 101.24,83.38 100.72,83.38 100.48,83.14 100.48,82.96 100.31,82.79 100.07,82.79 100.04,82.82 99.88,82.98 99.66,82.98
  BOTTOM w0.089: 99.66,82.98 99.36,82.98 98.52,82.14 96.84,82.14 96.52,82.47 v2(96.52,82.62)
N29827: length 3.5
  TOP w0.102: RD15.2 119.27,29.67 v2(118.95,29.99)
  BOTTOM w0.109: v2(118.95,29.99) 118.35,30.59 118.35,32.14 JDIMM1.197
N29829: length 4.4
  TOP w0.102: v1(119.95,30.79) v2(119.95,29.77) 120.21,29.52 RD16.2
  BOTTOM w0.102: JDIMM1.201 119.55,30.93 119.95,30.52 v2(119.95,29.77)
N33048: length 2.2
  TOP w0.102: CD36.2 72.01,25.34 71.69,25.02 71.15,25.02 70.96,25.21 70.96,25.21 v1(70.95,25.23)
  TOP w0.508: CD36.2 RD21.1
N33050: length 2.3
  TOP w0.102: CD54.2 127.8,31.78 RD25.1 127.8,30.38 v1(127.19,29.77)
N40459: length 5.5
  TOP w0.102: RV5.2 86.22,113.13 85.14,112.05 v1(84.2,112.05) QV2.1
N70739: length 3.1
  TOP w0.102: JDEG1.1 183.75,81.07 RE71.2 182.44,81.65 v1(182.44,81.07)
N70745: length 11.9
  TOP w0.102: UE2.B61 206.12,88.36 v2(205.63,88.84) ; v2(202.31,82.27) 202.11,82.48 RE64.1
  BOTTOM w0.102: v2(205.63,88.84) 206.14,88.34 206.14,84.17 204.82,82.86 204.09,82.86 203.51,82.27 v2(202.31,82.27)
N70747: length 2
  TOP w0.102: RE66.2 CE34.1 203.01,101.03 v1(202.14,101.03)
N70757: length 5.9
  TOP w0.102: UE2.A59 206.87,86.16 207.09,85.94 v1(207.09,85.42) 207.09,84.83 206.5,84.24 206.5,82.54 206.2,82.24 RE58.1 RE57.1
N73962: length 5.1
  TOP w0.102: v1(51.39,61.47) 51.69,61.47 52.34,60.82 54.04,60.82 CZ45.1
  TOP w0.203: CZ45.1 54.59,60.28 55.41,60.28 55.47,60.33 UZ9.12
N73964: length 4.2
  TOP w0.102: CZ46.1 54.41,61.31 53.95,61.76 52.85,61.76 52.43,62.18 v1(52.43,62.44)
  TOP w0.203: CZ46.1 55.3,61.31 55.47,61.13 UZ9.10
N75571: length 10.9
  TOP w0.102: 193.36,116.64 193.36,114.67 193.17,114.48 v1(192.83,114.48) QZ3.1 ; 193.36,116.64 DZ3.2 ; 193.36,116.64 193.89,117.17 RZ24.2 195.29,117.17 DZ4.2 195.33,117.47 194.69,118.1 194.69,119.74 194.3,120.13 QZ14.1
N75591: length 2.1
  TOP w0.102: v1(193.63,112.7) 193.58,112.65 RZ27.1 192.68,112.65 QZ4.1
N75595: length 3.2
  TOP w0.102: v1(191.76,117.73) 191.58,117.55 QZ3.3 192.76,115.78 DZ3.1
N75597: length 2.6
  TOP w0.102: QZ3.6 189.68,114.08 189.91,113.86 QZ4.2 188.97,113.31 v1(188.67,113.01)
N75599: length 2.9
  TOP w0.102: v1(200.37,121.21) 200.09,121.49 RZ33.1 200.09,123.05 QZ9.1
N75603: length 5.9
  TOP w0.102: QZ7.6 v1(195.48,126.99) 196.6,126.99 197.83,125.76 QZ9.2
N525777: length 2.5
  TOP w0.102: CZ42.1 v1(198.64,35.92)
  TOP w0.203: UZ8.10 198.69,34.93 CZ42.1
N588510: length 2.7
  TOP w0.102: v1(198.85,33.1) 198.64,33.3 CZ41.1
  TOP w0.203: CZ41.1 198.69,34.13 UZ8.12
N5261056: length 102
  TOP w0.254: QD1.3 108.5,8.31 109.6,9.41 v1(109.6,12.69) v2(109.6,18.51) ; RD10.1 RD11.1 v2(96,20.04) ; v2(168.3,18.86) 168.3,19.59 168.76,20.04 RD12.1 RD13.1
  IN1 w0.254: v2(96,20.04) 98.85,20.04 99.69,20.89 105.04,20.89 107.42,18.51 v2(109.6,18.51)
  IN2 w0.254: v2(109.6,18.51) 120.08,18.51 122,16.59 149.68,16.59 150.56,17.47 154.52,17.47 155.37,16.61 165.66,16.61 167.91,18.86 v2(168.3,18.86)
N10757881: length 2.4
  TOP w0.102: RD7.1 56.59,38.51 55.93,39.17 v1(55.78,39.17)
  TOP w0.508: RD7.1 56.59,37.23 CD21.2
N15438178:
  vias: v1(47.11,48.05)
N15438627: length 4.9
  BOTTOM w0.102: v1(42.62,41.99) 42.62,41.52 42.19,41.09 PR710.1
  BOTTOM w0.203: PC711.1 40.41,40.16 40.28,40.29 PU700.6 ; PC711.1 PR711.1 ; PC711.1 42.17,41.04 PR710.1
N15439163: length 3.2
  TOP w0.102: v1(42.46,39.6) 42.46,39.75 41.62,40.59 PR714.2
  TOP w0.254: v2(40.59,40.64) 40.64,40.59 PR714.2
  BOTTOM w0.203: v2(40.59,40.64) 40.54,40.69 PU700.5
N15439291: length 4.2
  BOTTOM w0.102: v1(41.37,36.57) PR716.2
  BOTTOM w0.203: PU700.7 40.17,39.89 40.74,39.32 40.74,38.95 PC718.2
  BOTTOM w0.254: PC718.2 41.29,37.61 PR716.2
N15439295: length 2.7
  TOP w0.254: PR718.2 39.63,37.98 v2(39.55,38.06) 39.55,38.62 PC719.2
  BOTTOM w0.203: v2(39.55,38.06) 38.92,38.69 PU700.8
N15439512: length 4
  TOP w0.102: v1(37.72,36.72) 38.28,37.28 PR720.2
  TOP w0.254: PR720.2 38.74,37.85 v2(38.92,38.02) 38.92,38.51 PR788.2
  BOTTOM w0.203: v2(38.92,38.02) 38.92,38.23 38.52,38.63 PU700.9
N15440461: length 2.1
  BOTTOM w0.203: PU700.10 38.12,38.56 38.46,38.22 38.46,37.54 PR717.2
N15441413: length 2.3
  TOP w0.254: v2(34.8,41.12) 34.67,41.25 33.9,41.25 PR722.1
  BOTTOM w0.203: v2(34.8,41.12) 34.82,41.09 PU700.18
N15441884: length 2.6
  TOP w0.432: PR723.1 34.1,40.53 v2(34.8,40.53) 34.81,40.54 35.07,40.54 35.54,40.07 PC729.1
  BOTTOM w0.203: v2(34.8,40.53) 34.9,40.53 35.05,40.69 PU700.17
N15442134: length 31.5
  TOP w0.102: v2(16.87,51.21) v1(16.87,50.51)
  TOP w0.254: v2(32.25,43.18) 32.45,43.39 PC727.1 32.93,43.39 33.66,42.66 34,42.66 34.42,42.24 v2(34.66,42.24) 35.28,42.24 PC726.2
  IN3 w0.254: v2(32.25,43.18) 32.08,43.18 31.28,42.38 24.79,42.38 23.98,41.57 19.45,41.57 16.74,44.28 16.74,51.08 v2(16.87,51.21)
  BOTTOM w0.203: PU700.20 35.16,41.89 34.81,42.24 v2(34.66,42.24)
  BOTTOM w0.254: v2(16.87,51.21) 16.5,50.84 PR721.3
N15442185: length 32.4
  TOP w0.102: v2(16.22,51.25) v1(16.22,51.9)
  TOP w0.254: PC728.1 35.5,41.11 34.88,41.74 v2(34.27,41.74) 34.27,41.79 33.89,42.17 33.2,42.17 PC727.2 32.77,42.6 v2(32.21,42.6)
  IN3 w0.254: v2(16.22,51.25) 16.36,51.11 16.36,44.12 19.33,41.15 24.26,41.15 25.11,42 31.61,42 v2(32.21,42.6)
  BOTTOM w0.203: v2(34.27,41.74) 34.82,41.74 35.06,41.49 PU700.19
  BOTTOM w0.254: PR721.2 16.5,51.53 v2(16.22,51.25)
N17156946: length 75.9
  BOTTOM w0.254: PQ4.4 50.25,39.06 50.99,39.81 50.99,41.65 52.31,42.97 52.31,45.66 53.56,46.9 53.56,49.04 58.23,53.71 58.23,62.77 59.17,63.71 63.16,63.71 67.12,67.67 67.12,69.1 75.92,77.9 75.92,83.42 75.6,83.75 75.12,83.75 74.68,84.19 74.68,92.51 73.7,93.49 73.7,97.81 72.9,98.61
  vias: v1(72.67,99.37) v2(71.96,99.94) v2(71.96,99.3) v2(71.96,98.67)
N17156948: length 1.4
  TOP w0.102: PQ6.1 v1(67.86,96.07)
N17639884: length 2.8
  TOP w0.102: v2(87.05,103.08) v1(86.17,103.08)
  TOP w0.508: v2(87.05,103.08) 87.44,102.68 PC505.2
  BOTTOM w0.203: PU500.2 87.75,102.87 87.54,103.08
N17640254: length 6.6
  TOP w0.254: v2(83.04,97.03) 83.64,97.64 PR535.1
  BOTTOM w0.203: PU500.25 86.38,98.7 86.05,98.36 86.05,97.31 v1(85.59,96.86) 85.11,96.37 PC506.1
  BOTTOM w0.254: PC506.1 PR523.1 83.7,96.37 v2(83.04,97.03)
N17640267: length 2
  TOP w0.102: v1(82.86,98.42) 83.25,98.42 83.39,98.56 PR535.2
  TOP w0.254: PR535.2 PC512.1
N17640270: length 6.8
  TOP w0.102: v2(85.47,98.06) 85.85,97.68 v1(85.85,97.44)
  TOP w0.254: PC512.2 85.05,97.64 v2(85.47,98.06)
  BOTTOM w0.203: PU500.26 86.26,99.1 85.94,98.78 85.52,98.78
  BOTTOM w0.254: PR523.2 PC506.2 85.04,97.29 85.47,97.72 v2(85.47,98.06) 85.4,98.06 84.88,98.58 PR521.1 85.07,98.78 85.52,98.78
N17645088: length 4.1
  TOP w0.102: v1(106.3,108.4) PR512.2
  TOP w0.254: v2(107.38,109.01) 107.38,108.52 PR512.2
  BOTTOM w0.254: PL500.3 107.15,108.78 v2(107.38,109.01)
N17680637: length 3.5
  TOP w0.102: v2(90.93,103.37) 91.7,103.37 v1(91.9,103.57)
  TOP w0.254: PR536.2 90.82,103.48 v2(90.93,103.37)
  BOTTOM w0.203: PU500.8 90.15,102.46 90.93,103.24 v2(90.93,103.37)
N17680665: length 3.8
  TOP w0.102: PR539.1 v1(87.16,103.94)
  TOP w0.254: v2(88.79,103.62) 88.47,103.94 PR539.1
  BOTTOM w0.203: PR516.1 88.15,103.41 PU500.3
  BOTTOM w0.254: PR516.1 88.34,103.62 v2(88.79,103.62)
N18325201: length 4.3
  BOTTOM w0.102: v1(268.1,133.9) CL16.1 269.66,133.9 270.81,132.76 TL1.3
N18325205: length 4
  BOTTOM w0.102: TL1.4 272.08,132.08 270.76,133.39 CL17.1 271.9,133.9 v1(271.96,133.85)
N18325209: length 8.3
  TOP w0.102: v2(275.85,129.07) 275.53,128.76 CL20.1
  BOTTOM w0.102: v1(278.25,133.37) 278.43,133.19 TL1.9 278.43,130.71 278.26,130.55 277.68,130.55 276.74,129.61 276.39,129.61 v2(275.85,129.07)
N18325213: length 8.8
  TOP w0.102: CL21.1 v2(276.48,129.07)
  BOTTOM w0.102: v1(279.7,133.38) TL1.10 279.7,130.62 279.35,130.28 277.8,130.28 276.6,129.07 v2(276.48,129.07)
N18328616: length 2.6
  TOP w0.102: UL3.10 196.89,107.99 196.97,107.9 197.3,107.9 v1(197.66,107.54) 197.81,107.39 CL24.1
N18328720: length 2.4
  TOP w0.102: CZ37.1 198.73,108.89 v1(197.81,108.89) 197.08,108.89 196.97,108.78 UL3.12
N18609334: length 10.5
  BOTTOM w0.102: RV6.2 125.06,124.58 125.51,124.12 QV7.1 125.98,123.4 125.66,123.08 124.93,123.08 123.64,121.78 122.21,121.78 QV8.2 120.61,122.72 v1(119.69,121.8)
N18734615: length 3.7
  BOTTOM w0.102: YV2.3 143.36,105.17 143.45,105.08 143.94,105.08 RV81.1 145.43,106.57 CV113.1
N19516037: length 0.8
  TOP w0.102: RZ35.1 CZ9.1
N19540333: length 6.7
  TOP w0.102: UZ2.10 192.6,46.81 192.62,46.83 192.62,47.22 192.37,47.48 191.46,47.48 190.78,48.15 190.78,50.74 CZ23.1
N19540335: length 5.6
  TOP w0.102: CZ49.1 190.55,48.06 191.8,46.81 UZ2.12
N19544058: length 0.9
  TOP w0.102: CC10.2 RC62.1
N19544059: length 3
  TOP w0.102: v1(194.72,73.82) 194.31,74.22 193.47,74.22 193.02,74.68 CC9.2 RC61.1
N19638635: length 3.6
  TOP w0.254: PU100.19 49.06,25.47 49.65,26.06 v1(49.65,26.47) 50.33,27.16 50.9,27.16 PR114.1
N19651849: length 2
  TOP w0.102: v1(182.64,91.65) 183.01,92.01 RE27.2 CE9.1
N19651850: length 8.9
  TOP w0.102: v2(179.22,97.79) 178.94,97.51 UE1.B19 ; RE24.1 178.51,92.73 v2(178.51,92.36) 178.51,92.03 v1(178.31,91.82)
  IN2 w0.122: v2(178.51,92.36) 180.37,94.21 180.37,95.91 179.22,97.05 v2(179.22,97.79)
N20106358: length 2.3
  TOP w0.102: RV50.1 125.44,111.85 v1(125.44,112.35) 125.44,112.88 125.53,112.98 UV7.27
N20106372: length 5
  TOP w0.102: v1(117.66,123.32) CV60.1 118.11,121.9 118.11,120.77 119.3,119.58 UV7.1
N20249193: length 3.3
  TOP w0.203: UA1.35 210.74,72.57 211.13,72.96 211.13,73.71 CA29.1
N20249194: length 6.5
  TOP w0.102: CA29.2 v1(214.1,74.25)
  TOP w0.203: UA1.36 210.65,72.97 210.8,73.12 210.8,73.88 211.06,74.14 211.06,74.75 211.23,74.92 212.38,74.92 CA29.2
N20249196: length 6.2
  TOP w0.203: UA1.31 210.84,70.97 211.2,70.62 213.07,70.62 213.81,69.88 v1(214.05,69.88) CA25.1
N20249200: length 0.8
  TOP w0.102: RA12.1 CA27.1
N20249201: length 0.8
  TOP w0.102: CA28.1 RA13.1
N20249202: length 3.2
  TOP w0.102: QA2.5 QA2.6 217.51,77.67 217.24,77.4 RA21.2 v1(216.69,76.18)
N20249205: length 0.9
  TOP w0.102: CA33.1 RA17.2
N20249232: length 1.1
  TOP w0.254: DA5.1 214.36,71.06 RA25.2
N20249233: length 2.2
  TOP w0.102: v1(215.35,73.28) DA4.1
  TOP w0.254: DA4.1 214.48,72.18 RA24.2
N20249314: length 1
  TOP w0.102: RA27.2 208.94,61.89 QA3.3
N20249315: length 2.4
  TOP w0.102: RA28.2 205.62,60.59 QA3.6 v1(206.21,59.34)
N20360585: length 2.5
  TOP w0.203: CA49.2 210.8,72.17 UA1.34
N20361305: length 3.5
  TOP w0.203: CA35.2 211.55,66.25 210.17,67.62 210.17,68.29 209.89,68.57 UA1.25
N20363962: length 6.7
  TOP w0.102: UA1.21 207.48,66.84 207.81,66.51 208.54,66.51 CA51.1 208.23,65.55 208.23,64.35 208.5,64.09 208.5,63.38 208.99,62.88 RA44.1
N20363967: length 3.3
  TOP w0.152: UA1.39 207.88,74.23 208.07,74.42 208.07,74.42 208.83,75.17 209.36,75.17 209.88,75.7 CA52.1
N20363972: length 4.8
  TOP w0.102: UA1.7 201.58,70.57 201.47,70.46 200.35,70.46 CA53.1 200.01,70.13 v1(198.78,70.13)
N20630808: length 3.2
  TOP w0.102: RE284.2 RE70.2 198,101.94 v1(198,101.27) QE4.2
N20711035: length 1.1
  BOTTOM w0.102: PC304.2 195.32,62.81 v1(194.97,62.46)
N20813044: length 240.1
  TOP w0.254: PD813.1 5.01,27 5.72,26.29 v2(6.52,26.29) ; PQ826.4 199.21,22.69 199.39,22.51 199.39,22.24 199.24,22.09 v2(198.81,22.09) ; v2(159.41,20.58) 159.41,16.93 163.59,12.75 178.79,12.75 179.71,13.67 194.13,13.67 v1(196.03,11.77) 197.14,10.66 198.86,10.66 199.32,11.12 199.32,15.04 v2(198.05,16.31)
  IN2 w0.254: v2(198.81,22.09) 198.05,21.33 v2(198.05,16.31) ; v2(159.41,20.58) 159.41,19.79 158.99,19.37 133.53,19.37 133.05,19.85 121.08,19.85 120.6,19.37 107.14,19.37 103.37,23.14 99.56,23.14 98.02,24.68 57.08,24.68 51.75,30.01 49.53,30.01 48.78,30.76 43.55,30.76 41.94,32.38 32.7,32.38 29.85,29.52 29.85,27.63 29.25,27.03 29.25,23.14 26.79,20.68 26.79,19.2 25.84,18.25 25.62,18.25 24.02,16.65 18.38,16.65 18.07,16.96 15.81,16.96 11.99,20.78 7.88,20.78 7.61,21.05 7.61,25.2 v2(6.52,26.29)
N20813052: length 0.8
  TOP w0.102: v2(197.97,24.64) PQ826.1
  vias: v1(195.37,22.04) v2(195.73,21.24) v2(195.73,20.63) v2(195.73,19.98) v2(195.73,19.37) v2(195.73,18.75) v2(195.72,18.11) v2(196.47,19.99) v2(196.45,19.36) v2(196.45,18.71) v2(196.43,18.13) v2(196.48,21.26) v2(196.48,20.63) v2(196.69,21.87) v2(197.39,21.86) v2(197.96,24.03) v2(197.94,23.41) v2(197.94,22.77) v2(197.93,22.16)
N20813067: length 3.8
  TOP w0.254: PR828.2 5.25,31.44 v1(4.41,31.44) 4.15,31.44 3.76,31.83 PQ832.2
N20813069: length 4.2
  TOP w0.254: PQ829.2 6.94,35.12 6.19,35.87 PR830.2 5.41,36.55 v1(5.17,36.31) PQ832.1
N20813073: length 18.5
  TOP w0.254: PQ829.1 10.12,34.15 11.17,35.2 14.05,35.2 14.46,35.6 v1(14.46,38) 14.38,38.08 14.38,44.17 14.95,44.75 16.97,44.75 17.54,44.18 PD815.2
N20813075: length 8.2
  TOP w0.102: v1(4.49,32.73) 4.78,33.02 5.53,33.02 5.69,33.19 PQ829.3
  TOP w0.254: PR830.1 PR895.2 7.97,36.17 8.26,35.88 8.26,33.39 8.05,33.19 PQ829.3
N20813085: length 1.6
  BOTTOM w0.102: PC807.2 v1(209.12,15.21)
N20826302: length 2.7
  TOP w0.102: PR204.1 v1(76.9,18.2)
  TOP w0.508: PR204.1 76.9,20.25 v2(76.46,20.69)
N20857922: length 224.2
  TOP w0.254: v2(10.31,35.46) 10.31,35.5 10.67,35.85 PQ806.3
  IN1 w0.254: v2(10.31,35.46) 10.31,35.45 10.15,35.28 10.15,22.41 9.55,21.81 9.55,17.25 11.62,15.18 14.31,15.18 15.09,14.39 16.15,14.39 17.27,13.27 17.27,12.09 20.23,9.13 59.66,9.13 60.06,9.54 87.11,9.54 87.48,9.17 148.75,9.17 149.44,9.86 152.04,9.86 152.4,9.5 175.85,9.5 180.16,13.81 204.64,13.81 v2(205.01,14.17)
  BOTTOM w0.102: v1(205.62,13.72) 205.46,13.72 v2(205.01,14.17)
  BOTTOM w0.254: PR815.2 203.82,14.82 204.24,14.41 PR816.1 204.28,14.17 v2(205.01,14.17)
N20862119: length 3
  TOP w0.102: PR524.1 96.6,99.62 v1(97.01,100.03)
  TOP w0.254: PR518.2 PR525.1 PR524.1
N20899585: length 3.5
  TOP w0.102: UV600.20 137.92,113.11 137.77,112.96 137.43,112.96 RV600.1 v1(135.51,112.01)
N20899609: length 7.3
  TOP w0.102: CV605.1 v1(132.92,113.47) 135.03,113.47 135.71,114.14 137.78,114.14 137.95,114.31 UV600.17
N20935195: length 1.8
  BOTTOM w0.203: PU700.21 35.32,42.29 34.9,42.71 PR799.1
N20987678: length 7.3
  TOP w0.102: PD817.1 11.35,34.28 12.49,34.28 12.78,33.99 v1(13.71,33.99)
  TOP w0.508: PQ814.3 9.72,31.16 10.35,31.79 PR827.2 10.7,32.99 11.03,33.32 PD817.1
N20987955: length 221.9
  TOP w0.102: v1(14.04,36.25) 14.04,36.33 v2(13.54,36.82)
  TOP w0.381: PQ806.6 13.21,37.15 v2(13.54,36.82)
  TOP w0.406: v2(13.54,36.82) 13.22,36.5 PQ806.5
  IN1 w0.508: v2(13.54,36.82) 14.29,36.07 14.29,30.99 13.17,29.87 13.17,26.24 11.79,24.86 11.79,17.47 12.78,16.48 15.86,16.48 17.13,15.21 17.6,15.21 19.63,13.17 19.63,12.71 21.94,10.4 59.13,10.4 59.54,10.81 86.21,10.81 86.76,11.36 143.27,11.36 143.59,11.67 152.03,11.67 152.9,10.8 175.35,10.8 179.76,15.21 200.38,15.21 201.8,16.63 v2(203.25,16.63)
  BOTTOM w0.508: v2(203.25,16.63) 203.55,16.63 203.82,16.35 PR813.2
N20988471: length 3.7
  TOP w0.102: PR819.1 v1(11.22,21.81)
  TOP w0.254: PU806.1 11.26,23.23 11.28,23.2 PQ817.6 12.25,22.78 PR819.1
N21132814: length 4.2
  TOP w0.102: RZ36.1 196.61,117.79 QZ12.1 198.73,119.48 199.14,119.89 v1(199.14,120.46)
N21200144: length 2.7
  TOP w0.102: RN2.2 216.61,109.82 QN1.6 QN1.5 v1(215.06,108.84)
N21281743: length 1.7
  BOTTOM w0.102: UV13.12 139.35,103.69 139.45,103.78 CV116.1
N21281745: length 1.7
  BOTTOM w0.102: CV117.1 138.55,104.94 UV13.10
N21423939: length 5.8
  TOP w0.102: v1(123.88,13.63) 123.7,13.45 v2(123.7,12.96)
  BOTTOM w0.102: SW1.2 124.99,13.3 124.65,12.96 v2(123.7,12.96) 122.07,12.96 RC2.2
N21533765: length 5.4
  TOP w0.102: v2(98.51,117.29) v1(98.51,116.49) 98.67,116.34 LV1.1
  BOTTOM w0.102: v2(98.51,117.29) 97.95,117.85 97.09,117.85 96.47,117.22 JEDP1.21
N21940788: length 2.6
  TOP w0.102: v1(57.74,118.7) 57.36,119.08 RI14.2 57.76,119.64 57.9,119.5 UI3.16
N22118161: length 4.2
  TOP w0.102: RD28.1 194.87,34.39 v2(195.07,34.6) v1(195.66,34.6)
  BOTTOM w0.102: JDIMM2.197 194.35,33.87 v2(195.07,34.6)
N22118165: length 6.7
  TOP w0.102: RD27.1 193.3,35.74 193.86,36.3 v1(194.05,36.3) 194.83,36.3 v2(195.01,36.12)
  BOTTOM w0.102: JDIMM2.201 195.55,35.58 v2(195.01,36.12)
N22342675: length 2.1
  TOP w0.203: UZ7.12 v1(135.16,97.91) 136.13,97.91 CZ62.1
N22342677: length 2.6
  TOP w0.203: CZ60.1 135.74,96.56 v1(135.22,96.56) 134.92,96.56 134.37,97.11 UZ7.10
N23772096: length 7.5
  TOP w0.102: UA1.22 207.88,67.03 v2(207.99,66.93) ; RA45.1 211.05,62.33 v2(211.1,62.39)
  IN3 w0.122: v2(207.99,66.93) 209.58,65.34 209.58,63.58 210.77,62.39 v2(211.1,62.39)
N24297830: length 2
  TOP w0.102: UI7.7 v1(223.4,78.57) RI4.1
N24352286: length 2
  BOTTOM w0.102: v1(173.56,124.31) 173.71,124.46 C319.1 R273.2
N24352288: length 1.9
  BOTTOM w0.102: v1(165.12,123.35) 165.12,124.31 R41.2 C43.1
N24352290: length 1.9
  BOTTOM w0.102: C42.1 R6.2 161.36,123.36 v1(161.38,123.33)
N24544483: length 31.6
  TOP w0.254: PR10.2 70.36,111.47 70.98,112.09 PQ2.1 70.98,112.68 70.55,113.11 68.77,113.11 PR7.1 67.74,113.41 67.25,112.92 v2(66.08,112.92) ; v2(74.69,116.21) v3(76.52,114.38) 77.45,113.45 PL3.1
  BOTTOM w0.254: v2(74.69,116.21) 71.87,116.21 70,118.08 PD5.3 PD5.2 67.17,120.81 65.9,119.54 65.9,113.1 v2(66.08,112.92)
N24550841: length 5.2
  BOTTOM w0.102: v1(146.99,19.02) PR6.2
  BOTTOM w0.254: PR6.2 v2(147.6,18.05) PC4.1 148.21,17.59 147.91,17.29 146.94,17.29 146.7,17.05 PQ1.2
N24550859: length 3.5
  BOTTOM w0.254: PQ1.1 148.45,14.15 v1(149.3,13.3) 150.53,13.3 PD4.2
N24606174: length 1.1
  TOP w0.102: PC309.1 v1(189.45,64.38)
  vias: v2(191.62,65.56)
N24627279: length 8.5
  TOP w0.102: v1(13.97,32.31) 13.49,32.79 13.08,32.79 v2(12.66,32.38)
  TOP w0.254: PR853.2 v2(12.52,27.33) ; v2(12.66,32.38) PQ813.5
  BOTTOM w0.254: v2(12.66,32.38) 12.52,32.24 v2(12.52,27.33)
N25195640: length 2.2
  BOTTOM w0.102: RV702.2 v1(167.57,116.97)
  BOTTOM w0.508: QV700.3 167.57,117.96 RV702.2
N48705653: length 6
  TOP w0.102: v1(67.5,113.77) 68.06,114.33 PR7.2
  TOP w0.254: PR7.2 69.99,114.33 PQ2.3 70.49,114.83 70.49,116.35 PR9.1
N48705663: length 4.4
  TOP w0.102: v1(68.42,109.69) PR12.2
  TOP w0.254: PQ3.2 70.99,109.06 70.39,109.67 69.41,109.67 PR12.2 PR10.1
N48705665: length 8.3
  TOP w0.102: PR11.2 73.14,116.16 73.56,115.74 v1(73.56,115.24)
  TOP w0.254: PQ3.1 71.64,111.12 71.94,111.41 PQ2.2 71.94,115.99 PR13.1 73.11,116.2 PR11.2
N48708367:
  vias: v1(74.35,16.54)
N48708425:
  vias: v1(74.37,17.87)
N48716673: length 5.1
  TOP w0.102: PR838.1 14.81,38.81 v1(14.81,40.24)
  TOP w0.254: PU800.28 16.09,37.54 PR838.1
N48716693: length 2.3
  TOP w0.254: PR845.1 19.19,39.45 19.41,39.23 PU800.26
N49522072:
  vias: v1(49.52,37.52)
N49522215: length 17.5
  TOP w0.254: PR706.2 55.95,39.65 57.56,38.04 58.83,38.04 59.21,38.42 59.21,39.27 60.49,40.55 v1(60.49,41.23) 59.11,42.61 PQ703.1 59.11,43.76 58.7,44.16 57.71,44.16 57.42,44.45 PR709.2 57.03,44.1 56.76,43.83 56.25,43.83 PR707.2 56.48,42.94 56.48,42.76 56.77,42.47 57.06,42.47 57.21,42.61 PQ703.3
N49522242: length 4.5
  TOP w0.254: PC703.1 v2(41.95,42.83) 41.96,42.82 PR705.2
  BOTTOM w0.102: v1(42.57,43.35) 42.05,42.83 v2(41.95,42.83)
  BOTTOM w0.203: PC702.2 40.78,42.29 PU700.1
  BOTTOM w0.254: PC702.2 v2(41.95,42.83)
N49522275: length 4.7
  TOP w0.102: v1(42.56,40.96) PR704.2
  TOP w0.254: PC701.2 41.63,41.72 v2(41.95,42.04) 41.97,42.06 42.43,42.06 PR704.2
  BOTTOM w0.203: PU700.2 41.3,41.89 PC702.1
  BOTTOM w0.254: v2(41.95,42.04) 41.82,41.91 PC702.1
N49522729: length 17.8
  TOP w0.254: PQ701.1 53.72,38.8 53.72,49.33 52.71,50.35 v1(49.74,50.35) 49.02,50.35 48.83,50.54 v2(48.83,50.85)
  BOTTOM w0.254: v2(48.83,50.85) 48.49,51.2 PR701.2
N49522731: length 22.7
  TOP w0.254: v2(48.14,50.85) 48.14,50.7 48.93,49.9 v1(51.68,49.9) 52.61,49.9 53.34,49.17 53.34,40.19 52.58,39.42 52.58,36.31 53.74,35.16 PQ702.1
  BOTTOM w0.254: PR701.3 48.49,50.5 v2(48.14,50.85)
N49522780: length 8.4
  BOTTOM w0.254: PQ700.4 50.17,42.98 50.66,43.48 51.69,43.48 51.93,43.72 v2(51.93,46.07) 51.93,46.47 PR700.1
N61500733: length 1.7
  TOP w0.254: v2(88.79,103) 88.79,102.63 PR513.1
  BOTTOM w0.203: v2(88.79,103) 88.79,102.93 88.55,102.7 PU500.4
N61500909: length 7.5
  TOP w0.254: PC510.2 84.84,99.76 84.19,99.11 83.23,99.11 v2(83.04,98.91)
  BOTTOM w0.102: v2(83.04,98.91) 82.98,98.91 v1(82.57,99.33)
  BOTTOM w0.203: PU500.28 85.96,99.9 85.87,99.99 84.2,99.99 PR526.1
  BOTTOM w0.254: PR526.1 83.73,99.61 v2(83.04,98.91)
N61500999: length 1.9
  TOP w0.102: PR515.1 109.81,107.48 v1(110,107.29)
  TOP w0.254: PR515.1 109.03,106.62 PH501.2
N61501245: length 15.9
  TOP w0.254: v2(92.89,100.66) PR505.2
  BOTTOM w0.203: PU500.14 91.34,99.5 92.05,98.8 92.66,98.8 92.89,99.03 PC501.1 v2(92.89,100.66)
  BOTTOM w0.254: v2(92.89,100.66) 92.97,100.74 94.45,100.74 v1(94.69,100.98) 94.92,101.21 94.92,102.59 99,106.67 99.88,106.67 PH500.2
N61501462: length 3.2
  BOTTOM w0.203: PU500.16 91.21,98.7 91.32,98.59 91.32,97.64 91.68,97.27 PR511.2
N66971793: length 3.5
  TOP w0.254: PR105.2 43.63,27.91 v1(44.15,27.38) 44.41,27.12 45.79,27.12 45.94,26.97 PU100.5
N66972075: length 4.2
  TOP w0.254: PU100.1 47.54,26.97 47.67,27.09 48.83,27.09 v1(49.62,27.88) 50.33,28.59 PR106.2
N78957489: length 8.1
  TOP w0.102: v2(199.88,10.16) v1(199.13,10.16)
  TOP w0.254: PQ816.1 201.32,10.16 v2(199.88,10.16)
  BOTTOM w0.254: v2(199.88,10.16) 198.24,10.16 197.37,11.03 PR822.2
N78967043: length 207.6
  TOP w0.254: PQ816.2 198.23,7.72 196.47,9.48 v2(196.47,10.44)
  IN1 w0.254: v2(196.47,10.44) 194.44,8.41 171.24,8.41 170.99,8.16 150.11,8.16 149.86,8.41 76.32,8.41 76,8.09 61,8.09 60.71,8.37 19.92,8.37 15.46,12.82 14.92,12.82 13.32,14.42 10.74,14.42 8.66,16.5 v2(8.66,25.17)
  vias: v1(7.83,25.42)
N78985854: length 5.2
  TOP w0.102: v1(5.88,39.37) PR812.2
  TOP w0.254: PR810.2 9.85,38.22 v2(9.26,38.22) PU804.2 6.01,38.22 PR812.2
N79002827: length 2.6
  TOP w0.254: PQ806.2 v1(10.06,36.5) 9,37.57 PU804.4
N79023703: length 3.2
  TOP w0.254: PU800.19 22.91,39 23.12,39.21 23.86,39.21 v1(24.28,39.64) 24.28,40.48 PR863.1
N79030038: length 3.2
  TOP w0.102: v1(14.39,28.27) 14.19,28.07 PR829.2
  TOP w0.254: PQ813.2 PQ813.3 13.31,28.16 PR829.2
N79030087: length 3.9
  TOP w0.102: v1(11.58,32.26) 12.01,31.83 PQ813.6 12.01,31.24
  TOP w0.254: PR826.2 11.31,29.65 11.31,29.98 12.01,30.68 12.01,31.24
N79030091: length 4.5
  TOP w0.102: v1(8.94,27.74) PQ814.2
  TOP w0.254: PQ814.2 9.97,29.23 PR826.1 PR827.1
N79030745: length 4.7
  TOP w0.102: v1(7.81,27) PD813.2
  TOP w0.254: PQ814.1 6.86,28.52 6.43,28.1 PD813.2
N80905978:
  vias: v1(193.45,77.71)
N80906026: length 1.9
  BOTTOM w0.102: v1(192.24,84.83) 192.94,85.53 PR402.2

## Copper pours and planes (outline as drawn)
0.675V_DDR_VTT_ON on TOP (solid shape): 95.57,11.94 95.57,9.62 95.37,9.41 95.37,8.75 95.59,8.53 96.69,8.53 96.94,8.78 96.95,8.78 97.11,8.94 98.04,8.94 98.16,8.82 98.16,7.87 98.11,7.82 97.48,7.82 97.46,7.79 94.14,7.79 94.01,7.92 94.01,9.3 94.2,9.49 94.6,9.49 94.87,9.76 94.87,10.38 94.76,10.49 94.47,10.49 94.01,10.95 94.01,12 94.15,12.14 95.37,12.14
1.05V_MP_PWROK on BOTTOM (solid shape): 189.49,66.79 189.49,65.46 190.17,64.77 190.17,63.74 190.11,63.68 188.62,63.68 188.57,63.73 188.57,64.37 189.17,64.96 189.17,66.79 189.23,66.86 189.42,66.86
1.5VSP on BOTTOM (solid shape): 194.39,87.61 197.23,87.61 197.41,87.42 197.41,87.04 196.99,87.04 196.94,86.99 196.94,86.6 196.99,86.55 197.46,86.55 197.5,86.52 197.5,85.68 198.16,85.02 198.16,83.8 197.88,83.52 196.15,83.52 196.03,83.65 196.03,85.73 195.74,86.01 193.63,86.01 193.54,86.11 193.54,87.66 193.68,87.8 194.2,87.8
1.35V_B+ on TOP (solid shape): 84.44,18 86.07,18 86.16,17.91 86.16,16.67 86.65,16.17 95.2,16.17 95.34,16.03 95.34,15.13 94.34,14.13 94.34,12.88 94.2,12.74 92.69,12.74 92.62,12.8 92.62,13.26 92.59,13.3 92.13,13.3 92.08,13.25 92.08,12.77 92.05,12.74 91.89,12.74 91.86,12.77 91.86,13.29 91.84,13.31 91.29,13.31 91.23,13.26 91.23,12.8 91.18,12.74 86.51,12.74 86.06,13.2 83.72,13.2 83.47,13.45 83.47,17.72 83.76,18.01 84.43,18.01
1.35V_FB on BOTTOM (solid shape): 76.24,16.31 76.24,16.22 76.18,16.16 75.07,16.16 74.7,15.79 74.7,14.85 74.28,14.42 74.28,13.28 74.01,13.01 72.89,13.01 72.88,13.02 71.66,13.02 71.58,13.1 71.58,15.27 71.67,15.36 72.3,15.36 72.47,15.19 72.47,14.67 72.89,14.25 73.62,14.25 74.09,14.72 74.09,15.55 74.91,16.36 76.19,16.36
+0.9V_LAN on TOP (solid shape): 205.15,121.96 205.15,119.84 205.45,119.54 205.45,119.33 205.34,119.22 204.49,119.22 204.36,119.35 204.36,119.64 204.43,119.71 204.43,122 204.47,122.04 205.07,122.04
+0.9V_LAN on BOTTOM (solid shape): 210.7,113.53 210.7,112.7 210.57,112.58 208.41,112.58 208.17,112.81 208.17,113.48 208.35,113.66 210.57,113.66
+0.9V_LAN on BOTTOM (solid shape): 210.34,110.9 210.34,109.99 209.31,108.96 208.46,108.96 208.35,109.07 208.35,109.62 207.97,110 207.97,110.86 208.09,110.99 208.37,110.99 208.49,110.87 209.8,110.87 209.93,111.01 210.23,111.01
+0.9V_LAN on IN4 (solid shape): outline of 408 points within 203.11,109.91 213.14,119.92
+0.675V_DDR_VTT on TOP (solid shape): 121.73,31.68 121.73,29.01 121.03,29.01 120.46,29.58 120.46,31.04 121.16,31.74 121.67,31.74
+0.675V_DDR_VTT on TOP (solid shape): 77.79,12.7 77.79,10.77 77.56,10.54 75.97,10.54 75.8,10.72 75.8,12.61 76.02,12.84 77.65,12.84
+0.675V_DDR_VTT on TOP (solid shape): 197.11,27.36 196.79,27.04 196.79,25.58 196.22,25.58 196.22,26.03 195.52,26.72 195.52,27.68 195.84,27.99 197.11,27.99
+0.675V_DDR_VTT on TOP (solid shape): 196.79,32.26 196.79,31.42 196.73,31.36 196.73,29.71 196.66,29.65 195.07,29.65 194.86,29.86 194.86,32.3 195,32.44 196.61,32.44
+0.675V_DDR_VTT on TOP (solid shape): 121.86,25.39 121.86,24.57 121.29,23.99 121.29,21.58 123.14,19.73 123.14,19.61 122.99,19.46 119.81,19.46 119.81,21.45 120.28,21.92 120.28,21.94 120.27,21.94 120.27,25.71 121.54,25.71
+0.675V_DDR_VTT on BOTTOM (solid shape): 121.69,25.66 121.69,23.12 121.49,22.91 120.4,22.91 120.25,23.07 120.25,25.58 120.47,25.81 121.54,25.81
+0.675V_DDR_VTT on BOTTOM (solid shape): 121.69,25.66 121.69,23.09 121.52,22.91 120.4,22.91 120.25,23.07 120.25,25.58 120.47,25.81 121.54,25.81
+0.675V_DDR_VTT on BOTTOM (solid shape): 196.44,33.06 196.44,30.96 197.3,30.1 197.3,23.23 197,22.94 196.36,22.94 196.22,23.08 196.22,26.17 194.97,27.41 194.97,30.48 195.4,30.92 195.66,30.92 195.96,31.22 195.96,33.02 196.09,33.15 196.34,33.15
+0.675V_DDR_VTT on BOTTOM (solid shape): 76.63,13.63 76.63,13.1 76.65,13.08 77.15,13.08 77.68,12.55 77.68,12.25 77.62,12.18 75.89,12.18 75.83,12.23 75.83,12.97 75.95,13.08 76.43,13.08 76.46,13.11 76.46,13.63 76.47,13.64 76.62,13.64
+0.675V_DDR_VTT on IN2 (solid shape): outline of 592 points within 119.29,20.9 197.08,31.16
+0.675V_P on BOTTOM (solid shape): 79.39,16.3 79.39,16.07 79.89,15.57 81.37,15.57 81.45,15.5 81.45,14.25 81.28,14.09 79.89,14.09 79.8,14 79.8,13.08 79.71,13 77.52,13 77.28,13.24 76.82,13.24 76.79,13.27 76.79,13.77 76.76,13.8 76.34,13.8 76.3,13.76 76.3,13.27 76.27,13.24 76.06,13.24 76.04,13.26 76.04,14.16 76.2,14.33 77.5,14.33 77.65,14.48 77.65,15.93 77.69,15.97 77.8,15.97 77.88,15.89 77.88,13.91 78.07,13.72 78.72,13.72 78.78,13.78 78.78,15.95 78.6,16.13 78.46,16.13 78.43,16.17 78.43,16.28 78.49,16.35 79.34,16.35
+1.2V_LDO on TOP (solid shape): 27.6,26.34 27.6,24.12 26.94,23.46 25.22,23.46 25.19,23.5 25.19,23.99 25.31,24.12 25.78,24.12 25.97,24.31 25.97,26.42 26.15,26.6 27.34,26.6
+1.2V_LDO on IN3 (solid shape): outline of 359 points within 18.35,12.91 27.42,27.05
+1.05V_M on TOP (solid shape): 88.8,76.12 88.8,75.01 88.68,74.89 88.06,74.89 87.29,74.12 86.95,74.12 86.82,74.24 86.82,75.84 87.25,76.27 88.65,76.27
+1.05V_M on TOP (solid shape): 132.8,77.32 132.8,76.84 132.88,76.76 133.87,76.76 134.22,76.42 134.5,76.42 134.61,76.3 134.61,75.95 134.62,75.95 134.62,75.71 134.49,75.58 134.03,75.58 133.44,76.18 130.92,76.18 130.8,76.3 130.45,76.3 130.3,76.46 130.3,76.81 130.41,76.92 131.83,76.92 132.29,77.38 132.75,77.38
+1.05V_M on TOP (solid shape): 136.67,103.25 136.67,101.68 136.31,101.32 135.32,101.32 135.07,101.07 135.07,100.47 133.62,99.03 133.12,99.03 133.03,99.08 133.04,99.18 132.66,99.71 132.52,99.07 132.56,99 132.53,98.92 132.4,98.78 132.4,98.25 132.35,98.2 131.65,98.2 131.64,98.23 131.48,98.41 131.24,98.45 130.64,99.05 130.64,101.74 130.88,101.98 132.18,101.98 132.4,101.76 133.05,101.76 133.27,101.98 134.47,101.98 134.8,102.31 134.8,103.24 135.03,103.47 136.45,103.47
+1.05V_M on BOTTOM (solid shape): 170.88,64.6 171.28,64.27 171.79,64.43 171.99,64.63 172.86,64.63 173.35,64.14 173.35,63.27 173.29,63.2 172.83,63.2 172.79,63.16 172.79,62.46 172.82,62.43 173.26,62.43 173.32,62.37 173.32,62.02 173.29,61.99 172.83,61.99 172.8,61.96 172.8,61.25 172.82,61.22 173.25,61.22 173.33,61.14 173.33,60.13 173.24,60.04 166.79,60.04 166.06,60.77 166.06,63.49 166.07,63.57 166.06,63.74 166.38,63.92 166.37,64.28 166.37,64.33 166.67,64.63 170.86,64.63
+1.05V_M on VCC: 148.57,59.3 148,59.87 145.4,59.87 144.13,61.14 134.92,61.14 132.02,64.04 132.02,66.83 130.16,68.7 129.33,68.7 128.65,69.37 128.65,73.67 128.84,73.86 128.84,74.51 128.86,74.58 128.84,74.61 128.84,76.91 130.03,78.1 135.05,78.1 135.96,79.01 135.96,83.9 149.29,97.23 149.29,98.58 145.66,102.21 132.48,102.21 132.48,98.71 131.99,98.23 124.65,98.23 124.65,107.09 122.85,108.89 146.34,108.89 151.55,103.69 156.93,103.69 158.94,101.68 158.94,79.01 160.72,77.23 160.72,75.15 158.49,72.92 158.49,70.85 159.18,70.16 167.92,70.16 170.94,67.13 170.94,62.64 170.25,61.94 170.25,59.3
+1.05V_MODPHY on TOP (solid shape): 132.91,106.86 132.91,104.82 132.69,104.6 132.69,103.51 133.16,103.04 133.16,102.85 133.1,102.75 133.07,102.63 133.07,102.61 133.04,102.58 133.04,102.06 132.9,101.92 132.62,101.92 132.43,102.11 130.83,102.11 130.51,101.79 130.51,99.48 130.18,99.15 129.5,99.15 129.21,99.44 129.21,100.33 129.24,100.36 129.74,100.36 129.75,100.37 129.75,100.86 129.74,100.87 129.23,100.87 129.2,100.9 129.2,101.44 129.53,101.77 129.53,102.67 129.74,102.88 129.74,102.88 130.67,103.55 131.38,104.45 131.48,104.64 131.57,104.82 131.57,104.84 131.88,105.93 131.87,107.05 132.72,107.05
+1.05V_MODPHY on BOTTOM (solid shape): 137.49,99.88 137.49,99.32 137.53,99.28 137.53,98.59 137.39,98.44 135.72,98.44 135.65,98.52 135.65,99.88 135.68,99.91 137.46,99.91
+1.05V_MODPHY on BOTTOM (solid shape): 133.04,102.87 133.04,102.44 133.3,102.19 134.05,102.19 134.19,102.05 134.19,100.48 133.99,100.27 132.67,100.27 132.54,100.4 132.54,102.93 132.59,102.97 132.94,102.97
+1.05V_MODPHY on IN2 (solid shape): 136.43,102.4 136.43,98.93 136.58,98.78 136.58,98.4 136.47,98.29 135.18,98.29 134.83,98.64 134.83,99.51 134.88,99.59 134.96,99.61 135.4,100.07 134.77,100.16 134.7,100.12 134.62,100.15 132.85,101.92 132.51,101.92 132.51,102.83 132.66,102.98 135.85,102.98
+1.05V_MODPHY_PCH on TOP (solid shape): 129.02,101.18 129.02,100.71 129.05,100.69 129.57,100.69 129.58,100.67 129.58,100.54 129.57,100.53 129.04,100.53 129.03,100.52 129.03,99.26 128.77,99 128.25,99 128.16,99.09 128.16,101.02 128.35,101.21 129,101.21
+1.05V_MODPHY_PCH on BOTTOM (solid shape): 134.04,84.58 134.04,84.1 133.99,83.85 134.17,83.68 134.2,83.67 134.2,83.52 133.94,83.26 133.88,83.24 133.47,83.24 133.46,83.24 133.31,83.27 133.18,83.22 133.1,83.15 133.06,83.05 133.06,83.04 132.99,82.98 132.99,82.77 132.8,82.58 132.4,82.58 132.3,82.68 132.3,82.97 132.72,83.39 132.72,83.46 132.76,83.49 132.76,83.77 133.21,84.23 133.21,84.53 133.33,84.65 133.97,84.65
+1.05V_MODPHY_PCH on IN2 (solid shape): outline of 1901 points within 128.17,82 136.21,101.2
