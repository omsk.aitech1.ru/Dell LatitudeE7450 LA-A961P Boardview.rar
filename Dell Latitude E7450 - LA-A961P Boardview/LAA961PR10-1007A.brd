# Allegro board LAA961PR10-1007A.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+3.3V_WLAN: length 116.7
  IN2 w1.016: 191.14,90.1 192.03,89.21 193.93,89.21 194.71,88.43 194.71,79.38 192.13,76.8 192.13,72.03 193.45,70.7 193.45,70.22 194.86,68.81 194.86,66.98 195.76,66.08 195.76,57.83 194.88,56.95 191.96,56.95 190.71,55.69 190.71,53.91 189.61,52.82 188.03,52.82
  IN3 w1.016: 169.67,90.03 167.01,90.03 164.28,92.76 162.56,92.76 ; 188.72,89.53 187.96,88.76 174.31,88.76 172.98,90.1 172.02,90.1
  IN4 w1.016: 189.68,52.91 190.43,53.67 190.43,54.96 191.07,55.59 191.61,55.59 192.89,56.87 192.89,57.84 194.23,59.18 194.23,64.36 ; 190.93,90.35 191.4,90.35 192.14,89.61 192.14,87.24 191.14,86.24 191.14,85.49 190.4,84.75 190.4,80.75 191.61,79.54 191.61,72.6 192.98,71.24 192.98,68.08 193.94,67.12
  BOTTOM w0.381: QZ2.5 QZ2.2
  BOTTOM w0.508: RZ15.2 v2(162.77,90.47)
  vias: v2(162.12,91.75) v2(162.94,91.88) v2(170.63,90.29) v2(171.07,89.91) v2(187.77,51.93) v2(187.92,51.36) v2(188.41,51.93) v2(188.56,51.36) v2(189.5,90.19) v2(189.92,90.69) v2(191.52,91.75) v2(191.71,91.18) v3(190.31,91.85)
+3.3V_WLAN_UZ2:
  vias: v1(187.47,46.36)
+3.3V_WWAN: length 158.1
  IN2 w0.508: v2(218.63,114.1) 219.52,113.21 219.52,111.83 220.86,110.49 220.86,105.29 222.05,104.09 222.05,93.34 223.59,91.8 223.59,89.53 225.1,88.01 225.1,85.34 226.57,83.87 226.57,79.58 225.72,78.73 225.72,74.15 225.98,73.89 225.98,68.96 223.65,66.63 v2(223.65,66.6)
  IN3 w0.508: v2(126.42,120.81) 126.42,120.47 126.82,120.07 132.68,120.07 133.41,120.8 138.32,120.8 141.25,123.73 151.67,123.73 153.16,122.24 168.58,122.24 170.39,120.44 182.2,120.44 186.1,116.54 186.1,114.47 186.8,113.77 197.53,113.77 198.84,112.45 212.66,112.45 213.17,111.94 216.76,111.94 217.43,112.6 217.43,112.89 v2(218.63,114.1)
  BOTTOM w0.457: RZ37.2 206.81,55.69 QZ11.2
  BOTTOM w0.508: v2(126.42,120.81) JANT1.1 JANT1.2 ; RZ37.2 RZ39.1 207.77,56.05 v2(208.26,56.53)
  vias: v2(192.79,51.62) v2(193.36,51.93) v2(193.36,51.3) v2(194,51.93) v2(194,51.3) v2(218.25,60.84) v2(218.72,61.27) v3(193.77,52.45)
+3.3V_WWAN_UZ2: length 2.4
  TOP w0.102: 193.84,46.05 193.84,45.04 194.05,44.83 194.68,44.83 v1(195.04,44.48)
+3V5V_PWR_SRC:
  vias: v2(38.74,13.62) v2(38.74,12.83) v2(39.39,13.63) v2(39.39,12.84) v2(40.01,13.63) v2(40.01,12.84) v2(40.6,13.63) v2(40.6,12.84) v2(41.24,13.62) v2(41.24,12.83) v2(45.21,21.33) v3(37.4,14.85)
+5V_ALW: length 394.3
  TOP w0.102: v2(164.91,77.74) 164.51,77.33 164.51,76.89 v3(164.81,76.58)
  TOP w0.203: UZ7.4 131.3,97.51 v2(131.3,97.51) ; UL3.4 193.69,108.39 v2(193.57,108.51) ; v2(192.2,43.49) UZ2.4 ; v2(203.01,34.53) UZ8.4
  TOP w0.254: UI3.1 59.65,117.46 60.05,117.06 60.94,117.06 CI13.1
  TOP w0.381: PU1.5 69.31,119.62 v2(69.47,119.79)
  TOP w0.457: v2(199.01,121.72) 199.01,121.38 197.54,119.9 197.54,119.89 197.46,119.81 197.46,119.6 QZ12.3
  TOP w0.508: v2(194.38,77.66) 194.12,77.66 192.73,79.06 192.73,80.32 RZ21.1 191.54,82.06 191.54,83.58 192.24,84.28 192.24,84.56 192.97,85.28 192.97,87.8 192.29,88.47 192.29,90.14 192.97,90.81 192.97,91.42 193.55,92 v3(193.55,98.97) 193.55,101.34 192.31,102.58 192.31,104.18 191.12,105.36 191.12,106.94 192.69,108.51 v2(193.57,108.51) ; CI13.1 61.88,116.12 RI13.2 ; PR843.2 18.04,41.53 16.51,40 v2(16.51,39.87) ; RZ5.1 166.6,77.84 166.28,77.52 165.13,77.52 v2(164.91,77.74) ; v2(196.2,115.41) 195.94,115.67 195.94,118.07 QZ12.3 ; v2(199.01,121.72) 197.83,122.9 QZ9.3 ; v2(74.05,116.89) PR11.1 ; v2(68.73,19.94) 68.73,20.81 69.34,21.42 72.15,21.42 72.91,20.65 PR202.1 72.91,19.23 73.54,18.61 75.01,18.61 75.5,19.1 PR204.2 ; RD9.1 93.87,9.95 93.64,10.18 93.64,10.33 v2(93.6,10.37)
  IN1 w0.508: v2(193.57,108.51) 193.9,108.51 195.24,107.17 205.01,107.17 v2(206.28,105.9) ; v2(203.01,34.53) 204.41,35.93 204.41,39.11 201.59,41.93 192.85,41.93 192.2,42.57 v2(192.2,43.49) ; v2(72.33,94.49) 78.06,94.49 81.36,97.79 v2(82.97,97.79) ; v2(113.96,119.13) 113.96,119.64 113.49,120.11 108.55,120.11 107.66,119.22 77.13,119.22 74.8,116.89 74.04,116.89 v2(74.05,116.89)
  IN2 w0.508: v2(196.2,115.41) 195.66,115.95 192.69,115.95 191.07,114.34 191.07,109.53 192.1,108.51 v2(193.57,108.51) ; v2(165.72,100.03) 165.72,99.1 166.82,98.01 166.82,93.05 166.05,92.28 166.05,88.71 164.9,87.56 164.9,84.92 165.8,84.01 165.8,81.09 165.38,80.67 165.38,78.21 v2(164.91,77.74) ; v2(207.83,34.83) 207.53,34.53 v2(203.01,34.53)
  IN3 w0.457: v2(138.95,100.46) 138.95,100.9 139.39,101.34
  IN3 w0.508: 145.16,101.34 139.39,101.34 ; 145.16,101.34 145.1,101.27 145.1,99.88 142.95,97.73 132.72,97.73 132.51,97.51 v2(131.3,97.51) ; 145.16,101.34 154.29,101.34 154.87,100.77 v2(154.87,100.38) 157.61,100.38 158.12,100.89 164.86,100.89 v2(165.72,100.03)
  IN4 w0.508: v2(193.57,108.51) 193.08,108.99 189.57,108.99 188.94,109.63 177.44,109.63 174.36,106.54 172.42,106.54 170.33,104.46 170.33,102.4 168.82,100.89 166.33,100.89 165.72,100.28 v2(165.72,100.03) ; v2(16.51,39.87) 16.32,39.68 16.32,35.3 17.27,34.34 17.27,26.34 17.78,25.84 17.78,25.14 18.29,24.63 21.47,24.63 22.42,23.68 30.74,23.68 33.34,26.28 37.71,26.28 39.74,28.31 43.21,28.31 44.16,27.36 49.72,27.36 56.33,20.76 66.63,20.76 v2(67.45,19.93)
  BOTTOM w0.508: 67.03,17.71 65.96,16.64 65.96,13.57 66.32,13.21 66.32,10.99 67.41,9.9 76.29,9.9 77.23,8.96 92.19,8.96 v2(93.6,10.37) ; v2(194.38,77.66) PC400.1 ; JLED1.1 116.01,119.4 115.6,119.82 114.53,119.82 113.96,119.24 v2(113.96,119.13) ; PR526.2 83.39,98.21 v2(82.97,97.79)
  vias: v2(58.52,118.9) v2(58.52,118.32) v2(58.77,59.67) v2(58.77,59.08) v2(59.11,118.9) v2(59.11,118.32) v2(59.16,67.66) v2(59.17,67.06) v2(59.29,60) v2(59.29,59.36) v2(59.69,67.9) v2(59.71,67.3) v2(63.01,121.86) v2(63.01,121.26) v2(63.63,121.92) v2(63.63,121.29) v2(67.49,19.31) v2(67.5,18.71) v2(67.49,18.11) v2(68.09,19.92) v2(68.09,19.33) v2(68.11,18.72) v2(68.1,18.08) v2(68.72,19.33) v2(68.75,18.72) v2(68.73,18.08) v2(211.15,28.38) v2(211.15,27.74) v2(211.15,27.11) v2(211.15,26.47) v2(211.79,28.38) v2(211.79,27.74) v2(211.79,27.11) v2(211.79,26.47) v2(212.42,28.38) v2(212.42,27.74) v2(214.61,9.49) v2(214.61,8.86) v2(214.61,8.22) v2(215.24,10.13) v2(215.24,9.49) v2(215.24,8.86) v2(215.24,8.22) v2(215.88,10.13) v2(215.88,9.49) v2(215.88,8.86) v2(215.88,8.22) v2(219.78,62.23) v2(219.78,61.65) v2(219.78,60.95) v2(219.78,60.35) v2(220.89,94.96) v2(220.89,94.26) v2(221.4,94.58) v2(221.4,93.88) v2(224.82,94.96) v2(224.82,94.26) v2(225.33,94.58) v2(225.33,93.88) v2(241.67,119.33) v2(242.05,119.78) v2(242.34,120.31) v2(266.98,130.31) v2(266.98,129.67) v2(267.62,130.31) v2(267.62,129.67) v3(59.57,60.56)
+5V_ALW2: length 1.8
  TOP w0.102: PC118.1 46.89,22.03 47.35,21.57 v1(48.28,21.57)
+5V_ALW_U41: length 4
  TOP w0.102: v1(191.89,80.18) 191.24,80.83 CZ35.1
  TOP w0.381: UZ5.1 190.68,82.11 RZ21.2 190.35,80.85 CZ35.1
+5V_ALWP: length 43.5
  TOP w0.254: v2(64.76,20.12) 63.77,21.11 55.9,21.11 54.09,22.91 v1(54.09,25.77) 54.09,29.91 52.59,31.41 50.26,31.41 49.44,30.6 PR101.2
  TOP w0.508: v2(64.72,18.44) 57.42,18.44 53.7,22.16 47.96,22.16
+5V_HDD: length 0.8
  TOP w0.508: RN1.1 213.41,110.87 v2(213.93,110.35)
  vias: v1(216.96,109.96)
+5V_RUN: length 359.3
  TOP w0.305: CZ10.1 223.21,47.72 222.8,47.31 JUSH1.7 ; JKBTP1.5 199.35,55.64 198.49,56.51 CZ29.1
  TOP w0.508: v2(197.82,57.59) 197.96,57.45 197.96,57.43 CZ29.1 ; v2(238.32,132.91) QV501.2 ; CZ10.1 223.21,49.75 221.77,51.18 221.77,53.93 221.91,54.07 221.91,56.62 v2(222.19,56.9)
  IN1 w0.508: v2(222.19,56.9) 221.83,56.9 220.23,58.5 217.49,58.5 v2(216.54,59.45) ; v2(85.28,113.66) 85.31,113.63 94.47,113.63 94.94,114.1 97.13,114.1 97.64,113.59 98.72,113.59 v2(100,112.31)
  IN2 w0.508: v2(238.32,132.91) 239.14,132.09 239.14,127.19 236.98,125.02 230.18,125.02 226.14,120.98 221.67,120.98 220.53,119.84 218.56,119.84 217.5,118.78 217.5,115.55 217.98,115.07 217.98,113.75 218.76,112.97 218.76,111.88 217.43,110.54 217.43,109.02 217.63,108.82 v2(217.63,106.89) ; v2(197.82,57.59) 197.81,57.59 196.65,58.74 196.65,66.45 195.8,67.3 195.8,69.19 194.82,70.17 194.82,73.65 194.03,74.44 194.03,76.36 195.68,78.01 195.68,88.71 194.48,89.91 194.48,91.77 194.19,92.07 194.19,93.76 v2(195.03,94.61)
  IN2 w1.524: 100.02,126.1 100.02,122.48 96.14,118.61 86.05,118.61 84.52,117.08 84.52,114.61 ; 84.14,112.2 84.11,112.2 84.11,108.17 81.08,105.13 81.08,89.11 79.97,88
  IN3 w1.524: 69.46,57.1 69.48,57.08 80.18,57.08 81.96,58.86 92.5,58.86 106.85,44.5 175.85,44.5 182.63,37.72 192.78,37.72
  IN3 w2.032: 57.05,63.14 57.05,67.72 66.56,77.23 69.45,77.23 73.07,80.85 73.07,83.73 76.69,87.36 76.69,87.65
  IN4 w0.508: v2(201.55,42.54) 199.77,42.54 198.78,43.53 198.78,51.59 196.93,53.44 196.93,56.7 v2(197.82,57.59)
  vias: v2(52.87,55.55) v2(52.9,56.2) v2(53.56,56.19) v2(53.55,55.54) v2(54.21,56.2) v2(54.22,55.57) v2(54.84,56.19) v2(54.85,55.55) v2(77.12,88.04) v2(77.55,88.5) v2(77.61,87.6) v2(78.04,88.05) v2(85.28,113.02) v2(99.49,127.37) v2(100.13,127.37) v2(100.65,112.26) v2(121.67,124.27) v2(122.09,124.74) v2(193.98,37.96) v2(194.59,37.96) v2(195.03,95.88) v2(195.03,95.24) v2(195.23,37.96) v2(201.44,40.82) v2(201.83,40.39) v2(202.21,39.94) v2(216.41,60.13) v2(216.99,106.87) v3(203.79,39.97)
+5V_RUN_AUDIO: length 45.1
  TOP w0.508: RA39.1 201.37,81.32 202.38,80.32 202.38,78.79 v2(202.57,78.6)
  IN2 w0.508: v2(213.62,60.85) 214.58,60.85 216.46,62.73 216.46,63.77 218.82,66.13 220.51,66.13 222.34,67.96 222.34,74.71 v2(221.43,75.62)
  IN3 w0.508: v2(221.43,75.62) 220.67,75.62 219.36,76.93 210.43,76.93 209.64,76.14 204.93,76.14 202.57,78.5 v2(202.57,78.6)
  vias: v1(212.26,60.93)
+5V_RUN_PVDD: length 11.1
  TOP w0.203: UA1.41 207.08,74.33 207.51,74.75 207.51,75.15 207.65,75.29 v2(207.65,75.52) 207.55,75.62 CA45.1 ; UA1.46 205.08,74.34 204.75,74.67 204.75,74.92 204.35,75.33 v2(204.22,75.33)
  TOP w0.254: CA47.1 203.1,75.72 203.49,75.33 v2(204.22,75.33)
  BOTTOM w0.457: v2(204.22,75.33) 204.22,75.43 204.93,76.14 207.34,76.14 207.65,75.84 v2(207.65,75.52)
  vias: v1(200.73,78.34)
+5V_RUN_UZ9: length 0.5
  BOTTOM w0.102: v2(56.07,58.6) v1(56.62,58.6)
  vias: v2(53.3,58.04) v2(54.04,58.04) v2(54.73,58.63) v2(54.73,58.04) v2(55.46,58.63) v2(55.46,58.04) v2(56.12,58.02)
+5V_TSP: length 24.1
  BOTTOM w0.254: CZ2.1 JEDP1.1
  BOTTOM w0.508: CZ2.1 106.9,114.39 108.47,115.97 110.09,115.97 110.66,116.54 110.66,120.83 112.19,122.37 116.68,122.37 v1(117.3,121.75) 118.4,120.64 QV8.1
+5V_USB_CHG_PWR: length 0.7
  TOP w0.102: v2(69.56,123.23) v3(69.56,123.97)
  vias: v2(58.46,122.19) v2(58.46,121.56) v2(59.1,122.19) v2(59.1,121.56) v2(68.93,123.23) v2(68.93,122.6) v2(69.56,122.6)
+GND_CHASSIS:
  vias: v1(274.31,121.87) v2(265.94,123.24) v2(265.94,122.66)
+V1.05S_APLLOPI: length 36
  TOP w0.508: v2(126.76,79.18) 126.89,79.31 CC68.1
  IN2 w0.508: v2(126.76,79.18) 126.05,79.89 126.05,94.94 125.66,95.33 v2(125.66,96.75)
  IN3 w0.508: v2(125.66,96.75) 126.28,97.38 128.37,97.38 129.9,98.91 129.9,100.04 130.57,100.71 134.3,100.71 v2(135.06,99.95)
  BOTTOM w0.254: UC1.AA21 127.13,78.81 v2(126.76,79.18) 127.13,79.55 UC1.W21
  BOTTOM w0.508: LC3.2 135.03,99.99 v2(135.06,99.95) ; v2(125.66,96.75) 125.66,97.44 v1(125.57,97.53) 124.68,98.42 CC67.1
+V1.05SP_B+: length 2.6
  BOTTOM w0.127: PJP302.2 v1(194.93,71.32)
  vias: v2(194,68.39)
+VCC_CORE: length 55.4
  TOP w0.508: v2(122.27,102.25) 122.49,102.48 CC79.2
  BOTTOM w0.089: UC1.G25 123.93,86.98 123.93,87.18 ; UC1.G25 124.4,86.52 ; UC1.G25 123.93,86.64 123.93,86.54 ; UC1.G25 124.4,87.11 ; 110.15,87.11 UC1.G47 110.15,86.52 ; UC1.F36 116.98,87.43 ; UC1.F36 117.56,86.84 ; UC1.F36 116.98,86.84 ; UC1.F36 117.56,87.43 ; UC1.K23 125.8,84.46 UC1.L22 125.8,83.65 UC1.M23 ; UC1.K23 125.41,84.46 125.27,84.32 ; UC1.K23 125.7,84.14 ; 103.87,87.11 103.87,86.99 UC1.G57 ; UC1.G45 111.42,86.96 111.42,87.11 ; UC1.G45 111.86,87.11 ; UC1.G45 111.86,86.52 ; UC1.G45 111.42,86.67 111.42,86.54 ; 123.11,86.54 123.11,86.68 UC1.G27 ; 115.06,87.43 UC1.F40 ; UC1.F40 115.06,86.84 ; UC1.F40 114.47,86.84 ; UC1.F40 114.47,87.43 ; UC1.F52 106.95,87.43 ; UC1.F52 107.53,87.43 ; UC1.F52 107.53,86.84 ; UC1.F52 106.95,86.84 ; UC1.F48 109.46,87.43 ; UC1.F48 110.04,87.43 ; UC1.F48 110.04,86.84 ; UC1.F48 109.46,86.84 ; 121.89,86.52 UC1.G29 ; UC1.G29 121.89,87.11 ; UC1.G29 121.39,87.02 121.39,87.11 ; UC1.G29 121.46,86.67 121.46,86.54 ; UC1.H23 125.84,86.23 125.84,86.41 ; UC1.H23 125.41,85.8 ; UC1.H23 125.41,86.38 ; UC1.H23 125.84,85.95 125.84,85.78 ; UC1.G51 108.06,86.69 108.06,86.54 ; UC1.G51 107.64,86.52 ; UC1.G51 107.64,87.11 ; UC1.G51 108.12,87 108.12,87.11 ; 113.9,86.54 113.9,86.64 UC1.G41 ; 105.03,86.84 UC1.F56 ; UC1.F56 104.44,87.43 ; UC1.F56 105.03,87.43 ; UC1.F56 104.44,86.84 ; 112.55,87.43 UC1.F44 ; UC1.F44 111.96,86.84 ; UC1.F44 111.96,87.43 ; UC1.F44 112.55,86.84 ; 119.38,86.52 UC1.G33 ; UC1.G33 118.92,86.98 118.92,87.11 ; UC1.G33 118.92,86.64 118.92,86.54 ; UC1.G33 119.38,87.11 ; 125.33,85.14 125.57,85.14 UC1.J23 ; 122.58,87.43 UC1.F28 ; UC1.F28 121.99,87.43 ; UC1.F28 122.58,86.84 ; UC1.F28 121.99,86.84 ; UC1.F32 119.49,86.84 ; UC1.F32 120.07,87.43 ; UC1.F32 119.49,87.43 ; UC1.F32 120.07,86.84 ; 116.44,86.54 116.44,86.67 UC1.G37 ; UC1.G27 122.68,86.52 ; UC1.G27 123.17,87.01 123.17,87.18 ; UC1.G27 122.68,87.11 ; UC1.G39 115.16,86.52 ; UC1.G39 115.61,86.65 115.61,86.54 ; UC1.G39 115.68,87.04 ; UC1.G39 115.16,87.11 ; UC1.G23 125.78,86.52 ; UC1.G23 125.78,87.11 ; UC1.G23 125.19,87.11 ; UC1.G23 125.19,86.52 ; UC1.F24 124.5,86.84 ; UC1.F24 125.09,86.84 ; UC1.F24 124.5,87.43 ; UC1.F24 125.09,87.43 ; 125.84,85.59 125.84,85.41 UC1.J23 ; UC1.G37 116.87,87.11 ; UC1.G37 116.38,87.02 116.38,87.11 ; UC1.G37 116.87,86.52 ; UC1.G43 112.65,86.52 ; UC1.G43 113.07,86.69 113.07,86.54 ; UC1.G43 113.14,87.01 113.14,87.11 ; UC1.G43 112.65,87.11 ; 108.88,87.18 108.88,86.99 UC1.G49 ; 104.34,86.52 UC1.G57 ; UC1.G57 103.75,86.52 ; UC1.G57 104.34,87.11 ; 109.35,86.52 UC1.G49 ; UC1.G49 108.88,86.64 108.88,86.54 ; UC1.G49 109.35,87.11 ; 114.37,86.52 UC1.G41 ; UC1.G41 114.37,87.11 ; UC1.G41 113.9,86.99 113.9,87.11 ; UC1.G35 117.67,86.52 ; UC1.G35 117.67,87.11 ; UC1.G35 118.15,87.01 118.15,87.11 ; UC1.G35 118.09,86.68 118.09,86.54 ; UC1.G53 106.84,87.11 ; UC1.G53 106.41,86.67 106.41,86.54 ; UC1.G53 106.34,87.02 106.34,87.11 ; UC1.G53 106.84,86.52 ; UC1.M23 125.36,83.65 125.33,83.68 ; UC1.M23 125.7,83.99 ; UC1.G55 105.58,86.66 105.58,86.54 ; UC1.G55 105.58,86.97 105.58,87.11 ; UC1.G55 105.13,87.11 ; UC1.G55 105.13,86.52 ; UC1.J23 125.7,85.28 125.46,85.53 ; 120.63,86.54 120.63,86.65 UC1.G31 ; UC1.G31 120.18,87.11 ; UC1.G31 120.69,87.04 ; UC1.G31 120.18,86.52
  BOTTOM w0.254: v2(102.49,87.2) 102.79,86.91 UC1.F59
  BOTTOM w0.508: v2(123.61,106.71) 123.61,106.82 123.38,107.05 123.38,110.42 124.15,111.18 CC84.2
  vias: v2(98.83,105.03) v2(98.83,102.87) v2(98.83,100.71) v2(98.83,98.56) v2(99.38,96.16) v2(101.16,105.02) v2(101.16,102.86) v2(101.16,100.7) v2(101.16,98.54) v2(101.84,82.71) v2(102.19,105.03) v2(102.19,102.87) v2(102.19,100.71) v2(102.19,98.56) v2(102.49,84.21) v2(102.49,81.21) v2(102.49,78.21) v2(103.14,79.71) v2(103.14,78.21) v2(103.99,77.63) v2(104.35,86.2) v2(104.31,83.49) v2(104.31,82.19) v2(104.31,80.89) v2(104.31,79.58) v2(104.31,78.28) v2(104.45,105.03) v2(104.43,102.86) v2(104.43,100.7) v2(104.47,98.47) v2(104.53,84.79) v2(104.87,87.74) v2(105.42,86.2) v2(105.5,105.03) v2(105.5,102.87) v2(105.5,100.71) v2(105.54,98.47) v2(106.55,86.2) v2(107.38,87.74) v2(107.76,105.02) v2(107.76,102.86) v2(107.76,100.7) v2(107.76,98.5) v2(107.93,86.2) v2(108.8,105.03) v2(108.8,102.87) v2(108.8,100.71) v2(108.8,98.56) v2(109.06,86.2) v2(109.88,87.74) v2(110.44,86.2) v2(111.57,86.2) v2(112.11,105.03) v2(112.11,102.87) v2(112.11,100.71) v2(112.11,98.47) v2(112.39,87.74) v2(112.95,86.2) v2(114.07,86.2) v2(114.9,87.74) v2(115.34,105.03) v2(115.34,100.71) v2(115.47,102.87) v2(115.45,86.2) v2(116.58,86.2) v2(117.41,87.74) v2(117.96,86.2) v2(118.68,107.18) v2(118.7,106.48) v2(118.71,105.03) v2(118.71,102.87) v2(118.71,100.71) v2(119.09,86.2) v2(119.91,87.74) v2(120.47,86.2) v2(121.6,86.2) v2(122.26,101.64) v2(122.26,100.99) v2(122.26,100.36) v2(122.26,99.74) v2(122.42,87.74) v2(122.98,86.2) v2(124.1,86.2) v3(118.62,98.42) v4(108.66,111.36) v4(108.65,110.68) v4(108.7,112.07) v4(109.45,112.07) v4(109.4,110.68) v4(110.12,111.34) v4(110.24,105.93) v4(110.72,112.09) v4(110.81,110.72) v4(110.96,106.48) v4(111.71,105.98) v4(111.94,111.32) v4(112.02,112.07) v4(112.56,108.7) v4(112.58,110.34) v4(112.6,109.53) v4(112.6,108) v4(112.6,107.23) v4(112.89,112.09) v4(112.91,111.31) v4(113.01,106.06) v4(113.36,109.53) v4(113.41,110.37) v4(113.38,108.73) v4(113.44,108) v4(113.39,107.17)
+VCC_PWR_SRC: length 13.8
  TOP w0.127: PC517.1 v1(91.56,107.01)
  TOP w0.508: v2(95.44,102.04) 95.07,101.67 PR518.1
  IN2 w0.508: v2(95.44,102.04) 95.44,107.09 v4(94.72,107.81)
  BOTTOM w0.508: PR511.1 94.06,97.27 95.44,98.66 v2(95.44,102.04)
  vias: v4(92.6,107.81) v4(93.23,107.81) v4(94.02,107.81)
+VCCIO_OUT: length 7.1
  TOP w0.508: RC196.1 100.55,94.95 100.75,94.95 101.72,93.98 v2(101.72,93.34)
  BOTTOM w0.089: v2(101.72,93.34) v1(101.72,93.88)
  BOTTOM w0.254: UC1.A59 102.92,90.67 101.72,91.86 v2(101.72,93.34)
+VCCIOA_OUT: length 5.2
  TOP w0.089: RC133.1 v1(125.49,85.33)
  TOP w0.508: RC133.1 126.11,85.77 126.11,87.3 126.8,87.99 v2(127.21,87.99)
  BOTTOM w0.254: UC1.E20 127.3,87.99 v2(127.21,87.99)
+VDDA_AVDD1: length 5.7
  TOP w0.508: LA5.1 216.75,65.04 215.53,66.26 215.53,67.05 v1(214.86,67.72) 214.44,68.14 214,68.14
+VDDA_PVDD: length 6.9
  TOP w0.127: RA4.2 215.31,75.76 215.94,75.12 v1(215.94,74.88)
  TOP w0.178: UA1.38 208.28,74.21 208.36,74.3 208.92,74.86 209.48,74.86 209.67,75.05 210.91,75.05 211.1,75.24 211.98,75.24 CA17.1
GND: length 3601.4
  TOP w0.203: UV7.35 125.87,116.78 125.79,116.69 v2(124.75,116.69) 124.75,116.71 126.02,117.98 UV7.38 ; UV600.19 137.61,113.51 v2(137.61,113.51) ; v2(192.2,47.03) UZ2.11 ; v2(201.23,34.53) UZ8.11 ; v2(130.1,132.88) 130.13,132.84 UI4.21 ; UI4.11 131.73,128.69 132.45,127.97 CI416.2 ; UV600.52 142.42,121.88 142.73,122.19 143,122.19 v2(143.27,121.92) ; v2(135.17,97.05) 134.7,97.51 UZ7.11 UZ7.15 ; UV600.11 140.2,116.71 v2(140.4,116.51) ; UI4.28 126.4,131.32 125.94,131.78 v2(125.87,131.78) ; v2(124.87,115.61) 124.87,114.39 125.13,114.13 UV7.26 ; UZ9.11 v2(55.15,60.73) ; v2(197.25,108.42) 197.21,108.39 UL3.11 ; v2(123.33,116.98) 123.33,117.25 125.93,119.85 UV7.43
  TOP w0.254: PU800.32 17.35,35.54 v2(17.12,35.77) ; v2(64.15,71.63) 63.6,71.08 UC7.7 ; RI14.1 57.4,120.5 UI3.14 ; UI7.21 v2(224.9,84.56) ; RPE10.6 205.87,104.89 v2(206.19,105.21) 206.37,105.03 RPE10.5 ; RPE10.8 204.87,104.97 v2(205.11,105.21) 205.37,104.95 RPE10.7 ; PU800.14 24.72,35.54 v2(24.78,35.47) ; v2(66.28,124.82) 66.17,124.7 66.17,122.91 DI1.3 ; PU800.5 v2(20.91,31.69) ; v2(223.88,117.9) 223.88,117.49 223.75,117.36 UN1.5 ; v2(68.33,45.2) 68.25,45.28 JXDP1.49 ; v2(21.22,39.92) 21.22,39.73 20.91,39.41 PU800.23 ; UN1.15 221.88,114.34 v2(222.13,114.1) 222.38,114.36 UN1.16 ; UI7.10 v2(224.9,78.72)
  TOP w0.279: JXDP1.8 57.75,51.14 v2(57.53,50.92) ; v2(62.5,54.17) 62.25,53.93 JXDP1.26 ; JXDP1.50 v2(68.25,51.04) ; JXDP1.37 v2(65.25,48.38) ; v2(61.2,54.16) 61.03,54.16 60.75,53.88 JXDP1.20 ; v2(61.15,45.27) 60.75,45.67 JXDP1.19 ; v2(63.99,48.32) 63.75,48.08 JXDP1.31 ; JXDP1.13 59.25,45.64 59.67,45.23 v2(60.39,45.23) ; v2(62.52,45.42) 62.25,45.69 JXDP1.25 ; v2(65.25,51.04) JXDP1.38 ; v2(57.82,45.33) 57.75,45.4 JXDP1.7 ; JXDP1.14 v2(59.25,54.09) ; JXDP1.59 70.75,48.41 v2(70.87,48.53) ; JXDP1.1 v2(56.25,45.27) ; JXDP1.32 63.75,54.05 64.12,54.41 v2(64.12,54.41) ; JXDP1.2 v2(56.25,54.09)
  TOP w0.305: UE2.B54 202.62,87.87 202.83,88.09 v2(202.83,88.31) ; v2(209.51,93.05) 209.91,93.05 209.96,93 UE2.B11 ; UE2.B60 205.63,87.41 v2(205.63,88.19) ; JAPS1.12 v2(219.8,103.7) ; v2(208.62,88.25) UE2.B66 ; JUSH1.3 224.8,45.78 v2(225.01,45.99) 225.3,45.7 JUSH1.2 ; UE2.B18 209.62,96 v2(209.55,95.94) ; JIO1.14 219.7,65.7 219.7,65.7 ; UN1.12 219.76,115.86 v2(219.59,115.69) 219.91,115.36 UN1.13 ; v2(219.46,116.86) UN1.10 ; 188.85,80.89 188.41,80.89 188.25,80.74 JDEG1.10 ; JAPS1.10 221.06,102.7 v2(221.44,102.33) 221.44,102.04 221.11,101.7 JAPS1.8 ; v2(219.78,67.5) 219.97,67.5 220.27,67.2 JIO1.17 ; JKBTP1.16 204.85,55.62 205.3,56.06 205.3,56.53 v2(205.12,56.71) 205.12,56.56 204.35,55.79 JKBTP1.15 ; v2(222.02,63.1) 221.76,63.1 221.66,63.2 220.7,63.2 JIO1.9 ; JKBTP1.9 201.35,54.42 v2(201.5,54.27) ; JAPS1.14 v2(219.8,104.7) ; JUSH1.20 216.3,44.11 216.08,43.89 215.15,43.89 v2(214.62,44.43) ; JKBTP1.2 197.85,55.64 v2(198.14,55.92) 198.35,55.7 JKBTP1.3 ; v2(182.62,97.79) 182.94,97.48 UE1.B27 ; JUSH1.17 217.8,44.13 v2(218.35,43.58)
  TOP w0.356: UC8.3 77.3,79.21 77.9,79.81 78.43,79.81 v2(78.55,79.68)
  TOP w0.381: PQ817.4 11.78,24.55 11.78,25.44 v2(11.47,25.75) ; 164.63,80.83 164.35,80.54 QZ10.1 ; UV502.7 240.44,118.66 v2(240.29,118.51) ; PQ806.1 10.1,37.15 v2(9.88,37.37) ; CZ5.2 180.57,54.6 UZ1.11 ; v2(11.45,28.69) 11.79,28.69 12.01,28.92 PQ813.1 ; UL2.3 212.92,120.1 v2(212.27,119.45) ; UZ1.8 181.01,56.55 v2(180.89,56.43) ; v2(126.76,77.56) 127.39,78.19 CC68.2 ; v2(115.23,93.53) 114.98,93.78 RC240.2 ; v2(126.76,80.81) 126.43,81.13 CC71.2 ; CC15.1 165.99,55.77 166.31,56.09 v2(166.31,56.43) ; v2(215.9,112.64) 215.9,112.2 215.71,112.01 QN1.1 ; 189.22,59.53 188.83,59.15 UZ1.25 ; v2(13.31,32.37) PQ813.4 ; v2(69.04,14.84) 69.37,14.84 69.72,15.18 JSIM1.5 ; UZ1.18 186.88,54.6 186.63,54.35 v2(186.63,54.04) ; JSIM1.13 v2(75.53,8.57) ; v2(11.17,25.04) 11.17,24.76 10.94,24.53 PU806.3 ; v2(14.3,23.52) 13.98,23.2 PQ817.1 ; JSIM1.16 v2(61.2,8.57) ; PQ806.4 13.25,35.85 13.38,35.73 v2(13.66,35.73) ; JSIM1.12 75.53,13.03 75.44,12.94 v2(75.44,12.53) ; RC241.2 116.25,94.1 116.8,93.54 v2(116.97,93.54) ; v2(207.97,59.52) 208.11,59.66 QA3.1 ; JSIM1.17 v2(61.2,12.34) ; v2(69.76,115.55) 69.31,116.01 PU1.2 ; UZ10.3 v2(187.6,114.81) ; UZ1.4 181.42,59.15 180.99,59.58 v2(180.83,59.58)
  TOP w0.406: v2(175.9,109.06) 176.11,109.27 UZ11.3 ; UZ6.3 186,90.04 v2(185.76,90.28) ; v2(204.97,61.7) 205.67,61.7 205.85,61.89 QA3.4 ; v2(7.74,37.23) 7.4,37.57 PU804.3
  TOP w0.432: 164.8,80.88 164.75,80.83 164.63,80.83 ; 164.8,80.88 165.65,81.73 QZ10.4 ; 164.8,80.88 v2(164.8,80.86)
  TOP w0.457: CL25.2 209.22,121.44 209.63,121.85 v2(209.88,121.85) 209.88,121.57 210.14,121.31 RL12.2 ; v2(114.21,117.64) 114.21,117.29 114.49,117.01 RV65.2 ; v2(69.46,39.14) 69.83,38.78 69.83,37.98 69.45,37.6 CC22.2 ; v2(67.95,57.9) 67.69,57.65 CC21.2 ; v2(193.11,83.96) 193.59,83.96 193.79,83.76 QE2.1 ; RV616.2 131.21,120.36 131.61,120.77 v2(131.98,120.77) ; RI23.2 219.08,79.56 v2(218.54,79.56) ; CV66.2 128.6,122 129.01,121.59 v2(129.11,121.59) 129.43,121.28 RV67.1 ; CC58.2 132.35,78.06 ; CV92.2 156.29,111.19 155.67,110.57 155.03,110.57 154.9,110.44 v5(154.75,110.44) ; RV100.2 135.08,120.25 135.58,119.75 v2(135.61,119.75) 135.99,119.37 CV600.2 ; CL23.2 197.14,104.5 v2(197.56,104.08)
  TOP w0.508: v2(203.79,10.18) 203.79,9.59 202.52,8.32 PQ816.3 ; v2(166.55,53.83) 166.2,53.83 165.17,54.86 CC48.2 CC50.2 ; v2(191.63,62.78) 191.63,62.08 190.88,61.33 190.88,60.24 190.6,59.96 ; v2(210.25,81.65) 210.15,81.55 ; 210.15,81.55 RE82.1 ; 210.15,81.55 210.14,81.54 209.4,81.54 CE29.2 ; RC191.2 97.68,78.44 97.45,78.67 97.45,79.13 v2(97.45,79.14) 97.5,79.19 97.5,79.79 RC189.2 97.33,80.03 v2(97.33,80.51) ; RD15.1 118.41,28.12 v2(118.08,27.78) ; CZ27.2 202.42,57.45 CZ30.2 202.43,56.77 v2(202.3,56.65) ; v2(204.8,100.96) 205.23,100.52 RE55.1 CE22.2 ; PC100.1 46.4,29.66 45.42,29.66 ; v2(15.64,17.96) CR31.2 CR6.2 ; CZ39.1 137.16,98.63 137.05,98.52 CZ62.2 CZ60.2 ; 189.22,59.53 189.64,59.96 190.6,59.96 ; v5(152.8,114.33) 152.37,114.33 CV83.2 ; v2(48.36,29.87) 48.55,29.68 PR104.2 ; PC805.1 10.06,41.3 v2(10.31,41.56) ; CL15.2 213.87,124.01 v2(214.19,123.69) ; v2(15.61,15.64) 15.8,15.45 CR34.2 ; CA45.2 207.61,77.27 v2(207.61,77.88) ; RD16.1 120.77,28.11 v2(121.03,28.38) ; CC53.2 132.9,81.7 v2(132.44,82.16) ; v2(130.84,81.47) 131,81.47 CC44.2 ; v2(202.38,83.56) CE18.2 ; QA1.3 201.77,62.03 v2(202.21,61.59) ; CC14.1 161.84,55.86 162.37,56.39 v2(162.37,56.43) ; v2(221.11,49.74) 221.64,49.2 CZ12.2 221.64,48.05 CZ11.2 ; CC73.2 133.24,56.81 v2(134.16,57.72) ; CR23.2 30.67,19.6 30.72,19.55 v2(31.1,19.55) ; PR525.2 95.96,101.63 96.22,101.88 v2(96.22,102.11) ; JTAG1.2 203.24,79.1 CE30.2 205.09,79.1 ; CV61.2 116.77,112.02 v2(117.01,111.78) ; v2(127.65,28.78) 128.72,29.85 RD25.2 128.69,30.88 RD24.2 ; RV63.2 124.4,125.56 124.4,128.01 v2(124.27,128.13) ; CV602.2 143.44,110.66 v2(143.21,110.89) ; CZ65.2 CZ63.2 65.46,19.51 v2(64.85,19.51) ; CV84.2 CV93.2 153.67,117.34 154.16,117.82 v2(154.32,117.82) ; v2(220.21,112.65) 220.92,111.94 CN1.2 ; CZ15.2 CZ17.1 CZ20.2 168.02,91.75 v2(168.18,91.9) ; JDEG1.12 189.86,77.93 v2(190.75,78.82) ; 205.09,79.1 RE65.2 ; 205.09,79.1 205.09,78.43 204.83,78.16 v2(204.16,78.16) 204,78.01 204,77.51 CA19.2 ; JAPS1.19 v2(225.14,96.1) ; v2(82.31,82.92) 82.58,83.19 RC129.1 ; v2(192,85.82) 192,85.6 191.33,84.93 UZ5.2 ; CA46.2 199.15,80.89 CA48.2 199.19,81.55 v2(199.29,81.65) ; RC152.2 131.07,73.88 130.68,73.49 v2(130.28,73.49) ; CZ40.2 201.81,32.25 v2(202.06,31.99) ; v2(203.76,119.45) 203.76,120.2 CL9.2 ; CZ36.2 198.21,112.25 v2(199.37,113.4) ; RV609.1 139.05,109.7 CV601.2 137.36,109.72 136.48,110.59 RV600.2 136.74,111.36 137.53,111.36 v2(137.68,111.51) ; RD14.1 96.62,9.62 v2(96.62,10.16) ; v2(212.96,78.97) CE44.2 ; CE7.2 191.67,103.08 v2(191.67,103.75) 191.35,104.07 CE3.2 ; v2(273.75,129.66) 273.75,128.9 274.13,128.51 CL20.2 ; JSIM1.18 v2(63.66,17.73) ; v2(255.5,131.58) LED6.1 ; CE5.2 183.84,110.06 v2(184.06,110.29) ; CE11.2 210.15,82.4 v2(210.06,82.31) ; v2(162.5,58.97) 162.5,58.43 162.94,57.98 CC12.1 ; v2(146.71,117.95) 146.2,117.95 RV606.1 ; CE4.2 v2(171.53,104.78) ; v2(225.44,57.45) 225.09,57.1 JIO1.31 ; RV617.2 143.32,129.93 v2(143.54,130.15) ; CR14.1 v2(16.32,10.81) ; v2(17.02,24.69) 17.02,24.41 17.2,24.23 CR8.1 ; RV1.2 99.3,117.69 v2(99.7,118.08) ; v2(21.83,12.27) 21.19,12.92 CR22.1 ; 45.42,29.66 v2(45.41,29.67) ; 45.42,29.66 PR102.1 ; PR12.1 v2(69.38,108.13) ; v2(212.35,109.08) 212.23,109.2 CL8.2 211.65,108.46 CL14.1 ; CZ7.2 190.91,59.66 190.6,59.96 ; v2(144.88,134.55) C317.2 ; CC43.2 126.86,96.85 126.91,96.8 v2(126.91,96.66) ; v2(234.37,127.5) CV511.2 ; CV95.2 CV98.2 151.52,117.16 v2(152.4,118.04) ; RI37.2 v2(229.94,82.8) ; CE40.2 215.71,94.99 215.39,94.67 v2(215.01,94.67) ; v2(218.35,60.11) 218.38,60.09 218.38,60.07 218.79,59.67 CI33.2 ; CC20.2 84.93,101.45 v2(85.58,101.45) ; RC303.2 144.96,86.16 v2(144.86,86.27) ; CL21.2 277.88,127.63 277.18,128.32 v2(277.18,129.08) ; v2(218.26,110.25) 217.78,109.77 CN2.2 ; CI417.2 v2(132.32,135.06) ; CA19.2 203.98,77.49 CA47.2 ; CA19.2 204.89,77.5 CA24.2 ; JUSH1.22 v2(211.65,41.85) ; v2(130.12,83.73) 130.12,84.1 CC59.2 ; v2(193.45,112.08) 193.11,111.74 RZ27.2 ; v2(154.8,76.51) 155.31,77.02 RC174.2 ; CE8.2 183.45,110.72 v2(183.02,110.29) 182.57,110.75 RE85.2 ; v2(70.26,19.04) 70,19.29 C263.2 ; CC70.2 128.99,83.61 v2(129.09,83.71) ; v2(178.81,58.93) 178.76,58.88 178.76,58.3 179.01,58.04 CZ6.2 ; v2(203.88,111.18) 203.32,111.18 202.43,112.07 CL11.2 ; RC21.2 93.5,76.07 RC183.2 v2(92.83,76.06) ; CA49.1 213.46,73.05 v2(213.87,73.46) ; v2(75.17,15.46) 75.17,16.06 74.68,16.55 JSIM1.11 ; CV99.2 155.6,117.24 156.12,117.75 v2(156.49,117.75) ; CD30.2 v2(97.86,13.3) ; PR844.2 v2(14.95,43.45) ; CE14.2 209.07,102.57 v2(209.37,102.26) ; v2(195.06,35.31) RD28.2 ; v2(92.14,117.47) 91.51,116.83 CV12.2 ; v2(214.12,99.56) 214.57,99.11 CE31.2 ; CZ25.2 166.6,79.39 166.5,79.49 v2(166.5,80) ; v2(214.63,93.65) 214.44,93.46 CE23.2 ; RI14.1 56.84,120.55 v2(56.57,120.82) ; 188.85,80.89 188.92,80.83 CZ35.2 189.41,80.11 v2(189.17,79.87) ; PC813.2 v2(18.85,28.26) ; v2(164.75,60.43) 164.46,60.72 RC91.1 ; v2(192.18,54.66) 192.18,55.08 192.66,55.56 CZ9.2 ; RI35.2 219.08,81.7 218.57,81.7 v2(218.1,82.17) 217.54,81.61 CE10.2 CE12.2 ; v2(223.8,8.21) DA6.1 ; DE1.2 v2(73.35,88.13) ; PR105.1 43.63,29.4 44.06,29.84 v2(44.06,29.85) ; PC514.1 83.55,99.71 v2(82.97,99.71) ; v2(218.56,86.63) 219.04,86.63 RI20.2 ; v2(121.73,75.2) 121.73,75.3 122.24,75.8 CC37.2 ; v2(27.6,37.66) 27.38,37.87 PR874.2 ; v2(131.57,135.07) CI418.2 ; CE32.2 v2(73.22,86.86) ; CZ41.2 CZ42.2 v2(197.11,34.98) ; CV85.2 CV91.2 152.21,106.7 v2(151.7,107.2) 151.45,107.46 CV94.2 ; CC100.1 146.31,76.09 v2(146.61,76.39) ; v2(133.45,105.03) 133.45,104.82 133.25,104.61 CZ38.2 ; CR9.1 19.24,26.67 v2(18.62,27.3) 17.91,26.58 CR7.1 ; v2(51.51,60.94) 51.51,60.86 52.02,60.35 CZ45.2 ; v2(125.86,124.96) 125.94,124.88 RV550.2 RV52.2 ; v2(234.76,6.75) 234.95,6.56 JSPK1.6 ; v2(144.26,75.26) CC80.2 ; JIO1.32 v2(223.75,76.75) ; v2(198.38,71.07) 198.78,71.07 CA33.2 ; v2(69.09,27.02) RD20.2 ; CA7.2 CZ1.2 101.23,115 100.59,114.35 v2(100.59,114.16) ; RE17.1 183.9,92.13 182.8,91.03 v2(182.37,91.03) 182.7,90.7 CZ34.2 ; v2(210.76,106.86) 210.44,106.54 YL1.2 ; CE28.2 207.58,84.52 v2(207.58,85.17) ; RE58.2 206.06,81.26 v2(206.06,80.7) ; RE78.2 203.24,104.51 v2(203.86,104.51) ; RI22.2 v2(218.61,85.08) ; CR13.1 28.86,18.74 v2(28.77,18.65) CR4.2 ; v2(65.85,57.59) CC19.2 ; v2(61.94,115.15) 61.47,115.62 CI13.2 ; CC60.2 124.92,94.33 v2(124.82,94.22) ; RC123.2 CC83.2 93.98,94.53 94.6,93.91 94.6,93.27 v2(94.44,93.11) ; CZ60.2 137.14,96.99 137.7,96.99 v2(137.75,96.94) ; CZ60.2 CZ56.2 ; RR5.2 19.17,12.97 CR3.2 18.34,12.96 v2(18.14,12.75) ; v2(196.65,88.07) 196.65,86.85 197.2,86.3 CE25.2 ; v2(202.51,101.57) 202.51,101.78 202.8,102.07 CE34.2 ; v2(22.55,12.26) 22.55,12.79 CR21.1 ; v2(62.96,64.72) CC17.2 ; PQ6.6 v2(73.15,96.07) ; CV86.2 152.15,110.91 151.67,110.44 v5(151.5,110.44) ; v2(202.43,99.91) 202.43,100.18 202.11,100.5 201.34,100.5 CE36.2 ; v2(128.98,80.42) 129.25,80.7 CC69.2 ; CN16.2 217.39,107.82 CN15.2 215.98,107.82 v2(215.52,107.37) ; v2(191.57,54.65) 191.38,54.84 CZ4.2 ; v2(139.85,125.63) 139.58,125.35 139.58,124.13 CV604.2 RV620.2 ; PC816.2 v2(26.11,31.37) ; v2(124.78,109.78) 125.03,110.04 RV50.2 125.88,110.53 CV62.2 ; CZ29.2 199.38,58.35 CZ28.2 199.39,59.01 v2(199.3,59.1) ; RA37.2 210.2,63 v2(211.09,63) ; RV66.2 CV60.2 116.35,122.36 116.08,122.08 v2(116.08,121.69) ; JSIM1.10 71.12,16.02 71.34,15.8 v2(71.67,15.8) ; CV97.2 154.69,117.22 154.94,117.48 154.94,118.14 v2(154.66,118.42) ; CV510.2 255.32,125.83 255.93,126.44 v2(255.93,126.69) ; RR8.2 16.02,19.73 v2(15.69,20.07) ; v2(206.07,82.92) 206.07,83.47 CE20.2 CE15.2 ; v2(75.62,125.01) 74.67,124.06 74.67,123 CV9.2 74.68,122.66 75.33,122.01 UV24.2 ; CI35.2 CI34.2 v2(218.37,67.4) ; CC9.1 194.27,74.68 v2(194.93,75.34) ; v2(102.86,114.33) 102.57,114.62 RV2.2 ; RC198.2 CC18.2 63.62,42.26 v2(62.12,42.26) ; v2(93.8,100.21) PR505.1 ; CZ43.2 201.81,36.69 v2(202,36.88) ; JAPS1.20 v2(225.19,108.8) ; CA30.2 199,73.45 v2(199.14,73.31) 199.33,73.5 CA10.2 200.31,73 CA50.2 ; RV608.1 141.68,109.2 v2(141.99,108.89) ; CE38.2 210.63,100.45 210.01,101.07 v2(209.78,101.07) 209.54,101.07 CE13.2 RE277.1 ; v2(157.67,130.42) 157.33,130.08 RV77.2 156.43,129.44 RV76.2 ; v2(173.8,76.64) 174.25,77.08 CC6.2 ; R271.2 C311.2 149.16,135.83 v2(149.16,135.53) ; CZ31.2 v2(205.12,56.71) ; v2(194.73,104.22) 195.01,104.5 RN7.2 ; UV501.2 251.73,127.45 v2(252.22,127.94) ; v2(24.79,24.32) 25.11,24.64 CR19.1 25.54,25.56 RR2.1 ; v2(4.64,34.42) 5.06,34 PQ832.3 ; RD21.2 72.04,27.12 71.99,27.17 71.99,27.27 71.48,27.78 v2(71.38,27.78) ; v2(130.74,79.62) CC64.2 CC63.2 ; SW2.3 226.13,89.93 v2(225.55,89.35) ; v2(50.82,60.19) 50.82,59.87 51.22,59.46 CZ44.2 ; v2(187.01,110.35) 187.39,109.97 RE21.1 ; v2(119.59,124.39) RV554.1 CV69.2 ; CV603.2 148.08,121.15 148.56,121.63 v2(148.56,121.89) ; RV619.2 RV618.2 142.83,124.35 v2(142.59,124.59) ; CR35.2 v2(31.74,12.2) ; CR15.1 18.75,12.11 CR1.2 18.96,11.56 19.54,10.99 v2(19.64,10.99) ; CC8.1 124.25,100.03 v2(123.98,99.76) 124.25,99.49 CC11.1 ; CZ5.2 v2(180.56,53.69) ; v2(54.97,32.2) 54.98,32.19 CD5.2 CD1.2 ; CI416.2 131.85,127.46 v2(131.79,127.52) ; YL1.4 207.91,102.54 v2(207.95,102.49) ; v2(233.94,121.85) 234.76,121.85 235.16,122.24 QV502.3 ; RI4.2 221.88,77.64 v2(221.72,77.8) ; RR11.2 v2(32.62,12.2) ; CD33.2 CD34.2 130.56,33.81 131.08,34.33 132.47,34.33 v2(133.11,33.68) ; v2(129.56,76.56) 130.14,75.98 CC57.2 ; PR106.1 50.33,30.19 v2(50.65,30.51) ; CZ68.2 224.5,47.18 224.12,47.56 CZ10.2 224.12,48.16 v2(224.54,48.58) ; v2(164.68,63.6) CC3.1 CC4.1 ; CA41.2 198.87,64.66 v2(198.29,65.24) ; v2(190.83,100.22) RE20.1 ; PQ712.3 v2(5.54,19.52) ; v2(199.37,109.66) 199.66,109.36 CZ37.2 CL24.2 ; CZ48.2 187.66,119.23 v2(187.07,119.82) ; PR858.2 21.67,40.36 v2(21.22,39.92) ; v2(225.85,12.3) DA7.1 ; CE45.2 209.08,78.12 208.68,78.53 207.89,78.53 207.61,78.25 v2(207.61,77.88) ; CZ50.2 195.05,45.38 195.06,45.39 v2(195.06,45.38) ; CI30.2 v2(229.95,81.02) ; v2(177.55,92.37) 177.55,92.48 CE2.2 CE6.2 ; CA23.2 206.65,77.5 CA22.2 207.03,77.88 v2(207.61,77.88) ; RC218.2 95.61,96.4 v2(94.76,95.55) ; CZ46.2 52.47,61.31 v2(52.22,61.55) ; JUSH1.21 v2(227.9,40.18) ; CL12.2 202.96,121.55 v2(202.68,121.83) ; PC815.2 v2(20.06,28.26) ; QN1.4 214.41,109.63 v2(213.87,109.08) RL13.2 ; JSIM1.14 v2(75.16,2.56) ; v2(131.99,83.7) 131.99,84.19 CC40.2 ; v2(52.99,62.26) CZ47.2 ; CC72.2 130.51,77.38 v2(130.59,77.31) 130.62,77.35 CC61.2 ; v2(196.54,97.97) 196.73,97.78 CE19.2 ; v2(190.62,36.31) 191.39,35.54 CD63.2 CD64.2 ; RE24.2 178.74,93.89 178.74,94.72 179.1,95.08 v2(179.34,95.08) ; v2(131.93,75.11) 132.25,75.42 CC49.2 ; CC78.2 129.89,96.6 v2(129.83,96.67) ; RI24.2 218.81,82.41 v2(218.56,82.67) ; RD7.2 55.68,37.27 RD6.2 55.2,37.21 54.96,36.97 v2(54.96,36.4) ; JSPK1.5 229.72,5.78 v2(229.9,5.6) ; v2(205.01,50.14) 206.12,50.14 206.95,50.97 JKBTP1.17 ; PR18.2 v2(74.18,97.04) ; v2(83.2,118.29) 83.2,119.95 82.97,120.18 CV10.2 ; CE21.2 217.12,83.58 CE16.2 v2(217.83,84.13) ; RE56.1 192.48,94.73 192.76,94.45 v2(192.76,94.44) ; v2(197.55,82.99) 197.03,82.46 QE2.4 ; PC810.1 v2(7.03,24.07) ; CE17.2 197.35,90.89 v2(197.6,91.14) 197.94,91.49 RE86.1 ; RV78.2 152.82,129.18 153.16,128.83 153.16,128.26 153.55,127.88 v2(153.55,127.56) ; RZ10.1 v2(226.19,47.81) ; CC54.2 132.35,78.06 v2(132.31,78.02) ; v2(189.27,45.38) CZ24.2 ; v2(18.67,21.89) CR17.1 ; RV62.2 RV64.2 v2(122.24,109.77) ; CR18.1 28.31,25.23 v2(28.31,24.58) ; JDEG1.11 182.75,77.93 182.25,78.44 v2(182.2,78.44) ; v2(20.58,25.58) 20.58,25.39 20.89,25.07 CR2.2 20.72,24.77 19.95,24.01 CR10.1 ; JSIM1.15 v2(61.56,2.57) ; RC171.2 168.65,85.13 v2(168.15,85.63) ; v2(107.32,112.86) DV4.1 ; C33.2 v2(147.28,138.14) ; v2(192.76,41.1) RZ40.1 ; CE9.2 182.12,93.67 181.88,93.91 v2(181.88,94.16) ; PC9.2 v2(81.47,115.03) ; RC305.2 95.49,78.32 94.57,78.32 RC190.2 94.42,78.58 94.83,78.99 94.83,79.25 v2(94.84,79.26) ; SW2.1 v2(226.13,95.39) ; RV61.2 v2(129.97,113.47) CV605.2 ; LED5.1 273.78,130.7 v2(273.05,129.98) ; CA31.2 198.92,76.24 v2(198.66,76.51) ; CC13.1 167.58,59.21 167.35,58.98 v2(166.72,58.98) ; D20.1 v2(139.32,137.4) ; PC119.2 v2(51.44,30.51) ; v2(191.87,41.1) RZ38.1 ; CA11.2 200.76,68.8 CA53.2 198.83,68.8 v2(198.72,68.91) ; v2(213.25,99.59) 212.75,100.09 RE77.2 ; v2(171.81,75.36) 172.42,75.36 172.76,75.02 CC10.1 ; PQ3.3 v2(72.29,109.27) ; v2(161.13,116.51) 161.13,117.31 160.72,117.72 CV87.2 CV82.2 ; RE88.2 v2(197.35,88) ; QV2.3 79.6,111.4 v2(79.35,111.15) ; CI29.2 v2(221.12,86.43) ; v2(65.6,25.45) CD6.2 ; CZ19.2 v2(187.71,91.98) ; PR114.2 52.42,27.17 v2(52.59,26.99) ; CC65.2 126.16,56.55 125.28,55.68 v2(124.86,55.68) ; RV3.1 v2(75.89,118.93) ; CE1.2 v2(185.87,92.47) ; v2(169.98,88) CZ16.2 ; CC35.2 v2(75.44,82.93) ; PC817.2 v2(27.65,34.46) ; C318.2 v2(144.72,138.67) ; v2(195.25,50.6) JKBTP1.18 ; v2(129.12,82.15) CC66.2
  GND1 w0.203: 182.94,136.78 JDOCK1.162 ; JDOCK1.162 182.94,137.72 ; JDOCK1.162 185,137.72 ; JDOCK1.162 187.06,136.78 ; JDOCK1.162 185,135.83 ; JDOCK1.162 187.06,135.83 ; JDOCK1.162 187.06,137.72 ; JMDP1.1 245.85,132.42 ; JMDP1.1 246.31,132.3 ; JMDP1.1 245.27,131.84 ; JMDP1.1 245.39,132.3 ; JMDP1.1 245.39,131.38 ; JMDP1.1 245.85,131.26 ; JMDP1.1 246.31,131.38 ; JDOCK1.157 155.3,132.05 ; JDOCK1.157 154.5,131.8 ; JDOCK1.157 153.45,132.85 ; JDOCK1.157 155.3,133.65 ; JDOCK1.157 154.5,133.9 ; JDOCK1.157 153.7,132.05 ; JDOCK1.157 155.55,132.85 ; JDOCK1.157 153.7,133.65 ; 80.33,136.68 JHDMI1.22 ; JHDMI1.22 81.21,139.62 ; JHDMI1.22 82.09,139.62 ; JHDMI1.22 81.21,136.68 ; JHDMI1.22 80.33,138.15 ; JHDMI1.22 82.09,136.68 ; JHDMI1.22 82.09,138.15 ; 154.5,135.8 JDOCK1.160 ; JDOCK1.160 155.55,137.75 ; JDOCK1.160 153.45,135.8 ; JDOCK1.160 154.5,137.75 ; JDOCK1.160 153.45,136.78 ; JDOCK1.160 155.55,135.8 ; JDOCK1.160 155.55,136.78 ; JDOCK1.160 153.45,137.75 ; 250.79,131.38 JMDP1.19 ; JMDP1.19 251.25,131.26 ; JMDP1.19 250.79,132.3 ; JMDP1.19 251.83,131.84 ; JMDP1.19 251.71,132.3 ; JMDP1.19 251.71,131.38 ; JMDP1.19 251.25,132.42 ; 243.55,128.53 JMDP1.24 ; JMDP1.24 242.77,131.15 ; JMDP1.24 242.77,128.53 ; JMDP1.24 242.77,129.84 ; JMDP1.24 244.33,131.15 ; JMDP1.24 243.55,131.15 ; JMDP1.24 244.33,128.53 ; JMDP1.24 244.33,129.84 ; H11.1 127.9,108.28 ; H11.1 126.56,105.11 ; H11.1 129.24,105.11 ; H11.1 126.56,107.79 ; H11.1 129.73,106.45 ; H11.1 126.07,106.45 ; H11.1 127.9,104.62 ; H11.1 129.24,107.79 ; 224.59,54.45 H18.1 ; H18.1 226.12,50.84 ; H18.1 227.64,51.4 ; H18.1 227.64,54.45 ; H18.1 226.12,55.01 ; H18.1 224.59,51.4 ; H18.1 224.03,52.93 ; H18.1 228.2,52.93 ; 284.87,133.7 JLOM1.16 ; JLOM1.16 283.96,137.2 ; JLOM1.16 284.87,137.2 ; JLOM1.16 283.96,135.45 ; JLOM1.16 283.96,133.7 ; PBATT1.10 149.38,4.43 ; PBATT1.10 150.35,4.43 ; PBATT1.10 148.4,2.55 ; PBATT1.10 150.35,2.55 ; PBATT1.10 148.4,4.43 ; PBATT1.10 148.4,0.67 ; PBATT1.10 150.35,0.67 ; PBATT1.10 149.38,0.67 ; JHDMI1.11 91.42,131.61 ; JHDMI1.11 90.5,131.61 ; JHDMI1.11 90.96,131.49 ; JHDMI1.11 91.42,132.53 ; JHDMI1.11 90.96,132.65 ; JHDMI1.11 90.5,132.53 ; 73.72,68.17 H19.1 ; H19.1 72.19,71.77 ; H19.1 75.24,68.73 ; H19.1 73.72,72.33 ; H19.1 72.19,68.73 ; H19.1 75.24,71.77 ; H19.1 75.8,70.25 ; H19.1 71.63,70.25 ; JUSB1.4 63.29,126.4 ; JUSB1.4 63.29,127.67 ; JUSB1.4 62.02,126.4 ; JUSB1.4 63.48,127.04 ; JUSB1.4 61.82,127.04 ; JUSB1.4 62.65,126.21 ; 213.45,101.77 H21.1 ; H21.1 211.47,103.75 ; H21.1 214.9,105.2 ; H21.1 215.43,103.75 ; H21.1 213.45,105.73 ; H21.1 212,102.3 ; H21.1 214.9,102.3 ; H21.1 212,105.2 ; JDOCK1.159 179.55,132.85 ; JDOCK1.159 178.5,133.9 ; JDOCK1.159 179.3,133.65 ; JDOCK1.159 177.45,132.85 ; JDOCK1.159 179.3,132.05 ; JDOCK1.159 177.7,133.65 ; JDOCK1.159 178.5,131.8 ; JDOCK1.159 177.7,132.05 ; 149.55,90.81 H10.1 ; H10.1 149.55,87.41 ; H10.1 151.25,86.77 ; H10.1 152.95,87.41 ; H10.1 151.25,91.45 ; H10.1 153.59,89.11 ; H10.1 152.95,90.81 ; H10.1 148.91,89.11 ; 165.7,133.65 JDOCK1.158 ; JDOCK1.158 165.7,132.05 ; JDOCK1.158 167.3,132.05 ; JDOCK1.158 167.55,132.85 ; JDOCK1.158 166.5,133.9 ; JDOCK1.158 165.45,132.85 ; JDOCK1.158 167.3,133.65 ; JDOCK1.158 166.5,131.8 ; 98.83,138.15 JHDMI1.23 ; JHDMI1.23 100.59,136.68 ; JHDMI1.23 100.59,139.62 ; JHDMI1.23 98.83,139.62 ; JHDMI1.23 99.71,136.68 ; JHDMI1.23 100.59,138.15 ; JHDMI1.23 98.83,136.68 ; JHDMI1.23 99.71,139.62 ; JUSB1.10 74.88,127.16 ; JUSB1.10 74.88,128.63 ; JUSB1.10 74.88,130.1 ; JUSB1.10 73.12,127.16 ; JUSB1.10 74,130.1 ; JUSB1.10 74,127.16 ; JUSB1.10 73.12,128.63 ; 7.87,7.95 H13.1 ; H13.1 9.7,9.78 ; H13.1 8.36,6.61 ; H13.1 11.53,7.95 ; H13.1 11.04,9.29 ; H13.1 8.36,9.29 ; H13.1 11.04,6.61 ; H13.1 9.7,6.12 ; 45.5,32.22 H15.1 ; H15.1 47.33,34.05 ; H15.1 43.67,34.05 ; H15.1 46.84,35.39 ; H15.1 46.84,32.71 ; H15.1 44.16,32.71 ; H15.1 44.16,35.39 ; H15.1 45.5,35.88 ; 229.66,114.59 H6.1 ; H6.1 229.66,111.91 ; H6.1 231,111.42 ; H6.1 232.83,113.25 ; H6.1 231,115.08 ; H6.1 232.34,114.59 ; H6.1 229.17,113.25 ; PBATT1.11 171.63,4.43 ; PBATT1.11 172.6,0.67 ; PBATT1.11 170.65,4.43 ; PBATT1.11 171.63,0.67 ; PBATT1.11 170.65,0.67 ; PBATT1.11 172.6,4.43 ; PBATT1.11 172.6,2.55 ; PBATT1.11 170.65,2.55 ; JHDMI1.20 84.09,132.88 ; JHDMI1.20 82.33,132.88 ; JHDMI1.20 83.21,129.72 ; JHDMI1.20 84.09,129.72 ; JHDMI1.20 82.33,129.72 ; JHDMI1.20 83.21,132.88 ; JHDMI1.20 82.33,131.3 ; JHDMI1.20 84.09,131.3 ; JDOCK1.161 167.55,136.78 ; JDOCK1.161 167.55,137.75 ; JDOCK1.161 166.5,135.8 ; JDOCK1.161 167.55,135.8 ; JDOCK1.161 166.5,137.75 ; JDOCK1.161 165.45,137.75 ; JDOCK1.161 165.45,135.8 ; JDOCK1.161 165.45,136.78 ; 7.76,44.81 H5.1 ; H5.1 9.1,44.32 ; H5.1 7.27,46.15 ; H5.1 10.44,47.49 ; H5.1 7.76,47.49 ; H5.1 10.93,46.15 ; H5.1 9.1,47.98 ; H5.1 10.44,44.81 ; 133.94,127.98 JDOCK1.151 ; JDOCK1.151 136,129.87 ; JDOCK1.151 138.06,127.98 ; JDOCK1.151 136,127.98 ; JDOCK1.151 133.94,128.93 ; JDOCK1.151 138.06,128.93 ; JDOCK1.151 133.94,129.87 ; 128.38,19.1 SW1.5 ; SW1.5 128.14,18.34 ; SW1.5 130.15,18.34 ; SW1.5 129.14,19.35 ; SW1.5 128.38,17.58 ; SW1.5 129.14,17.34 ; SW1.5 129.9,19.1 ; SW1.5 129.9,17.58 ; 87.5,131.61 JHDMI1.5 ; JHDMI1.5 87.96,131.49 ; JHDMI1.5 87.96,132.65 ; JHDMI1.5 88.42,132.53 ; JHDMI1.5 87.5,132.53 ; JHDMI1.5 88.42,131.61 ; 182.94,127.98 JDOCK1.154 ; JDOCK1.154 187.06,128.93 ; JDOCK1.154 187.06,129.87 ; JDOCK1.154 185,127.98 ; JDOCK1.154 185,129.87 ; JDOCK1.154 182.94,128.93 ; JDOCK1.154 187.06,127.98 ; H4.1 218.84,134.79 ; H4.1 217.5,131.62 ; H4.1 215.67,133.45 ; H4.1 219.33,133.45 ; H4.1 216.16,132.11 ; H4.1 218.84,132.11 ; H4.1 216.16,134.79 ; H4.1 217.5,135.28 ; 151.69,1.49 PBATT1.9 ; PBATT1.9 153.31,3.11 ; PBATT1.9 153.31,1.49 ; PBATT1.9 152.5,3.38 ; PBATT1.9 151.69,3.11 ; PBATT1.9 152.5,1.22 ; PBATT1.9 151.42,2.3 ; JMDP1.7 247.55,131.23 ; JMDP1.7 248.13,130.64 ; JMDP1.7 247.55,130.06 ; JMDP1.7 248.01,131.1 ; JMDP1.7 247.09,131.1 ; JMDP1.7 248.01,130.18 ; JMDP1.7 247.09,130.18 ; JHDMI1.21 98.59,131.3 ; JHDMI1.21 97.71,129.72 ; JHDMI1.21 96.83,129.72 ; JHDMI1.21 98.59,132.88 ; JHDMI1.21 96.83,131.3 ; JHDMI1.21 96.83,132.88 ; JHDMI1.21 98.59,129.72 ; JHDMI1.21 97.71,132.88 ; H23.1 264.23,137.26 ; H23.1 260.77,138.75 ; H23.1 262.5,137.26 ; H23.1 264.23,140.24 ; H23.1 260.77,140.24 ; H23.1 262.5,140.24 ; H23.1 260.77,137.26 ; H23.1 264.23,138.75 ; 220.32,137.5 JUSB2.12 ; JUSB2.12 220.32,136.13 ; JUSB2.12 221.2,134.76 ; JUSB2.12 220.32,134.76 ; JUSB2.12 221.2,137.5 ; JDOCK1.148 185.68,134.7 ; JDOCK1.148 186.59,131 ; JDOCK1.148 186.59,132.85 ; JDOCK1.148 185.68,131 ; JDOCK1.148 186.59,134.7 ; 134.41,132.85 JDOCK1.145 ; JDOCK1.145 135.33,134.7 ; JDOCK1.145 135.33,131 ; JDOCK1.145 134.41,134.7 ; JDOCK1.145 134.41,131 ; 100.01,16.61 H16.1 ; H16.1 101.35,16.12 ; H16.1 101.35,19.78 ; H16.1 99.52,17.95 ; H16.1 102.69,16.61 ; H16.1 103.18,17.95 ; H16.1 102.69,19.29 ; H16.1 100.01,19.29 ; 50.16,135.29 H1.1 ; H1.1 52.84,132.61 ; H1.1 49.67,133.95 ; H1.1 53.33,133.95 ; H1.1 52.84,135.29 ; H1.1 51.5,132.12 ; H1.1 51.5,135.78 ; H1.1 50.16,132.61 ; H2.1 104.84,135.79 ; H2.1 103.5,132.62 ; H2.1 104.84,133.11 ; H2.1 103.5,136.28 ; H2.1 105.33,134.45 ; H2.1 102.16,135.79 ; H2.1 102.16,133.11 ; H2.1 101.67,134.45 ; 191.27,138.35 H12.1 ; H12.1 194.44,137.01 ; H12.1 193.1,136.52 ; H12.1 194.93,138.35 ; H12.1 191.76,137.01 ; H12.1 191.76,139.69 ; H12.1 194.44,139.69 ; H12.1 193.1,140.18 ; 174.92,1.65 H27.1 ; H27.1 178.09,2.99 ; H27.1 175.41,2.99 ; H27.1 176.75,3.48 ; JDOCK1.153 166.5,129.9 ; JDOCK1.153 167.55,128.93 ; JDOCK1.153 167.55,129.9 ; JDOCK1.153 167.55,127.95 ; JDOCK1.153 165.45,128.93 ; JDOCK1.153 166.5,127.95 ; JDOCK1.153 165.45,129.9 ; JDOCK1.153 165.45,127.95 ; JUSB2.4 226.19,127.67 ; JUSB2.4 226.38,127.04 ; JUSB2.4 226.19,126.4 ; JUSB2.4 225.55,126.21 ; JUSB2.4 224.92,126.4 ; JUSB2.4 224.72,127.04 ; JUSB2.10 237.78,130.1 ; JUSB2.10 236.9,127.16 ; JUSB2.10 237.78,128.63 ; JUSB2.10 236.9,130.1 ; JUSB2.10 236.02,128.63 ; JUSB2.10 237.78,127.16 ; JUSB2.10 236.02,127.16 ; H14.1 228.84,16.11 ; H14.1 229.33,17.45 ; H14.1 227.5,15.62 ; H14.1 228.84,18.79 ; H14.1 226.16,18.79 ; H14.1 227.5,19.28 ; H14.1 225.67,17.45 ; H14.1 226.16,16.11 ; 155.69,3.11 PBATT1.7 ; PBATT1.7 156.5,1.22 ; PBATT1.7 157.31,3.11 ; PBATT1.7 155.69,1.49 ; PBATT1.7 156.5,3.38 ; PBATT1.7 157.31,1.49 ; 229.05,127.71 JUSB2.7 ; JUSB2.7 229.88,128.54 ; JUSB2.7 228.22,128.54 ; JUSB2.7 229.69,127.91 ; JUSB2.7 228.42,127.91 ; H22.1 181.53,114.75 ; H22.1 179.55,116.73 ; H22.1 178.1,116.2 ; H22.1 178.1,113.3 ; H22.1 179.55,112.77 ; H22.1 177.57,114.75 ; H22.1 181,113.3 ; H22.1 181,116.2 ; H7.1 152.96,67.09 ; H7.1 149.55,70.49 ; H7.1 152.96,70.49 ; H7.1 149.55,67.09 ; H7.1 148.92,68.79 ; H7.1 151.25,71.13 ; H7.1 151.25,66.45 ; H7.1 153.59,68.79 ; 158.5,1.22 PBATT1.6 ; PBATT1.6 159.31,1.49 ; PBATT1.6 157.69,1.49 ; PBATT1.6 158.5,3.38 ; PBATT1.6 159.31,3.11 ; PBATT1.6 157.69,3.11 ; 141.45,132.85 JDOCK1.156 ; JDOCK1.156 141.7,133.65 ; JDOCK1.156 142.5,131.8 ; JDOCK1.156 143.3,132.05 ; JDOCK1.156 142.5,133.9 ; JDOCK1.156 143.55,132.85 ; JDOCK1.156 141.7,132.05 ; JDOCK1.156 143.3,133.65 ; JUSB1.11 74,137.5 ; JUSB1.11 74.88,137.5 ; JUSB1.11 74,134.76 ; JUSB1.11 74.88,136.13 ; JUSB1.11 74.88,134.76 ; JHDMI1.8 89.46,131.45 ; JHDMI1.8 89,130.41 ; JHDMI1.8 89,131.33 ; JHDMI1.8 89.46,130.29 ; JHDMI1.8 89.92,131.33 ; JHDMI1.8 89.92,130.41 ; 249.09,131.1 JMDP1.13 ; JMDP1.13 249.55,131.23 ; JMDP1.13 250.01,131.1 ; JMDP1.13 249.09,130.18 ; JMDP1.13 249.55,130.06 ; JMDP1.13 250.01,130.18 ; JMDP1.13 248.97,130.64 ; PBATT1.8 155.31,1.49 ; PBATT1.8 153.69,1.49 ; PBATT1.8 155.31,3.11 ; PBATT1.8 154.5,1.22 ; PBATT1.8 153.69,3.11 ; PBATT1.8 154.5,3.38 ; 221.2,127.16 JUSB2.13 ; JUSB2.13 220.32,130.1 ; JUSB2.13 220.32,128.63 ; JUSB2.13 222.08,127.16 ; JUSB2.13 221.2,130.1 ; JUSB2.13 222.08,128.63 ; JMDP1.23 254.33,129.84 ; JMDP1.23 253.55,131.15 ; JMDP1.23 253.55,128.53 ; JMDP1.23 254.33,131.15 ; JMDP1.23 252.77,129.84 ; JMDP1.23 254.33,128.53 ; JMDP1.23 252.77,131.15 ; JMDP1.23 252.77,128.53 ; 85.41,68.79 H8.1 ; H8.1 86.05,70.49 ; H8.1 87.75,71.13 ; H8.1 90.09,68.79 ; H8.1 86.05,67.09 ; H8.1 89.45,70.49 ; H8.1 89.45,67.09 ; H8.1 87.75,66.45 ; 86.05,90.81 H9.1 ; H9.1 89.45,87.41 ; H9.1 87.75,86.77 ; H9.1 87.75,91.45 ; H9.1 86.05,87.41 ; H9.1 85.41,89.11 ; H9.1 89.45,90.81 ; H9.1 90.09,89.11 ; 57.42,130.1 JUSB1.13 ; JUSB1.13 57.42,128.63 ; JUSB1.13 59.18,127.16 ; JUSB1.13 58.3,130.1 ; JUSB1.13 57.42,127.16 ; JUSB1.13 59.18,128.63 ; JUSB1.13 58.3,127.16 ; JUSB2.11 236.9,137.5 ; JUSB2.11 237.78,137.5 ; JUSB2.11 237.78,134.76 ; JUSB2.11 236.9,134.76 ; JUSB2.11 237.78,136.13 ; 93.5,131.61 JHDMI1.17 ; JHDMI1.17 94.42,131.61 ; JHDMI1.17 93.96,131.49 ; JHDMI1.17 93.96,132.65 ; JHDMI1.17 94.42,132.53 ; JHDMI1.17 93.5,132.53 ; 65.32,128.54 JUSB1.7 ; JUSB1.7 66.98,128.54 ; JUSB1.7 66.79,127.91 ; JUSB1.7 66.15,127.71 ; JUSB1.7 65.52,127.91 ; JUSB1.12 58.3,137.5 ; JUSB1.12 57.42,136.13 ; JUSB1.12 57.42,134.76 ; JUSB1.12 58.3,134.76 ; JUSB1.12 57.42,137.5 ; JDOCK1.155 138.06,136.78 ; JDOCK1.155 133.94,135.83 ; JDOCK1.155 138.06,137.72 ; JDOCK1.155 136,137.72 ; JDOCK1.155 133.94,137.72 ; JDOCK1.155 133.94,136.78 ; JDOCK1.155 136,135.83 ; 121.84,18.34 SW1.4 ; SW1.4 122.84,19.35 ; SW1.4 123.85,18.34 ; SW1.4 122.84,17.34 ; SW1.4 122.08,17.58 ; SW1.4 123.6,17.58 ; SW1.4 123.6,19.1 ; SW1.4 122.08,19.1 ; JMDP1.21 243.55,135.68 ; JMDP1.21 242.77,135.68 ; JMDP1.21 242.77,133.06 ; JMDP1.21 243.55,133.06 ; JMDP1.21 242.77,134.37 ; 86,130.41 JHDMI1.2 ; JHDMI1.2 86.46,131.45 ; JHDMI1.2 85.88,130.87 ; JHDMI1.2 86.92,130.41 ; JHDMI1.2 86.46,130.29 ; JHDMI1.2 86.92,131.33 ; JHDMI1.2 86,131.33 ; JMDP1.22 253.55,135.68 ; JMDP1.22 254.33,134.37 ; JMDP1.22 253.55,133.06 ; JMDP1.22 254.33,135.68 ; JMDP1.22 254.33,133.06 ; H3.1 129.24,137.01 ; H3.1 126.56,137.01 ; H3.1 127.9,140.18 ; H3.1 126.56,139.69 ; H3.1 129.73,138.35 ; H3.1 126.07,138.35 ; H3.1 129.24,139.69 ; H3.1 127.9,136.52 ; 153.45,127.95 JDOCK1.152 ; JDOCK1.152 154.5,127.95 ; JDOCK1.152 154.5,129.9 ; JDOCK1.152 155.55,127.95 ; JDOCK1.152 155.55,128.93 ; JDOCK1.152 155.55,129.9 ; JDOCK1.152 153.45,129.9 ; JDOCK1.152 153.45,128.93
  GND2 w0.203: PBATT1.8 155.31,3.11 ; PBATT1.8 154.5,1.22 ; PBATT1.8 154.5,3.38 ; PBATT1.8 153.69,3.11 ; PBATT1.8 155.31,1.49 ; PBATT1.8 153.69,1.49 ; 133.94,127.98 JDOCK1.151 ; JDOCK1.151 136,129.87 ; JDOCK1.151 138.06,127.98 ; JDOCK1.151 133.94,129.87 ; JDOCK1.151 136,127.98 ; JDOCK1.151 138.06,128.93 ; JDOCK1.151 133.94,128.93 ; 86.05,87.41 H9.1 ; H9.1 85.41,89.11 ; H9.1 89.45,90.81 ; H9.1 87.75,91.45 ; H9.1 90.09,89.11 ; H9.1 86.05,90.81 ; H9.1 89.45,87.41 ; H9.1 87.75,86.77 ; JMDP1.23 254.33,129.84 ; JMDP1.23 254.33,128.53 ; JMDP1.23 253.55,128.53 ; JMDP1.23 252.77,129.84 ; JMDP1.23 254.33,131.15 ; JMDP1.23 252.77,128.53 ; JMDP1.23 252.77,131.15 ; JMDP1.23 253.55,131.15 ; H3.1 129.24,137.01 ; H3.1 127.9,136.52 ; H3.1 126.56,137.01 ; H3.1 129.73,138.35 ; H3.1 127.9,140.18 ; H3.1 129.24,139.69 ; H3.1 126.07,138.35 ; H3.1 126.56,139.69 ; 134.41,132.85 JDOCK1.145 ; JDOCK1.145 135.33,131 ; JDOCK1.145 135.33,134.7 ; JDOCK1.145 134.41,134.7 ; JDOCK1.145 134.41,131 ; JHDMI1.23 100.59,138.15 ; JHDMI1.23 99.71,136.68 ; JHDMI1.23 100.59,136.68 ; JHDMI1.23 99.71,139.62 ; JHDMI1.23 98.83,136.68 ; JHDMI1.23 98.83,139.62 ; JHDMI1.23 98.83,138.15 ; JHDMI1.23 100.59,139.62 ; JLOM1.16 284.87,137.2 ; JLOM1.16 283.96,135.45 ; JLOM1.16 283.96,133.7 ; JLOM1.16 284.87,133.7 ; JLOM1.16 283.96,137.2 ; 149.38,0.67 PBATT1.10 ; PBATT1.10 150.35,4.43 ; PBATT1.10 148.4,4.43 ; PBATT1.10 149.38,4.43 ; PBATT1.10 148.4,2.55 ; PBATT1.10 150.35,2.55 ; PBATT1.10 148.4,0.67 ; PBATT1.10 150.35,0.67 ; JUSB2.11 236.9,137.5 ; JUSB2.11 237.78,134.76 ; JUSB2.11 237.78,137.5 ; JUSB2.11 236.9,134.76 ; JUSB2.11 237.78,136.13 ; JUSB2.4 226.38,127.04 ; JUSB2.4 224.92,126.4 ; JUSB2.4 225.55,126.21 ; JUSB2.4 226.19,127.67 ; JUSB2.4 226.19,126.4 ; JUSB2.4 224.72,127.04 ; 178.1,116.2 H22.1 ; H22.1 181,113.3 ; H22.1 178.1,113.3 ; H22.1 179.55,116.73 ; H22.1 181,116.2 ; H22.1 179.55,112.77 ; H22.1 181.53,114.75 ; H22.1 177.57,114.75 ; H8.1 87.75,71.13 ; H8.1 85.41,68.79 ; H8.1 89.45,70.49 ; H8.1 89.45,67.09 ; H8.1 87.75,66.45 ; H8.1 86.05,67.09 ; H8.1 90.09,68.79 ; H8.1 86.05,70.49 ; PBATT1.7 156.5,3.38 ; PBATT1.7 155.69,1.49 ; PBATT1.7 157.31,3.11 ; PBATT1.7 155.69,3.11 ; PBATT1.7 156.5,1.22 ; PBATT1.7 157.31,1.49 ; JDOCK1.154 187.06,128.93 ; JDOCK1.154 187.06,127.98 ; JDOCK1.154 187.06,129.87 ; JDOCK1.154 185,129.87 ; JDOCK1.154 185,127.98 ; JDOCK1.154 182.94,128.93 ; JDOCK1.154 182.94,127.98 ; JUSB1.4 63.48,127.04 ; JUSB1.4 62.02,126.4 ; JUSB1.4 61.82,127.04 ; JUSB1.4 63.29,127.67 ; JUSB1.4 63.29,126.4 ; JUSB1.4 62.65,126.21 ; 93.96,131.49 JHDMI1.17 ; JHDMI1.17 93.5,131.61 ; JHDMI1.17 94.42,132.53 ; JHDMI1.17 93.96,132.65 ; JHDMI1.17 93.5,132.53 ; JHDMI1.17 94.42,131.61 ; H7.1 152.96,70.49 ; H7.1 151.25,66.45 ; H7.1 153.59,68.79 ; H7.1 151.25,71.13 ; H7.1 148.92,68.79 ; H7.1 149.55,67.09 ; H7.1 149.55,70.49 ; H7.1 152.96,67.09 ; JHDMI1.8 89.92,131.33 ; JHDMI1.8 89.46,131.45 ; JHDMI1.8 89,131.33 ; JHDMI1.8 89,130.41 ; JHDMI1.8 89.46,130.29 ; JHDMI1.8 89.92,130.41 ; 213.45,101.77 H21.1 ; H21.1 211.47,103.75 ; H21.1 214.9,102.3 ; H21.1 215.43,103.75 ; H21.1 214.9,105.2 ; H21.1 212,102.3 ; H21.1 213.45,105.73 ; H21.1 212,105.2 ; JMDP1.1 246.31,132.3 ; JMDP1.1 245.85,132.42 ; JMDP1.1 246.31,131.38 ; JMDP1.1 245.39,132.3 ; JMDP1.1 245.27,131.84 ; JMDP1.1 245.39,131.38 ; JMDP1.1 245.85,131.26 ; 229.05,127.71 JUSB2.7 ; JUSB2.7 229.88,128.54 ; JUSB2.7 229.69,127.91 ; JUSB2.7 228.42,127.91 ; JUSB2.7 228.22,128.54 ; 133.94,136.78 JDOCK1.155 ; JDOCK1.155 138.06,136.78 ; JDOCK1.155 138.06,137.72 ; JDOCK1.155 136,137.72 ; JDOCK1.155 136,135.83 ; JDOCK1.155 133.94,135.83 ; JDOCK1.155 133.94,137.72 ; H15.1 46.84,35.39 ; H15.1 46.84,32.71 ; H15.1 45.5,32.22 ; H15.1 44.16,32.71 ; H15.1 44.16,35.39 ; H15.1 43.67,34.05 ; H15.1 45.5,35.88 ; H15.1 47.33,34.05 ; 57.42,128.63 JUSB1.13 ; JUSB1.13 59.18,128.63 ; JUSB1.13 58.3,127.16 ; JUSB1.13 58.3,130.1 ; JUSB1.13 57.42,130.1 ; JUSB1.13 59.18,127.16 ; JUSB1.13 57.42,127.16 ; 100.01,19.29 H16.1 ; H16.1 103.18,17.95 ; H16.1 102.69,16.61 ; H16.1 102.69,19.29 ; H16.1 100.01,16.61 ; H16.1 101.35,16.12 ; H16.1 101.35,19.78 ; H16.1 99.52,17.95 ; 153.45,135.8 JDOCK1.160 ; JDOCK1.160 155.55,135.8 ; JDOCK1.160 154.5,137.75 ; JDOCK1.160 154.5,135.8 ; JDOCK1.160 153.45,137.75 ; JDOCK1.160 153.45,136.78 ; JDOCK1.160 155.55,136.78 ; JDOCK1.160 155.55,137.75 ; JDOCK1.152 154.5,129.9 ; JDOCK1.152 154.5,127.95 ; JDOCK1.152 155.55,127.95 ; JDOCK1.152 155.55,129.9 ; JDOCK1.152 153.45,127.95 ; JDOCK1.152 153.45,129.9 ; JDOCK1.152 155.55,128.93 ; JDOCK1.152 153.45,128.93 ; 141.7,133.65 JDOCK1.156 ; JDOCK1.156 142.5,133.9 ; JDOCK1.156 143.3,133.65 ; JDOCK1.156 141.45,132.85 ; JDOCK1.156 143.55,132.85 ; JDOCK1.156 141.7,132.05 ; JDOCK1.156 143.3,132.05 ; JDOCK1.156 142.5,131.8 ; 220.32,130.1 JUSB2.13 ; JUSB2.13 222.08,128.63 ; JUSB2.13 221.2,130.1 ; JUSB2.13 222.08,127.16 ; JUSB2.13 220.32,128.63 ; JUSB2.13 221.2,127.16 ; JUSB2.10 236.9,130.1 ; JUSB2.10 236.9,127.16 ; JUSB2.10 237.78,127.16 ; JUSB2.10 236.02,127.16 ; JUSB2.10 237.78,130.1 ; JUSB2.10 237.78,128.63 ; JUSB2.10 236.02,128.63 ; PBATT1.11 172.6,0.67 ; PBATT1.11 170.65,2.55 ; PBATT1.11 172.6,4.43 ; PBATT1.11 170.65,4.43 ; PBATT1.11 172.6,2.55 ; PBATT1.11 171.63,4.43 ; PBATT1.11 171.63,0.67 ; PBATT1.11 170.65,0.67 ; 226.16,16.11 H14.1 ; H14.1 228.84,16.11 ; H14.1 228.84,18.79 ; H14.1 225.67,17.45 ; H14.1 227.5,19.28 ; H14.1 227.5,15.62 ; H14.1 226.16,18.79 ; H14.1 229.33,17.45 ; 85.88,130.87 JHDMI1.2 ; JHDMI1.2 86,130.41 ; JHDMI1.2 86,131.33 ; JHDMI1.2 86.92,130.41 ; JHDMI1.2 86.46,131.45 ; JHDMI1.2 86.92,131.33 ; JHDMI1.2 86.46,130.29 ; JUSB1.7 66.98,128.54 ; JUSB1.7 66.15,127.71 ; JUSB1.7 65.32,128.54 ; JUSB1.7 65.52,127.91 ; JUSB1.7 66.79,127.91 ; JHDMI1.11 91.42,131.61 ; JHDMI1.11 90.5,132.53 ; JHDMI1.11 91.42,132.53 ; JHDMI1.11 90.96,132.65 ; JHDMI1.11 90.96,131.49 ; JHDMI1.11 90.5,131.61 ; JDOCK1.148 186.59,134.7 ; JDOCK1.148 186.59,132.85 ; JDOCK1.148 185.68,134.7 ; JDOCK1.148 185.68,131 ; JDOCK1.148 186.59,131 ; 249.09,131.1 JMDP1.13 ; JMDP1.13 250.01,131.1 ; JMDP1.13 249.55,130.06 ; JMDP1.13 250.01,130.18 ; JMDP1.13 248.97,130.64 ; JMDP1.13 249.09,130.18 ; JMDP1.13 249.55,131.23 ; 165.45,136.78 JDOCK1.161 ; JDOCK1.161 166.5,135.8 ; JDOCK1.161 166.5,137.75 ; JDOCK1.161 165.45,135.8 ; JDOCK1.161 167.55,136.78 ; JDOCK1.161 167.55,135.8 ; JDOCK1.161 167.55,137.75 ; JDOCK1.161 165.45,137.75 ; 165.45,127.95 JDOCK1.153 ; JDOCK1.153 167.55,127.95 ; JDOCK1.153 166.5,129.9 ; JDOCK1.153 165.45,129.9 ; JDOCK1.153 167.55,129.9 ; JDOCK1.153 166.5,127.95 ; JDOCK1.153 167.55,128.93 ; JDOCK1.153 165.45,128.93 ; JUSB1.10 74.88,130.1 ; JUSB1.10 74.88,127.16 ; JUSB1.10 73.12,128.63 ; JUSB1.10 74.88,128.63 ; JUSB1.10 73.12,127.16 ; JUSB1.10 74,130.1 ; JUSB1.10 74,127.16 ; 250.79,131.38 JMDP1.19 ; JMDP1.19 250.79,132.3 ; JMDP1.19 251.83,131.84 ; JMDP1.19 251.25,131.26 ; JMDP1.19 251.25,132.42 ; JMDP1.19 251.71,131.38 ; JMDP1.19 251.71,132.3 ; 243.55,128.53 JMDP1.24 ; JMDP1.24 244.33,131.15 ; JMDP1.24 244.33,129.84 ; JMDP1.24 242.77,128.53 ; JMDP1.24 242.77,129.84 ; JMDP1.24 243.55,131.15 ; JMDP1.24 242.77,131.15 ; JMDP1.24 244.33,128.53 ; 51.5,132.12 H1.1 ; H1.1 53.33,133.95 ; H1.1 50.16,135.29 ; H1.1 50.16,132.61 ; H1.1 49.67,133.95 ; H1.1 52.84,135.29 ; H1.1 52.84,132.61 ; H1.1 51.5,135.78 ; 231,111.42 H6.1 ; H6.1 229.66,111.91 ; H6.1 229.17,113.25 ; H6.1 232.83,113.25 ; H6.1 231,115.08 ; H6.1 232.34,114.59 ; H6.1 229.66,114.59 ; H18.1 227.64,54.45 ; H18.1 224.03,52.93 ; H18.1 224.59,54.45 ; H18.1 224.59,51.4 ; H18.1 226.12,55.01 ; H18.1 227.64,51.4 ; H18.1 228.2,52.93 ; H18.1 226.12,50.84 ; H2.1 104.84,135.79 ; H2.1 101.67,134.45 ; H2.1 102.16,135.79 ; H2.1 102.16,133.11 ; H2.1 103.5,132.62 ; H2.1 104.84,133.11 ; H2.1 105.33,134.45 ; H2.1 103.5,136.28 ; 165.7,132.05 JDOCK1.158 ; JDOCK1.158 167.3,132.05 ; JDOCK1.158 167.55,132.85 ; JDOCK1.158 166.5,133.9 ; JDOCK1.158 165.7,133.65 ; JDOCK1.158 166.5,131.8 ; JDOCK1.158 167.3,133.65 ; JDOCK1.158 165.45,132.85 ; SW1.4 123.85,18.34 ; SW1.4 123.6,17.58 ; SW1.4 122.08,17.58 ; SW1.4 121.84,18.34 ; SW1.4 122.84,19.35 ; SW1.4 122.08,19.1 ; SW1.4 123.6,19.1 ; SW1.4 122.84,17.34 ; 153.7,133.65 JDOCK1.157 ; JDOCK1.157 153.45,132.85 ; JDOCK1.157 153.7,132.05 ; JDOCK1.157 155.3,133.65 ; JDOCK1.157 155.55,132.85 ; JDOCK1.157 155.3,132.05 ; JDOCK1.157 154.5,131.8 ; JDOCK1.157 154.5,133.9 ; JDOCK1.159 179.3,133.65 ; JDOCK1.159 179.55,132.85 ; JDOCK1.159 178.5,131.8 ; JDOCK1.159 177.7,133.65 ; JDOCK1.159 178.5,133.9 ; JDOCK1.159 177.45,132.85 ; JDOCK1.159 179.3,132.05 ; JDOCK1.159 177.7,132.05 ; H4.1 218.84,134.79 ; H4.1 219.33,133.45 ; H4.1 216.16,132.11 ; H4.1 217.5,135.28 ; H4.1 215.67,133.45 ; H4.1 218.84,132.11 ; H4.1 217.5,131.62 ; H4.1 216.16,134.79 ; 74,134.76 JUSB1.11 ; JUSB1.11 74.88,136.13 ; JUSB1.11 74.88,134.76 ; JUSB1.11 74.88,137.5 ; JUSB1.11 74,137.5 ; 157.69,3.11 PBATT1.6 ; PBATT1.6 158.5,1.22 ; PBATT1.6 157.69,1.49 ; PBATT1.6 158.5,3.38 ; PBATT1.6 159.31,1.49 ; PBATT1.6 159.31,3.11 ; 126.07,106.45 H11.1 ; H11.1 127.9,104.62 ; H11.1 129.24,105.11 ; H11.1 126.56,105.11 ; H11.1 129.24,107.79 ; H11.1 129.73,106.45 ; H11.1 127.9,108.28 ; H11.1 126.56,107.79 ; JMDP1.22 253.55,135.68 ; JMDP1.22 254.33,133.06 ; JMDP1.22 254.33,135.68 ; JMDP1.22 254.33,134.37 ; JMDP1.22 253.55,133.06 ; H12.1 193.1,140.18 ; H12.1 194.44,139.69 ; H12.1 191.76,137.01 ; H12.1 191.27,138.35 ; H12.1 191.76,139.69 ; H12.1 194.44,137.01 ; H12.1 193.1,136.52 ; H12.1 194.93,138.35 ; JHDMI1.21 98.59,131.3 ; JHDMI1.21 96.83,132.88 ; JHDMI1.21 96.83,129.72 ; JHDMI1.21 98.59,129.72 ; JHDMI1.21 97.71,132.88 ; JHDMI1.21 97.71,129.72 ; JHDMI1.21 96.83,131.3 ; JHDMI1.21 98.59,132.88 ; 9.1,44.32 H5.1 ; H5.1 7.27,46.15 ; H5.1 9.1,47.98 ; H5.1 10.44,44.81 ; H5.1 7.76,47.49 ; H5.1 10.44,47.49 ; H5.1 7.76,44.81 ; H5.1 10.93,46.15 ; 182.94,136.78 JDOCK1.162 ; JDOCK1.162 187.06,135.83 ; JDOCK1.162 182.94,137.72 ; JDOCK1.162 185,135.83 ; JDOCK1.162 185,137.72 ; JDOCK1.162 187.06,136.78 ; JDOCK1.162 187.06,137.72 ; 128.38,17.58 SW1.5 ; SW1.5 130.15,18.34 ; SW1.5 128.14,18.34 ; SW1.5 129.9,17.58 ; SW1.5 129.14,19.35 ; SW1.5 128.38,19.1 ; SW1.5 129.9,19.1 ; SW1.5 129.14,17.34 ; 73.72,68.17 H19.1 ; H19.1 73.72,72.33 ; H19.1 75.24,68.73 ; H19.1 71.63,70.25 ; H19.1 75.8,70.25 ; H19.1 75.24,71.77 ; H19.1 72.19,71.77 ; H19.1 72.19,68.73 ; 87.5,131.61 JHDMI1.5 ; JHDMI1.5 87.96,132.65 ; JHDMI1.5 87.96,131.49 ; JHDMI1.5 88.42,132.53 ; JHDMI1.5 87.5,132.53 ; JHDMI1.5 88.42,131.61 ; 151.69,3.11 PBATT1.9 ; PBATT1.9 152.5,1.22 ; PBATT1.9 153.31,3.11 ; PBATT1.9 152.5,3.38 ; PBATT1.9 151.69,1.49 ; PBATT1.9 153.31,1.49 ; PBATT1.9 151.42,2.3 ; 8.36,6.61 H13.1 ; H13.1 7.87,7.95 ; H13.1 11.04,9.29 ; H13.1 11.04,6.61 ; H13.1 11.53,7.95 ; H13.1 8.36,9.29 ; H13.1 9.7,6.12 ; H13.1 9.7,9.78 ; 220.32,136.13 JUSB2.12 ; JUSB2.12 220.32,137.5 ; JUSB2.12 221.2,137.5 ; JUSB2.12 221.2,134.76 ; JUSB2.12 220.32,134.76 ; 242.77,133.06 JMDP1.21 ; JMDP1.21 242.77,134.37 ; JMDP1.21 243.55,133.06 ; JMDP1.21 242.77,135.68 ; JMDP1.21 243.55,135.68 ; 80.33,138.15 JHDMI1.22 ; JHDMI1.22 80.33,136.68 ; JHDMI1.22 82.09,139.62 ; JHDMI1.22 81.21,139.62 ; JHDMI1.22 82.09,138.15 ; JHDMI1.22 81.21,136.68 ; JHDMI1.22 82.09,136.68 ; 82.33,129.72 JHDMI1.20 ; JHDMI1.20 84.09,131.3 ; JHDMI1.20 84.09,129.72 ; JHDMI1.20 83.21,132.88 ; JHDMI1.20 82.33,132.88 ; JHDMI1.20 84.09,132.88 ; JHDMI1.20 82.33,131.3 ; JHDMI1.20 83.21,129.72 ; 149.55,87.41 H10.1 ; H10.1 152.95,87.41 ; H10.1 152.95,90.81 ; H10.1 151.25,86.77 ; H10.1 153.59,89.11 ; H10.1 149.55,90.81 ; H10.1 148.91,89.11 ; H10.1 151.25,91.45 ; JMDP1.7 248.01,130.18 ; JMDP1.7 247.09,130.18 ; JMDP1.7 248.01,131.1 ; JMDP1.7 247.55,131.23 ; JMDP1.7 247.55,130.06 ; JMDP1.7 247.09,131.1 ; JMDP1.7 248.13,130.64 ; H27.1 178.09,2.99 ; H27.1 174.92,1.65 ; H27.1 175.41,2.99 ; H27.1 176.75,3.48 ; 57.42,136.13 JUSB1.12 ; JUSB1.12 58.3,134.76 ; JUSB1.12 58.3,137.5 ; JUSB1.12 57.42,137.5 ; JUSB1.12 57.42,134.76 ; 260.77,137.26 H23.1 ; H23.1 260.77,138.75 ; H23.1 262.5,140.24 ; H23.1 262.5,137.26 ; H23.1 264.23,140.24 ; H23.1 260.77,140.24 ; H23.1 264.23,138.75 ; H23.1 264.23,137.26
  GND3 w0.203: 57.42,130.1 JUSB1.13 ; JUSB1.13 58.3,127.16 ; JUSB1.13 57.42,128.63 ; JUSB1.13 57.42,127.16 ; JUSB1.13 59.18,128.63 ; JUSB1.13 58.3,130.1 ; JUSB1.13 59.18,127.16 ; H13.1 11.53,7.95 ; H13.1 11.04,9.29 ; H13.1 8.36,6.61 ; H13.1 9.7,9.78 ; H13.1 7.87,7.95 ; H13.1 8.36,9.29 ; H13.1 9.7,6.12 ; H13.1 11.04,6.61 ; JUSB2.4 226.38,127.04 ; JUSB2.4 226.19,127.67 ; JUSB2.4 224.92,126.4 ; JUSB2.4 226.19,126.4 ; JUSB2.4 225.55,126.21 ; JUSB2.4 224.72,127.04 ; 249.09,130.18 JMDP1.13 ; JMDP1.13 250.01,131.1 ; JMDP1.13 249.55,130.06 ; JMDP1.13 248.97,130.64 ; JMDP1.13 249.09,131.1 ; JMDP1.13 249.55,131.23 ; JMDP1.13 250.01,130.18 ; JMDP1.24 244.33,129.84 ; JMDP1.24 244.33,128.53 ; JMDP1.24 243.55,128.53 ; JMDP1.24 243.55,131.15 ; JMDP1.24 244.33,131.15 ; JMDP1.24 242.77,128.53 ; JMDP1.24 242.77,129.84 ; JMDP1.24 242.77,131.15 ; H19.1 75.8,70.25 ; H19.1 73.72,68.17 ; H19.1 75.24,68.73 ; H19.1 75.24,71.77 ; H19.1 72.19,71.77 ; H19.1 71.63,70.25 ; H19.1 72.19,68.73 ; H19.1 73.72,72.33 ; 153.45,136.78 JDOCK1.160 ; JDOCK1.160 154.5,137.75 ; JDOCK1.160 154.5,135.8 ; JDOCK1.160 153.45,135.8 ; JDOCK1.160 155.55,135.8 ; JDOCK1.160 155.55,137.75 ; JDOCK1.160 153.45,137.75 ; JDOCK1.160 155.55,136.78 ; JHDMI1.22 82.09,136.68 ; JHDMI1.22 80.33,136.68 ; JHDMI1.22 81.21,139.62 ; JHDMI1.22 82.09,138.15 ; JHDMI1.22 81.21,136.68 ; JHDMI1.22 82.09,139.62 ; JHDMI1.22 80.33,138.15 ; JDOCK1.158 166.5,133.9 ; JDOCK1.158 165.45,132.85 ; JDOCK1.158 167.55,132.85 ; JDOCK1.158 165.7,133.65 ; JDOCK1.158 167.3,133.65 ; JDOCK1.158 165.7,132.05 ; JDOCK1.158 166.5,131.8 ; JDOCK1.158 167.3,132.05 ; 128.38,19.1 SW1.5 ; SW1.5 129.9,17.58 ; SW1.5 130.15,18.34 ; SW1.5 129.14,17.34 ; SW1.5 128.38,17.58 ; SW1.5 129.14,19.35 ; SW1.5 128.14,18.34 ; SW1.5 129.9,19.1 ; 247.09,130.18 JMDP1.7 ; JMDP1.7 248.13,130.64 ; JMDP1.7 247.55,130.06 ; JMDP1.7 247.09,131.1 ; JMDP1.7 248.01,130.18 ; JMDP1.7 248.01,131.1 ; JMDP1.7 247.55,131.23 ; 156.5,1.22 PBATT1.7 ; PBATT1.7 157.31,1.49 ; PBATT1.7 155.69,1.49 ; PBATT1.7 155.69,3.11 ; PBATT1.7 157.31,3.11 ; PBATT1.7 156.5,3.38 ; 154.5,127.95 JDOCK1.152 ; JDOCK1.152 155.55,128.93 ; JDOCK1.152 153.45,129.9 ; JDOCK1.152 154.5,129.9 ; JDOCK1.152 153.45,127.95 ; JDOCK1.152 155.55,129.9 ; JDOCK1.152 153.45,128.93 ; JDOCK1.152 155.55,127.95 ; 51.5,132.12 H1.1 ; H1.1 53.33,133.95 ; H1.1 52.84,132.61 ; H1.1 49.67,133.95 ; H1.1 50.16,132.61 ; H1.1 52.84,135.29 ; H1.1 51.5,135.78 ; H1.1 50.16,135.29 ; 136,135.83 JDOCK1.155 ; JDOCK1.155 138.06,137.72 ; JDOCK1.155 136,137.72 ; JDOCK1.155 133.94,135.83 ; JDOCK1.155 133.94,136.78 ; JDOCK1.155 133.94,137.72 ; JDOCK1.155 138.06,136.78 ; JUSB1.10 74,130.1 ; JUSB1.10 74.88,127.16 ; JUSB1.10 74.88,130.1 ; JUSB1.10 74.88,128.63 ; JUSB1.10 74,127.16 ; JUSB1.10 73.12,127.16 ; JUSB1.10 73.12,128.63 ; 165.45,135.8 JDOCK1.161 ; JDOCK1.161 167.55,137.75 ; JDOCK1.161 166.5,137.75 ; JDOCK1.161 166.5,135.8 ; JDOCK1.161 167.55,136.78 ; JDOCK1.161 167.55,135.8 ; JDOCK1.161 165.45,136.78 ; JDOCK1.161 165.45,137.75 ; 90.96,131.49 JHDMI1.11 ; JHDMI1.11 91.42,132.53 ; JHDMI1.11 90.5,131.61 ; JHDMI1.11 90.5,132.53 ; JHDMI1.11 91.42,131.61 ; JHDMI1.11 90.96,132.65 ; 96.83,132.88 JHDMI1.21 ; JHDMI1.21 97.71,132.88 ; JHDMI1.21 98.59,131.3 ; JHDMI1.21 96.83,131.3 ; JHDMI1.21 96.83,129.72 ; JHDMI1.21 98.59,132.88 ; JHDMI1.21 98.59,129.72 ; JHDMI1.21 97.71,129.72 ; PBATT1.10 150.35,2.55 ; PBATT1.10 150.35,0.67 ; PBATT1.10 150.35,4.43 ; PBATT1.10 148.4,2.55 ; PBATT1.10 148.4,4.43 ; PBATT1.10 148.4,0.67 ; PBATT1.10 149.38,0.67 ; PBATT1.10 149.38,4.43 ; 86,131.33 JHDMI1.2 ; JHDMI1.2 86.46,131.45 ; JHDMI1.2 85.88,130.87 ; JHDMI1.2 86.92,131.33 ; JHDMI1.2 86,130.41 ; JHDMI1.2 86.46,130.29 ; JHDMI1.2 86.92,130.41 ; H18.1 226.12,55.01 ; H18.1 226.12,50.84 ; H18.1 224.59,51.4 ; H18.1 224.59,54.45 ; H18.1 227.64,54.45 ; H18.1 227.64,51.4 ; H18.1 228.2,52.93 ; H18.1 224.03,52.93 ; H2.1 104.84,135.79 ; H2.1 102.16,135.79 ; H2.1 101.67,134.45 ; H2.1 105.33,134.45 ; H2.1 102.16,133.11 ; H2.1 104.84,133.11 ; H2.1 103.5,132.62 ; H2.1 103.5,136.28 ; 57.42,134.76 JUSB1.12 ; JUSB1.12 58.3,134.76 ; JUSB1.12 57.42,136.13 ; JUSB1.12 58.3,137.5 ; JUSB1.12 57.42,137.5 ; H9.1 89.45,90.81 ; H9.1 87.75,86.77 ; H9.1 89.45,87.41 ; H9.1 87.75,91.45 ; H9.1 90.09,89.11 ; H9.1 86.05,87.41 ; H9.1 86.05,90.81 ; H9.1 85.41,89.11 ; 170.65,2.55 PBATT1.11 ; PBATT1.11 172.6,0.67 ; PBATT1.11 170.65,0.67 ; PBATT1.11 172.6,4.43 ; PBATT1.11 171.63,4.43 ; PBATT1.11 171.63,0.67 ; PBATT1.11 170.65,4.43 ; PBATT1.11 172.6,2.55 ; H4.1 218.84,134.79 ; H4.1 219.33,133.45 ; H4.1 217.5,135.28 ; H4.1 218.84,132.11 ; H4.1 216.16,134.79 ; H4.1 216.16,132.11 ; H4.1 215.67,133.45 ; H4.1 217.5,131.62 ; JDOCK1.157 155.3,133.65 ; JDOCK1.157 154.5,131.8 ; JDOCK1.157 155.3,132.05 ; JDOCK1.157 155.55,132.85 ; JDOCK1.157 154.5,133.9 ; JDOCK1.157 153.7,133.65 ; JDOCK1.157 153.45,132.85 ; JDOCK1.157 153.7,132.05 ; 242.77,133.06 JMDP1.21 ; JMDP1.21 243.55,133.06 ; JMDP1.21 242.77,134.37 ; JMDP1.21 243.55,135.68 ; JMDP1.21 242.77,135.68 ; 185.68,131 JDOCK1.148 ; JDOCK1.148 186.59,134.7 ; JDOCK1.148 186.59,132.85 ; JDOCK1.148 186.59,131 ; JDOCK1.148 185.68,134.7 ; H23.1 264.23,137.26 ; H23.1 264.23,138.75 ; H23.1 262.5,137.26 ; H23.1 260.77,140.24 ; H23.1 262.5,140.24 ; H23.1 260.77,137.26 ; H23.1 264.23,140.24 ; H23.1 260.77,138.75 ; H14.1 228.84,18.79 ; H14.1 226.16,18.79 ; H14.1 228.84,16.11 ; H14.1 227.5,19.28 ; H14.1 226.16,16.11 ; H14.1 225.67,17.45 ; H14.1 227.5,15.62 ; H14.1 229.33,17.45 ; H12.1 193.1,140.18 ; H12.1 194.44,137.01 ; H12.1 194.44,139.69 ; H12.1 191.76,139.69 ; H12.1 193.1,136.52 ; H12.1 191.27,138.35 ; H12.1 194.93,138.35 ; H12.1 191.76,137.01 ; H7.1 153.59,68.79 ; H7.1 149.55,67.09 ; H7.1 152.96,67.09 ; H7.1 151.25,71.13 ; H7.1 148.92,68.79 ; H7.1 152.96,70.49 ; H7.1 149.55,70.49 ; H7.1 151.25,66.45 ; JHDMI1.20 84.09,132.88 ; JHDMI1.20 83.21,129.72 ; JHDMI1.20 82.33,131.3 ; JHDMI1.20 82.33,132.88 ; JHDMI1.20 84.09,129.72 ; JHDMI1.20 82.33,129.72 ; JHDMI1.20 84.09,131.3 ; JHDMI1.20 83.21,132.88 ; 179.55,112.77 H22.1 ; H22.1 181,116.2 ; H22.1 179.55,116.73 ; H22.1 178.1,116.2 ; H22.1 178.1,113.3 ; H22.1 181,113.3 ; H22.1 177.57,114.75 ; H22.1 181.53,114.75 ; H16.1 103.18,17.95 ; H16.1 100.01,19.29 ; H16.1 99.52,17.95 ; H16.1 101.35,19.78 ; H16.1 102.69,19.29 ; H16.1 100.01,16.61 ; H16.1 102.69,16.61 ; H16.1 101.35,16.12 ; 149.55,90.81 H10.1 ; H10.1 153.59,89.11 ; H10.1 152.95,87.41 ; H10.1 151.25,91.45 ; H10.1 151.25,86.77 ; H10.1 149.55,87.41 ; H10.1 148.91,89.11 ; H10.1 152.95,90.81 ; 182.94,127.98 JDOCK1.154 ; JDOCK1.154 187.06,129.87 ; JDOCK1.154 182.94,128.93 ; JDOCK1.154 187.06,128.93 ; JDOCK1.154 187.06,127.98 ; JDOCK1.154 185,129.87 ; JDOCK1.154 185,127.98 ; 62.02,126.4 JUSB1.4 ; JUSB1.4 63.29,127.67 ; JUSB1.4 63.29,126.4 ; JUSB1.4 61.82,127.04 ; JUSB1.4 63.48,127.04 ; JUSB1.4 62.65,126.21 ; JUSB2.13 221.2,130.1 ; JUSB2.13 220.32,128.63 ; JUSB2.13 222.08,128.63 ; JUSB2.13 222.08,127.16 ; JUSB2.13 221.2,127.16 ; JUSB2.13 220.32,130.1 ; 89,131.33 JHDMI1.8 ; JHDMI1.8 89.92,131.33 ; JHDMI1.8 89.46,130.29 ; JHDMI1.8 89.46,131.45 ; JHDMI1.8 89.92,130.41 ; JHDMI1.8 89,130.41 ; PBATT1.6 159.31,1.49 ; PBATT1.6 157.69,3.11 ; PBATT1.6 159.31,3.11 ; PBATT1.6 158.5,3.38 ; PBATT1.6 158.5,1.22 ; PBATT1.6 157.69,1.49 ; 122.84,17.34 SW1.4 ; SW1.4 122.84,19.35 ; SW1.4 123.6,19.1 ; SW1.4 122.08,19.1 ; SW1.4 121.84,18.34 ; SW1.4 122.08,17.58 ; SW1.4 123.85,18.34 ; SW1.4 123.6,17.58 ; H5.1 10.44,47.49 ; H5.1 7.76,47.49 ; H5.1 7.27,46.15 ; H5.1 10.44,44.81 ; H5.1 10.93,46.15 ; H5.1 9.1,47.98 ; H5.1 9.1,44.32 ; H5.1 7.76,44.81 ; JMDP1.19 251.71,132.3 ; JMDP1.19 251.25,131.26 ; JMDP1.19 251.25,132.42 ; JMDP1.19 250.79,131.38 ; JMDP1.19 250.79,132.3 ; JMDP1.19 251.83,131.84 ; JMDP1.19 251.71,131.38 ; H11.1 129.24,105.11 ; H11.1 126.56,107.79 ; H11.1 126.56,105.11 ; H11.1 129.73,106.45 ; H11.1 127.9,108.28 ; H11.1 127.9,104.62 ; H11.1 126.07,106.45 ; H11.1 129.24,107.79 ; JUSB2.12 221.2,137.5 ; JUSB2.12 220.32,134.76 ; JUSB2.12 221.2,134.76 ; JUSB2.12 220.32,137.5 ; JUSB2.12 220.32,136.13 ; H6.1 232.34,114.59 ; H6.1 232.83,113.25 ; H6.1 229.66,111.91 ; H6.1 231,111.42 ; H6.1 231,115.08 ; H6.1 229.66,114.59 ; H6.1 229.17,113.25 ; 182.94,136.78 JDOCK1.162 ; JDOCK1.162 185,135.83 ; JDOCK1.162 187.06,135.83 ; JDOCK1.162 182.94,137.72 ; JDOCK1.162 185,137.72 ; JDOCK1.162 187.06,136.78 ; JDOCK1.162 187.06,137.72 ; JUSB1.7 66.98,128.54 ; JUSB1.7 65.52,127.91 ; JUSB1.7 66.79,127.91 ; JUSB1.7 65.32,128.54 ; JUSB1.7 66.15,127.71 ; 245.27,131.84 JMDP1.1 ; JMDP1.1 246.31,131.38 ; JMDP1.1 245.85,132.42 ; JMDP1.1 245.85,131.26 ; JMDP1.1 246.31,132.3 ; JMDP1.1 245.39,132.3 ; JMDP1.1 245.39,131.38 ; 136,127.98 JDOCK1.151 ; JDOCK1.151 138.06,128.93 ; JDOCK1.151 138.06,127.98 ; JDOCK1.151 133.94,129.87 ; JDOCK1.151 133.94,127.98 ; JDOCK1.151 133.94,128.93 ; JDOCK1.151 136,129.87 ; 141.7,133.65 JDOCK1.156 ; JDOCK1.156 141.7,132.05 ; JDOCK1.156 143.55,132.85 ; JDOCK1.156 142.5,133.9 ; JDOCK1.156 141.45,132.85 ; JDOCK1.156 142.5,131.8 ; JDOCK1.156 143.3,132.05 ; JDOCK1.156 143.3,133.65 ; 126.07,138.35 H3.1 ; H3.1 127.9,140.18 ; H3.1 126.56,137.01 ; H3.1 129.73,138.35 ; H3.1 129.24,137.01 ; H3.1 126.56,139.69 ; H3.1 127.9,136.52 ; H3.1 129.24,139.69 ; PBATT1.8 154.5,3.38 ; PBATT1.8 155.31,1.49 ; PBATT1.8 153.69,1.49 ; PBATT1.8 154.5,1.22 ; PBATT1.8 155.31,3.11 ; PBATT1.8 153.69,3.11 ; H15.1 46.84,32.71 ; H15.1 43.67,34.05 ; H15.1 46.84,35.39 ; H15.1 44.16,32.71 ; H15.1 45.5,32.22 ; H15.1 44.16,35.39 ; H15.1 45.5,35.88 ; H15.1 47.33,34.05 ; JDOCK1.159 179.55,132.85 ; JDOCK1.159 178.5,131.8 ; JDOCK1.159 177.45,132.85 ; JDOCK1.159 178.5,133.9 ; JDOCK1.159 179.3,133.65 ; JDOCK1.159 177.7,132.05 ; JDOCK1.159 177.7,133.65 ; JDOCK1.159 179.3,132.05 ; PBATT1.9 153.31,3.11 ; PBATT1.9 151.69,1.49 ; PBATT1.9 151.42,2.3 ; PBATT1.9 153.31,1.49 ; PBATT1.9 152.5,3.38 ; PBATT1.9 151.69,3.11 ; PBATT1.9 152.5,1.22 ; JUSB1.11 74.88,136.13 ; JUSB1.11 74.88,137.5 ; JUSB1.11 74.88,134.76 ; JUSB1.11 74,137.5 ; JUSB1.11 74,134.76 ; JHDMI1.17 94.42,132.53 ; JHDMI1.17 93.5,132.53 ; JHDMI1.17 94.42,131.61 ; JHDMI1.17 93.96,132.65 ; JHDMI1.17 93.96,131.49 ; JHDMI1.17 93.5,131.61 ; 165.45,129.9 JDOCK1.153 ; JDOCK1.153 166.5,127.95 ; JDOCK1.153 167.55,127.95 ; JDOCK1.153 165.45,127.95 ; JDOCK1.153 167.55,128.93 ; JDOCK1.153 165.45,128.93 ; JDOCK1.153 166.5,129.9 ; JDOCK1.153 167.55,129.9 ; JUSB2.11 237.78,137.5 ; JUSB2.11 236.9,137.5 ; JUSB2.11 236.9,134.76 ; JUSB2.11 237.78,136.13 ; JUSB2.11 237.78,134.76 ; 87.5,131.61 JHDMI1.5 ; JHDMI1.5 88.42,131.61 ; JHDMI1.5 87.96,132.65 ; JHDMI1.5 87.96,131.49 ; JHDMI1.5 88.42,132.53 ; JHDMI1.5 87.5,132.53 ; 211.47,103.75 H21.1 ; H21.1 214.9,102.3 ; H21.1 212,105.2 ; H21.1 212,102.3 ; H21.1 214.9,105.2 ; H21.1 213.45,105.73 ; H21.1 215.43,103.75 ; H21.1 213.45,101.77 ; JMDP1.23 254.33,128.53 ; JMDP1.23 252.77,129.84 ; JMDP1.23 253.55,131.15 ; JMDP1.23 253.55,128.53 ; JMDP1.23 252.77,128.53 ; JMDP1.23 254.33,129.84 ; JMDP1.23 254.33,131.15 ; JMDP1.23 252.77,131.15 ; 99.71,136.68 JHDMI1.23 ; JHDMI1.23 98.83,136.68 ; JHDMI1.23 99.71,139.62 ; JHDMI1.23 98.83,138.15 ; JHDMI1.23 100.59,139.62 ; JHDMI1.23 100.59,138.15 ; JHDMI1.23 100.59,136.68 ; JHDMI1.23 98.83,139.62 ; 236.9,127.16 JUSB2.10 ; JUSB2.10 236.9,130.1 ; JUSB2.10 236.02,127.16 ; JUSB2.10 237.78,127.16 ; JUSB2.10 237.78,128.63 ; JUSB2.10 236.02,128.63 ; JUSB2.10 237.78,130.1 ; JMDP1.22 254.33,135.68 ; JMDP1.22 254.33,134.37 ; JMDP1.22 253.55,135.68 ; JMDP1.22 254.33,133.06 ; JMDP1.22 253.55,133.06 ; JLOM1.16 284.87,137.2 ; JLOM1.16 283.96,135.45 ; JLOM1.16 283.96,137.2 ; JLOM1.16 284.87,133.7 ; JLOM1.16 283.96,133.7 ; 134.41,132.85 JDOCK1.145 ; JDOCK1.145 135.33,134.7 ; JDOCK1.145 135.33,131 ; JDOCK1.145 134.41,131 ; JDOCK1.145 134.41,134.7 ; H8.1 90.09,68.79 ; H8.1 87.75,66.45 ; H8.1 85.41,68.79 ; H8.1 89.45,67.09 ; H8.1 86.05,70.49 ; H8.1 87.75,71.13 ; H8.1 86.05,67.09 ; H8.1 89.45,70.49 ; 228.42,127.91 JUSB2.7 ; JUSB2.7 229.69,127.91 ; JUSB2.7 229.88,128.54 ; JUSB2.7 229.05,127.71 ; JUSB2.7 228.22,128.54 ; H27.1 176.75,3.48 ; H27.1 174.92,1.65 ; H27.1 175.41,2.99 ; H27.1 178.09,2.99
  BOTTOM w0.076: 130.67,67.43 130.65,67.44 130.65,68.09 130.62,68.13 130.62,68.19
  BOTTOM w0.102: v3(83.45,82.43) 82.96,82.92 v2(82.31,82.92) ; 130.67,67.43 130.67,67.19 130.98,66.87 130.98,66.29 131.61,65.66 131.61,63.43 132.28,62.77 132.35,62.77 132.44,62.68 132.44,61.89 RC178.2 ; 130.28,66.73 130.28,66.23 130.46,66.06 130.46,65.12 130.57,65.01 130.57,61.99 RC187.2 ; v2(122.51,94.19) 122.89,93.81 122.89,92.57 122.56,92.24 v2(122.51,92.24) ; v2(92.83,76.06) v3(92.18,76.06)
  BOTTOM w0.127: 123.45,89.59 123.45,90.45 123.88,90.89 123.88,94.55 123.37,95.06
  BOTTOM w0.178: UC1.A28 122.29,92.02 v2(122.51,92.24) ; UC1.P63 99.7,82.33 v2(99.65,82.38) ; UC1.Y63 99.57,79.34 v2(99.4,79.17) ; v2(103.99,67.03) 104.05,67.1 UC1.AY57 ; v2(99.63,77.22) 99.77,77.09 UC1.AD63 ; v2(99.49,75.58) 99.57,75.66 UC1.AG63 UC1.AG62 UC1.AG61 ; UC1.AV51 UC1.AW51 UC1.AY51 107.84,67.35 107.74,67.26 v2(107.74,66.35) ; UC1.AY53 106.49,67.33 106.44,67.29 106.44,66.91 v2(106.26,66.73) ; UC1.P59 102.79,82.41 v2(102.49,82.71) ; UC1.Y59 102.79,79.41 v2(102.49,79.71) ; UC1.AL17 UC1.AM17 UC1.AN17 UC1.AP17 UC1.AR17
  BOTTOM w0.203: UC1.AY59 102.73,67.17 v2(102.64,67.08) ; UC1.P63 UC1.P62 ; UC1.AP10 133.23,71.54 v2(133.55,71.21) ; v2(133.56,73.16) 133.23,73.49 UC1.AL10 ; UV8.G9 v5(151.5,113.68) 151.82,114.01 UV8.G10 ; v2(135.06,78.69) 135.06,78.39 UC1.AB7 ; v5(152.8,111.09) UV8.F6 ; v5(150.2,113.68) UV8.J9 ; 131.12,90.77 131.12,91.44 131.38,91.7 131.38,93.06 v2(131.87,93.55) ; v5(150.2,113.03) UV8.J8 ; UV8.H10 151.17,114.01 v5(150.85,114.34) ; v2(101.19,84.21) 101.49,83.91 UC1.L61 ; v5(151.5,111.74) UV8.G7 ; v5(151.5,114.98) UV8.G11 ; v2(133.57,68.64) 133.87,68.94 UC1.AV8 ; RPC20.5 138.25,96.72 138.04,96.94 v2(137.75,96.94) ; v2(125.33,81.62) UC1.R22 ; UC1.D59 102.92,88.05 103.44,87.53 UC1.F58 ; UV8.F4 152.47,110.11 v5(152.8,110.44) UV8.F5 ; UC1.AC61 101.49,77.91 v2(101.19,78.21) ; UV8.D11 153.77,114.66 v5(154.1,114.33) UV8.D10 ; v2(89.38,97.11) 89.38,97.37 89.35,97.39 PU500.19 ; UC1.F61 101.49,86.91 v2(101.19,87.2) ; UV8.J6 150.52,111.41 v5(150.2,111.74) UV8.J7 ; UV8.F8 v5(152.8,113.03) 152.47,113.36 UV8.F9 ; UV8.C5 v5(154.75,110.44) ; UV8.D7 v5(154.1,111.74) ; UC1.A24 124.79,90.37 v2(124.89,90.47) ; v2(140.25,69.01) 140.13,69.01 139.53,69.61 UC1.AU1 ; v5(150.2,114.98) UV8.J11 ; v2(101.19,81.21) 101.49,80.91 UC1.U61 ; v5(154.1,113.68) UV8.D9 ; UC1.T58 103.44,81.65 UC1.P59 ; UC1.AY4 136.89,67.94 136.84,67.99 UC1.AW4 ; v2(139,104.07) 138.95,104.02 UV13.11 ; v5(151.5,110.44) UV8.G5 ; v5(150.2,115.63) UV8.J12 ; v5(149.55,110.44) UV8.K5 ; v5(151.5,109.79) UV8.G4 ; v2(97.06,88.04) 97.58,88.56 99.4,88.56 99.67,88.29 UC1.D63 100.25,88.23 UC1.D62 ; UC1.K1 v2(139.33,84.54) ; v2(139.35,75.55) UC1.AG1 ; v5(151.5,111.09) UV8.G6 ; v5(154.1,111.09) UV8.D6 ; v5(152.8,114.33) UV8.F10 ; PU500.22 88.15,97.34 88.03,97.21 v2(88.03,97.15) ; v2(126.73,86.99) 126.24,86.5 UC1.G22 ; UC1.J63 99.73,85.33 v2(99.61,85.45) ; UV8.E4 v5(153.45,109.79) ; UC1.AR17 129.59,70.94 ; v2(139.25,97.08) RPC20.7 ; v5(150.2,110.44) UV8.J5 ; UV8.F11 v5(152.8,114.98) ; UV8.F7 v5(152.8,111.74) ; v5(151.5,113.03) UV8.G8 ; UV8.D8 v5(154.1,113.03)
  BOTTOM w0.216: v5(153.45,109.79) 153.77,110.11 UV8.D4 ; UV8.D5 153.77,110.76 v5(154.1,111.09)
  BOTTOM w0.229: UC1.J22 125.25,84.87 v2(125.08,84.7) ; v2(125.33,83.25) UC1.M22
  BOTTOM w0.254: v2(111,86.56) 111,86.56 UC1.F46 UC1.D46 ; JDOCK1.7 143.25,129.86 v2(143.54,130.15) ; v2(144.21,131.12) 144.75,130.58 JDOCK1.13 ; UV8.C13 UV8.C14 154.76,116.95 154.76,117.3 154.8,117.34 154.8,118.28 v2(154.66,118.42) ; JDOCK1.126 174.75,135.38 v2(174.75,135.38) ; v2(207.97,59.52) 207.1,59.52 206.7,59.12 JNGFF2.11 ; v2(178.18,130.61) 177.75,130.18 JDOCK1.137 ; UV8.L6 149.22,111.41 v5(148.9,111.09) ; JDOCK1.50 153.75,138.33 v2(153.75,138.33) ; JEDP1.28 92.97,115.62 93.09,115.49 93.3,115.49 93.47,115.66 JEDP1.27 93.47,116.81 v2(94.03,117.38) ; JDOCK1.31 149.25,130.26 149.1,130.41 149.1,131.37 v2(149.47,131.74) ; JDOCK1.61 157.75,127.8 v2(158.05,127.5) 158.25,127.69 JDOCK1.63 ; UC1.D30 UC1.F30 121.03,86.56 v2(121.03,86.56) ; v2(116.01,86.56) 116.02,86.56 UC1.F38 UC1.D38 ; v2(216.65,112.69) 216.82,112.69 217.15,112.36 JSATA1.14 ; UC1.AY11 132.44,66.93 v2(132.54,66.83) ; JDOCK1.131 176.25,127.61 v2(176.27,127.59) ; v2(164.09,131.05) 164.25,130.89 JDOCK1.87 ; v2(161.48,135.31) 161.25,135.54 JDOCK1.76 ; UC1.D59 102.92,88.39 102.32,88.99 102.32,89.42 102.19,89.55 102.19,89.57 UC1.B60 ; JDOCK1.120 v2(173.25,135.42) ; UC1.U9 133.79,80.56 UC1.V10 ; v2(159.58,135.56) 159.75,135.74 JDOCK1.70 ; UC1.D26 UC1.F26 123.54,86.56 v2(123.54,86.56) ; UV8.E11 153.12,114.66 v5(152.8,114.98) ; v2(143.25,135.51) JDOCK1.8 ; JEDP1.8 102.97,114.44 v2(102.86,114.33) 102.89,114.3 103.85,114.3 103.97,114.42 JEDP1.6 ; JDOCK1.138 177.75,135.78 v2(178.03,135.5) ; JDOCK1.49 153.75,127.77 v2(153.55,127.56) 153.25,127.86 JDOCK1.47 ; v2(156.75,135.44) 156.75,135.44 JDOCK1.58 ; v2(218.32,56.82) 218.06,57.08 216.91,57.08 216.7,57.28 JNGFF2.43 ; JDOCK1.114 171.75,135.38 v2(171.75,135.38) ; v2(152.17,135.56) 152.25,135.64 JDOCK1.44 ; UC1.D42 UC1.F42 113.51,86.56 v2(113.51,86.56) ; JDOCK1.81 162.75,131.36 v2(162.55,131.56) ; JDOCK1.51 v2(155.25,127.38) ; v2(137.13,67.06) 136.89,67.31 UC1.AY4 ; JSATA1.12 218.15,111.72 218.15,110.37 v2(218.26,110.25) ; v2(103.99,78.93) UC1.AA58 ; JSATA1.1 223.65,112.51 223.94,112.8 v2(223.94,113.01) ; v2(165.93,134.61) 165.75,134.79 JDOCK1.94 ; v2(95.51,117.21) 95.47,117.17 JEDP1.23 ; CC62.2 158.32,74.03 159.87,74.03 159.99,73.91 JLPDE1.9 160.92,73.91 161.28,73.55 v2(161.28,73.09) ; JDOCK1.25 147.75,130.23 147.39,130.6 v2(147.39,131.24) ; v2(135.5,72.49) 135.38,72.49 UC1.AN7 135.13,72.19 v2(135.51,71.81) ; JDOCK1.123 174.25,127.69 v2(174.5,127.44) 174.75,127.68 JDOCK1.125 ; JSATA1.7 220.65,112.46 220.46,112.65 v2(220.21,112.65) ; v2(142.05,130.17) 141.75,129.86 JDOCK1.1 ; UC1.D50 UC1.F50 108.5,86.56 v2(108.49,86.56) ; JDOCK1.57 156.75,127.66 v2(156.47,127.37) 156.25,127.59 JDOCK1.55 ; UC1.A40 UC1.B40 ; JEDP1.4 104.97,115.47 105.55,114.89 CZ2.2 ; v2(136.02,66.25) 135.44,66.83 UC1.AY6 ; UC1.F58 103.44,86.72 v2(103.31,86.58) 103.73,86.16 UC1.H57 ; JDOCK1.88 v2(164.25,135.41) ; v2(171.59,127.54) 171.75,127.69 JDOCK1.113 ; JDOCK1.108 v2(170.25,135.38) ; v2(139.35,78.55) UC1.AA1 ; JDOCK1.26 147.75,136.85 v2(147.75,135.58) ; JEDP1.39 87.47,115.6 87.95,115.12 v2(88.78,115.12) ; UC1.V7 134.93,80.12 135.18,80.37 v2(135.18,80.5) ; v2(154.89,134.75) 155.25,135.11 JDOCK1.52 ; UC1.J59 102.79,85.41 v2(102.49,85.71) ; v2(105.98,86.56) 105.99,86.56 UC1.F54 UC1.D54 ; JDOCK1.69 159.75,127.5 v2(159.75,127.5) ; JDOCK1.43 152.25,127.46 v2(152.22,127.44) ; v2(103.99,80.24) UC1.V58 ; JNGFF1.7 171.8,80.44 171.09,79.73 v2(170.74,79.73) 170.3,80.17 JNGFF1.1 ; JDOCK1.75 161.25,129.81 v2(161.67,130.23) ; v2(170.25,130.13) JDOCK1.107 ; JDOCK1.37 150.75,130.8 150.94,130.99 150.94,131.5 v2(150.75,131.69) ; v2(103.99,84.14) UC1.L58 ; UC1.A28 UC1.B28 ; v2(145.61,131.25) 146.25,130.6 JDOCK1.19 ; v2(150.73,135.57) 150.75,135.58 JDOCK1.38 ; v2(162.75,135.57) 162.75,135.57 JDOCK1.82 ; JDOCK1.119 173.25,127.53 v2(172.86,127.14) ; v2(149.16,135.53) 149.25,135.61 JDOCK1.32 ; JDOCK1.64 v2(158.25,135.56) ; JDOCK1.101 168.75,130.11 v2(168.75,130.11) 167.48,130.11 167.25,129.88 JDOCK1.95 ; JDOCK1.102 168.75,135.08 v2(168.75,135.08) ; JDOCK1.14 144.75,135.63 v2(144.88,135.5) ; JDOCK1.91 v2(165.25,130.17) 165.75,129.67 JDOCK1.93 ; UC1.A11 132.45,90.92 132.81,91.28 v2(132.81,91.96) ; v2(118.52,86.56) 118.53,86.56 UC1.F34 UC1.D34 ; JSATA1.4 v2(222.15,113.05) ; v5(151.5,109.79) 151.18,110.11 UV8.H4 ; v2(99.7,118.08) 99.47,117.85 JEDP1.15 ; JEDP1.25 94.47,117.15 v2(94.64,117.33) 94.97,117 JEDP1.24 ; JDOCK1.96 v2(167.25,138.42) ; UV8.D13 UV8.D14 154.32,117.16 v2(154.32,117.82) ; JDOCK1.20 v2(146.25,135.57) ; v5(148.9,111.74) 148.9,111.74 UV8.L7 UV8.L8 ; JDOCK1.132 v2(176.25,135.38)
  BOTTOM w0.305: JNGFF1.28 179.05,89.69 178.6,90.14 v2(177.55,90.14) JNGFF1.22 ; 212.42,59.2 212.2,58.98 JNGFF2.25 ; JNGFF1.67 188.8,80.24 v2(189.17,79.87) ; JNGFF2.63 221.7,58.2 221.7,59.19 v2(222,59.49) 222.2,59.29 JNGFF2.65 ; JNGFF1.61 187.3,80.03 187.45,79.87 187.45,79.06 v2(187.37,78.98) ; 213.62,59.49 213.7,59.41 JNGFF2.31 ; JNGFF1.43 182.8,80.2 182.3,79.7 v2(181.55,79.7) 181.55,79.73 181.3,79.98 JNGFF1.37 ; 215.14,59.49 215.2,59.43 JNGFF2.37 ; JNGFF1.16 176.05,87.65 v2(175.95,87.54) ; JNGFF1.55 185.8,83.05 v2(184.6,84.26) ; JNGFF2.49 218.2,59.96 v2(218.35,60.11) ; JNGFF1.25 178.3,82.11 178.01,82.4 v2(177.4,82.4) 177.3,82.3 JNGFF1.21 ; v2(175.94,82.43) 175.94,82.1 175.8,81.96 JNGFF1.15 ; JNGFF2.19 210.7,59.3 210.89,59.49 ; JNGFF1.49 184.3,80.03 CC7.2 ; v2(179.8,79.95) JNGFF1.31 ; JNGFF2.5 205.2,56.79 v2(205.12,56.71) 205.12,56.98 204.7,57.4 JNGFF2.3
  BOTTOM w0.33: JNGFF1.10 174.55,89.76 v2(174.41,89.91)
  BOTTOM w0.356: v2(114.49,22.47) 114.45,22.51 JDIMM1.184 ; JDIMM2.63 151.75,30.41 v2(151.15,29.81) ; JDIMM1.38 v2(68.25,22.55) ; JDIMM1.54 v2(73.05,22.55) ; JDIMM1.150 104.25,25.13 v2(105.04,25.92) ; JDIMM1.8 v2(59.25,22.55) ; v2(97.48,25.39) 97.65,25.22 JDIMM1.128 ; v2(64.83,30.19) 64.35,30.67 JDIMM1.25 ; JDIMM2.139 176.95,33.16 v2(177.24,33.44) ; JDIMM2.43 145.75,33.43 145.98,33.66 v2(146.52,33.66) ; v2(100.52,33.57) 100.95,33.14 JDIMM1.139 ; v2(75.23,29.81) 75.94,30.52 75.94,30.84 75.75,31.02 JDIMM1.63 ; v2(110.43,22.47) 110.85,22.89 JDIMM1.172 ; v2(67.97,33.54) 67.95,33.52 JDIMM1.37 ; v2(113.16,34.15) 112.95,33.94 JDIMM1.179 ; JDIMM1.161 107.55,33.32 107.74,33.51 v2(108.13,33.51) ; JDIMM1.13 60.75,33.54 v2(60.52,33.77) ; v2(62.46,22.55) 62.85,22.93 JDIMM1.20 ; JDIMM1.151 104.55,33.35 v2(105.03,33.84) ; v2(144.05,33.66) 143.95,33.56 JDIMM2.37 ; v2(62.66,33.54) 62.55,33.43 JDIMM1.19 ; v2(73.5,33.54) 73.35,33.39 JDIMM1.55 ; v2(102.75,33.52) JDIMM1.145 ; JDIMM2.167 185.35,33.22 v2(185.63,33.5) ; JDIMM2.13 136.75,33.54 v2(136.93,33.72) ; v2(141.37,25.34) 141.25,25.22 JDIMM2.28 ; v2(175.37,22.53) 175.45,22.62 JDIMM2.134 ; v2(135.13,25.35) 135.25,25.23 JDIMM2.8 ; v2(149.1,25.35) 149.05,25.3 JDIMM2.54 ; JDIMM2.156 182.05,25.9 v2(181.95,26) ; JDIMM2.155 181.75,33.46 v2(181.68,33.53) 180.94,33.53 180.55,33.14 JDIMM2.151 ; JDIMM2.19 138.55,33.38 v2(138.22,33.71) ; v2(192.09,25.4) 192.25,25.24 JDIMM2.190 ; JDIMM1.48 v2(71.25,22.55) ; v2(59.01,29.82) 59.08,29.82 59.55,30.29 JDIMM1.9 ; v2(117.73,33.52) 117.75,33.5 JDIMM1.195 ; JDIMM2.3 133.75,33.05 v2(133.11,33.68) ; JDIMM2.162 183.85,22.55 v2(183.85,22.55) ; v2(116.27,22.47) 116.25,22.49 JDIMM1.190 ; v2(102.5,25.33) 102.45,25.28 JDIMM1.144 ; v2(150.84,25.3) 150.85,25.29 JDIMM2.60 ; JDIMM2.49 147.55,31.11 v2(147.01,30.57) ; v2(100.76,25.42) 100.65,25.3 JDIMM1.138 ; v2(140.78,30.57) 140.35,31.01 JDIMM2.25 ; JDIMM2.71 154.15,33.51 v2(154.03,33.63) ; JDIMM1.26 v2(64.65,22.54) ; JDIMM2.72 154.45,25.33 v2(154.49,25.37) ; v2(145.84,25.37) 146.05,25.15 JDIMM2.44 ; v2(109.61,26.26) 110.25,25.61 JDIMM1.170 ; v2(57.22,30.34) 57.75,30.88 JDIMM1.3 ; JDIMM2.46 146.65,22.24 v2(146.05,21.64) ; JDIMM1.153 105.15,33.09 v2(105.54,33.48) 105.75,33.27 JDIMM1.155 ; JDIMM2.55 149.35,33.16 v2(149.76,33.57) ; v2(178.25,22.53) 178.45,22.74 JDIMM2.144 ; JDIMM2.9 135.55,33.09 v2(134.95,33.68) ; v2(147.42,22.37) 147.25,22.54 JDIMM2.48 ; v2(178.85,33.55) 178.75,33.45 JDIMM2.145 ; JDIMM1.46 v2(70.65,22.57) ; JDIMM2.170 186.25,22.53 v2(186.25,22.53) ; v2(140.59,25.34) 140.65,25.28 JDIMM2.26 ; JDIMM1.66 v2(76.65,22.55) ; v2(138.81,25.54) 138.85,25.51 JDIMM2.20 ; JDIMM1.127 97.35,30.75 v2(96.99,30.4) ; JDIMM2.168 v2(185.65,22.54) ; v2(109.73,22.47) 109.65,22.55 JDIMM1.168 ; JDIMM2.136 v2(176.05,22.55) ; v2(110.19,30.16) 109.35,31 JDIMM1.167 ; JDIMM2.38 144.25,25.28 v2(144.19,25.34) ; UV11.7 133,125.07 v2(132.72,124.78) ; JDIMM1.162 107.85,22.49 v2(107.83,22.47) 106.25,22.47 106.05,22.67 JDIMM1.156 ; v2(71.37,33.49) 71.55,33.31 JDIMM1.49 ; JDIMM1.133 99.15,33.16 v2(98.74,33.57) ; v2(190.63,29.5) 191.35,30.22 JDIMM2.187 ; v2(66.73,22.53) 66.45,22.81 JDIMM1.32 ; v2(66.23,33.55) 66.15,33.47 JDIMM1.31 ; JDIMM2.184 190.45,25.51 v2(190.63,25.69) ; v2(136.62,29.81) 136.03,30.4 136.03,30.92 136.15,31.03 JDIMM2.11 ; JDIMM2.153 181.15,30.53 v2(180.43,29.81) ; JDIMM1.187 115.35,33.36 115.19,33.52 v2(114.87,33.52) 114.75,33.39 JDIMM1.185 ; v2(183.43,33.54) 183.55,33.42 JDIMM2.161 ; JDIMM2.150 v2(180.25,22.55) ; JDIMM1.72 v2(78.45,22.55) ; v2(77.08,33.52) 77.92,33.52 78.15,33.3 JDIMM1.71 ; v2(186.85,22.55) 186.85,22.55 JDIMM2.172 ; JDIMM2.66 v2(152.65,22.41) ; JDIMM1.44 v2(70.05,22.55) ; v2(142.67,25.3) 142.45,25.08 JDIMM2.32 ; JDIMM2.61 151.15,33.4 v2(151.45,33.7) 152.06,33.7 152.35,33.41 JDIMM2.65 ; JDIMM2.14 137.05,25.49 v2(137.06,25.5) ; JDIMM1.61 75.15,33.37 75.37,33.58 v2(75.75,33.58) 76.01,33.58 76.35,33.24 JDIMM1.65 ; JDIMM1.60 v2(74.85,22.55) ; JDIMM2.138 176.65,22.8 v2(176.9,22.55) ; JDIMM2.2 133.45,25.34 v2(133.45,25.34) ; JDIMM1.2 v2(57.45,22.55) ; JDIMM2.31 142.15,33.14 v2(141.58,33.71) ; JDIMM1.178 112.65,22.53 v2(112.72,22.47) ; JDIMM2.173 187.15,31.13 186.21,30.19 v2(185.83,30.19) ; JDIMM1.196 118.05,22.47 v2(118.05,22.47) ; v2(175.77,30.57) 175.15,31.2 JDIMM2.133 ; v2(60.7,29.81) 60.15,30.36 JDIMM1.11 ; JDIMM1.43 v2(69.75,33.54) ; JDIMM1.14 v2(61.05,22.55) ; JDIMM1.28 v2(65.25,22.56)
  BOTTOM w0.381: UC5.3 160.5,81.31 v2(160.77,81.58) ; UC6.3 158.03,79.42 v2(158.04,79.4) ; v2(164.44,107.8) 164.37,107.88 163.9,107.88 163.69,107.67 UV12.7 ; DI6.3 v2(224.98,125.38) ; UC4.3 162.07,84.23 162.07,83.87 162.79,83.15 163.3,83.15 163.67,83.52 v2(163.67,83.92)
  BOTTOM w0.406: JMDP1.14 249.45,128.66 v2(249.45,126.59) ; v2(248.17,126.62) 248.17,126.86 247.65,127.39 247.65,128.66 JMDP1.8
  BOTTOM w0.432: v2(171.35,118.18) 171.13,117.96 QV700.4 ; v2(168.24,116.07) 168.24,116.4 168.5,116.66 QV700.1
  BOTTOM w0.457: v2(114.21,117.64) 114.21,116.7 JLED1.8 ; PD2.1 v2(152.75,15.47) ; JANT1.8 132.02,120.27 131.98,120.31 v2(131.98,120.77) 131.61,120.77 131.23,120.38 JANT1.7 ; v2(154.74,15.47) PD1.1 ; RV508.1 v2(142.59,124.59) RV509.1
  BOTTOM w0.508: v2(56.57,120.82) 56.86,120.53 CI19.2 ; v2(3.05,14.14) 3.25,13.94 JSD1.13 ; JSPI1.19 175.38,68.81 v2(175.07,68.49) 175.07,68.15 174.89,67.96 JSPI1.18 ; CC81.2 117.22,96.09 v2(117.41,95.9) ; v2(132,58.83) 132,60.52 CC101.2 132,60.54 RC178.2 RC187.2 ; v2(210.42,114.62) 210.42,114.87 210.95,115.41 CL10.2 ; PC402.2 PR401.2 190.89,78.68 v2(190.75,78.82) ; CL3.2 208.12,108.33 207.65,108.8 v2(207.65,109.02) ; v2(158.04,79.4) 158.04,79.27 158.1,79.21 CC52.2 ; PC4.2 149.13,17.83 v2(148.67,17.38) ; PR745.2 38.44,34.79 v2(38.31,34.66) ; v2(219.64,47.25) 219.25,47.63 JRTC1.2 ; v2(139.45,106.54) CV116.2 ; CZ18.1 190.52,87.35 v2(190.27,87.6) ; RV503.1 v2(248.22,124.22) ; v2(143.21,110.89) 143.68,110.42 RV89.2 ; JEDP1.45 v2(84.57,120.35) ; v2(174.54,126.04) C319.2 174.44,125.28 C316.2 ; RC80.2 164.42,84.39 163.94,83.92 v2(163.67,83.92) ; v2(108.09,120.51) 108.87,119.73 JEDP1.41 ; CN13.2 CN14.2 214.92,107.97 v2(215.52,107.37) ; DI3.1 237.75,122.79 v2(237.75,122.7) ; v2(200.01,40.29) 199.76,40.04 JDIMM2.206 ; JRTC1.3 223.05,43.9 v2(222.8,43.65) ; v2(28.07,32.16) 28.29,31.95 JSD1.6 ; JLED1.7 121.55,116.2 v2(122.34,117) ; JDIMM2.205 135.51,36.53 v2(135.72,36.53) ; v2(145.53,63.52) 145.37,63.68 CC1.1 ; JSD1.21 31.15,27.7 v2(31.51,28.06) ; v2(160.38,108.49) 159.98,108.88 RV79.2 ; v2(76.71,84.06) 77.82,85.17 JFAN1.6 ; v2(86.18,53.56) 85.61,54.13 CMOS1.1 ; v2(187.12,62.5) 187.12,63.12 PR303.2 ; RC140.2 144.85,83.14 v2(144.77,83.21) ; CZ64.2 68.2,12.83 v2(67.91,12.54) ; CC5.2 137.31,60.82 v2(137.41,60.93) ; v2(159.12,100.18) 158.88,99.94 CV121.2 ; v2(140.4,116.51) 140.01,116.12 CC42.2 ; v2(92.63,84.76) 92.63,85.43 RC188.2 ; JSD1.20 31.67,39.25 v2(31.72,39.3) ; PD5.1 v2(67.92,118.91) ; JEDP1.44 88.23,120.5 89.51,120.5 v2(89.61,120.4) ; v2(92.65,112.77) 92.65,113.11 CV8.2 ; v2(196.65,88.07) 195.38,88.07 PC404.2 ; JFAN1.5 77.82,93.76 v2(76.82,92.76) ; v2(163.41,125.23) C43.2 ; v2(217.11,43.11) 217.11,44.15 216.7,44.56 JRTC1.4 ; CC2.1 146.88,60.44 147.58,61.14 v2(147.58,61.35) ; v2(143.5,107.29) 143.7,107.5 RV73.2 144.57,107.25 CV113.2 ; v2(212.96,78.97) 212.96,76.97 213.87,76.05 v2(213.87,73.46) ; v2(181.29,71.88) 181.29,72.25 181.49,72.44 UC2.4 ; JSPI1.21 v2(165.38,70.98) 165.06,71.31 JLPDE1.11 ; JSD1.3 30.7,24.85 31.28,25.43 31.31,25.43 v2(31.74,25.86) ; JSATA1.23 v2(226.3,111.85) ; JEDP1.42 105.61,120.07 104.18,120.07 v2(103.69,120.57) ; CI8.2 248.62,122.01 v2(248.12,121.52) ; JNGFF1.68 169.2,80.39 v2(169.9,79.68) ; v2(58.66,41.82) 58.66,40.87 57.83,40.04 JDIMM1.205 ; v2(78.44,91.9) 79.72,91.9 JFAN1.1 ; v2(133.32,119.22) JANT1.10 ; v2(163.36,79.15) 163.55,79.34 JLPDE1.12 ; CC7.2 183.14,79.25 v2(182.74,78.86) ; v2(135.61,119.75) 135.5,119.64 QV9.3 ; v2(193.77,65.9) 194.13,66.27 PC311.2 ; CV124.2 142.06,120.03 v2(142.18,119.91) ; CZ57.2 v2(226.71,57.71) ; v2(214.42,120.44) 214.98,121 CL7.2 ; v2(175.2,65.83) 175.89,66.51 JSPI1.20 ; RV504.2 v2(247.32,124.22) ; v2(215,114.21) 213.37,115.85 JSATA1.22 ; v2(270.76,136.12) CL17.2 ; RC128.1 82.31,83.32 v2(82.31,82.92) ; CZ2.2 105.45,114.29 v2(104.84,114.29) ; v2(269.56,136.01) CL16.2 ; CC67.2 121.8,98.42 v2(122.18,98.03) ; v2(137.61,113.51) 136.82,114.29 CC41.2 ; v2(159.75,127.5) 159.75,125.82 159.8,125.82 C42.2 ; CV509.2 251.76,124.87 v2(252.42,124.22) ; v2(94.76,95.55) CC24.2 ; v2(92.94,110.23) PC503.1 PC521.2 ; CL4.2 v2(207.52,111.32) ; v2(177.71,69.84) JSPI1.23 ; RC304.2 164.65,81.02 v2(164.8,80.86) ; v2(91.61,80.57) 91.12,80.08 RC185.2 ; RC132.2 RC130.2 RC131.2 98.56,62.08 99.35,62.87 100.35,62.87 v2(100.48,62.73) ; CL27.2 223.23,125.16 v2(223.23,125.81) ; CA5.2 CA6.2 v2(109.64,125.34) ; CV117.2 138.75,106.05 v2(138.75,106.56) CV118.1 ; v2(70.92,12.45) PR209.2 69.98,13.33 PC214.2 ; QV7.3 125.33,121.82 124.84,121.34 v2(124.5,121.34) ; v2(93.94,119.86) 93.94,120.22 94.23,120.51 96.29,120.51 JEDP1.43 ; v2(215.98,51.44) 216.66,52.12 PC1.2 ; JNGFF1.69 189.9,80.6 v2(189.17,79.87) ; v2(6.35,14.11) 6.55,13.91 JSD1.10 ; DI2.1 67.92,123.12 68.25,122.79 v2(68.25,121.95) ; JNGFF2.69 224.53,58.97 224.86,59.3 v2(224.86,59.68) ; v2(177.69,67.04) JSPI1.24 ; v2(228.89,64.28) CZ52.2 ; YV2.2 141.29,106.12 v2(140.74,106.67) 140.34,106.27 CV518.2 ; v2(193.11,83.96) 193.59,84.45 PU400.1 ; CI38.2 126.37,125.47 v2(125.86,124.96) ; JNGFF2.68 203.1,56.87 v2(203.34,56.63) ; v2(228.89,63.4) CZ51.2 ; v2(193.49,65.24) 192.92,65.81 PC310.2 ; PC212.2 74.84,12.72 v2(74.69,12.56) ; v2(192,85.82) 192.03,85.84 PR403.2 ; v2(154.41,16.89) PC3.2 ; v2(192.59,62.78) PR310.2 ; v2(102.59,112.98) 101.93,112.98 PC509.1 ; v2(33.29,44.12) 33.24,44.17 33.24,45.3 33.8,45.85 PC710.2 ; YV2.4 143.36,103.33 143.96,102.73 v2(144.72,102.73) 144.72,103.28 144.59,103.41 CV115.2 ; v2(143.07,94.29) 142.53,94.82 RC141.1 RC142.1 ; v2(124.82,94.22) 125.08,94.49 CC82.2 ; v2(164.66,98.15) QV10.3 ; v2(249.94,124.24) RV502.1 ; v2(73.43,21.66) 74.6,21.66 PC211.2 ; PC215.2 v2(71.45,18.11) ; C310.2 R268.2 152.58,124.31 152.94,124.67 v2(152.94,125.53) ; v2(149.67,100.64) 150.69,101.65 UV9.4 ; CV7.2 97.04,113.35 v2(96.74,113.05) ; v2(93.8,100.21) PC501.2 ; CL19.2 259.08,124.77 v2(259.59,125.28) 259.15,125.72 CL18.2 ; v2(228.91,65.15) CZ53.2 ; v2(165.38,68.32) JSPI1.22 ; PC511.2 v2(82.43,104.19) ; v2(75.34,20.72) 75.5,20.72 76.11,21.33 PC209.1 ; v2(216.22,129.21) CL26.2 ; RC242.2 RC243.2 158.92,65 v2(158.68,64.76) ; v2(119.36,40.41) 119.74,40.04 JDIMM1.206 ; PC737.2 v2(37.53,34.67) ; RC139.1 135.51,96.7 v2(135.17,97.05) ; CI10.2 241.89,126.25 v2(241.49,126.65) ; CD44.2 156.1,21.64 v2(154.45,21.64) ; JSATA1.24 v2(225.77,115.85) ; v2(202.21,61.59) 201.87,61.93 CZ55.2 201.44,61.78 CZ54.2 ; v2(91,77.21) 91,77.33 90.2,78.13 RC184.2 ; v2(136.03,20.89) 136.38,20.55 CD35.2 ; PC741.1 v2(36.65,34.67) ; v2(214.12,114.04) 214.12,113.15 213.1,112.12 JSATA1.21 ; RV505.1 v2(246.43,124.23) ; v2(101.73,125.34) CV24.2 ; RC175.2 160.62,65.43 160.62,64.72 161.15,64.19 v2(162.12,64.19) ; CV114.2 v2(159.73,96.62) ; JSD1.17 v2(6.55,40.99) ; v2(191.63,62.78) PR308.2 ; RV74.2 v2(161.13,116.51) ; v2(193.16,72.44) UC3.4 ; RV75.2 148.64,120.84 148.21,120.41 v2(148.21,119.12)
  vias: v2(0.52,43.36) v2(0.52,38.28) v2(0.52,33.2) v2(0.52,28.12) v2(0.52,23.04) v2(0.52,17.96) v2(0.52,12.88) v2(2.9,11.19) v2(3.71,50.99) v2(3.72,45.25) v2(5.13,5.36) v2(5.21,59.35) v2(5.22,54.27) v2(7.62,7.99) v2(7.72,62.16) v2(8.07,6.53) v2(8.58,9.71) v2(9.41,14.07) v2(9.41,13.49) v2(11.05,9.52) v2(11.24,6.53) v2(11.75,7.93) v2(11.86,62.13) v2(16.25,5.37) v2(17.52,62.13) v2(19.67,36.9) v2(19.6,34.12) v2(20.23,56.34) v2(20.23,55.71) v2(20.87,56.34) v2(20.87,55.71) v2(20.91,35.54) v2(21.06,27.42) v2(21.47,20.56) v2(21.47,18.85) v2(21.47,17.2) v2(21.41,5.37) v2(21.5,56.34) v2(21.5,55.71) v2(22.14,56.34) v2(22.14,55.71) v2(22.23,36.91) v2(22.27,34.04) v2(22.61,20.56) v2(22.61,18.85) v2(22.67,17.2) v2(22.77,56.34) v2(22.77,55.71) v2(23.1,43.03) v2(23.18,62.13) v2(23.27,12.27) v2(23.41,56.34) v2(23.41,55.71) v2(23.69,43.03) v2(23.69,20.56) v2(23.75,18.79) v2(23.82,17.14) v2(24.64,27.44) v2(24.87,22.53) v2(26.16,19.42) v2(26.56,5.37) v2(27.33,15.4) v2(27.73,13.66) v2(29.62,16.97) v2(30.2,16.97) v2(31.09,18.93) v2(31.71,5.37) v2(31.98,23.23) v2(32.46,20.45) v2(33.67,43.64) v2(34.5,62.13) v2(36.86,5.37) v2(38.97,30.72) v2(38.97,30.1) v2(39.59,30.72) v2(39.59,30.1) v2(39.99,62.59) v2(42.02,5.37) v2(43.25,17.76) v2(43.25,17.07) v2(43.31,18.98) v2(43.31,18.34) v2(43.89,22.93) v2(43.94,18.98) v2(43.94,18.34) v2(43.92,17.64) v2(43.92,16.96) v2(44.31,23.41) v2(44.55,17.54) v2(44.55,16.86) v2(44.63,19.62) v2(44.58,18.98) v2(44.58,18.34) v2(45.24,19.64) v2(45.21,18.28) v2(45.32,63.97) v2(45.28,18.98) v2(45.29,17.61) v2(45.29,16.92) v2(45.84,21.33) v2(45.89,19.83) v2(45.89,19.14) v2(45.91,18.53) v2(45.98,17.9) v2(46.45,25.34) v2(46.45,24.73) v2(46.48,19.85) v2(46.51,19.14) v2(47.12,25.34) v2(47.12,24.7) v2(47.17,19.87) v2(47.16,19.08) v2(47.14,5.34) v2(47.9,138.1) v2(47.9,132.27) v2(47.9,126.44) v2(47.88,38.38) v2(48.47,38.38) v2(49.72,134.99) v2(49.75,123.35) v2(49.85,132.71) v2(50.34,66.21) v2(51.5,136.07) v2(51.5,131.82) v2(52.31,5.36) v2(53.22,132.58) v2(53.34,134.93) v2(54.28,120.46) v2(54.88,69.32) v2(55.01,138.32) v2(56.97,60.73) v2(57.48,27.91) v2(57.48,26.38) v2(57.48,5.37) v2(58.35,116.77) v2(58.4,20.06) v2(58.38,19.38) v2(58.78,138.19) v2(58.85,33.62) v2(58.91,130.51) v2(58.88,73.14) v2(59.01,28.3) v2(59.01,26.01) v2(59.02,20.06) v2(59.01,19.38) v2(60.37,120.18) v2(60.7,28.29) v2(61.61,112.6) v2(62.18,77.59) v2(62.55,29.81) v2(62.55,28.29) v2(62.55,26.76) v2(62.61,34.28) v2(62.87,50.47) v2(63.35,68.61) v2(63.46,123.03) v2(64.22,107.83) v2(64.34,81.75) v2(64.35,33.54) v2(64.65,26.26) v2(64.83,27.91) v2(65.41,27.02) v2(66.36,29.81) v2(66.36,28.29) v2(66.44,26.26) v2(66.89,97.44) v2(66.9,91.99) v2(67.21,27.02) v2(67.35,22.56) v2(68.08,29.81) v2(68.08,28.29) v2(69.85,26.26) v2(70.67,30.11) v2(70.67,27.83) v2(71.38,26.26) v2(71.92,125.01) v2(72.51,125.01) v2(73.05,26.26) v2(73.14,125.01) v2(73.35,29.81) v2(73.35,28.29) v2(73.78,132.15) v2(73.78,125.01) v2(73.81,27.02) v2(75.06,34.41) v2(75.23,28.29) v2(75.43,25.63) v2(76.2,27.15) v2(76.93,17.52) v2(76.93,16.79) v2(77.08,132.4) v2(77.22,133.86) v2(77.42,137.54) v2(77.69,27.02) v2(77.73,17.5) v2(77.73,16.78) v2(77.94,20.06) v2(77.93,19.47) v2(78.15,29.81) v2(78.15,28.29) v2(78.09,5.37) v2(78.27,132.35) v2(78.36,133.9) v2(78.31,14.74) v2(78.31,14.14) v2(78.45,26.26) v2(80.42,12.65) v2(80.65,78.03) v2(80.79,29.81) v2(80.79,28.29) v2(81.16,12.67) v2(81.4,133.45) v2(81.45,27.78) v2(81.45,26.26) v2(83.24,5.37) v2(83.37,29.81) v2(83.85,27.78) v2(83.85,26.26) v2(84.08,104.58) v2(84.84,12.7) v2(84.89,27.02) v2(85.27,29.81) v2(85.27,28.29) v2(85.42,122.48) v2(85.44,12.69) v2(85.65,26.26) v2(85.87,102.67) v2(87.16,29.81) v2(87.15,28.29) v2(87.45,26.26) v2(87.87,99.43) v2(87.92,117.47) v2(88.21,27.02) v2(88.32,100.77) v2(88.39,5.37) v2(88.58,29.81) v2(88.7,100.07) v2(89.04,122.38) v2(89.16,27.79) v2(89.21,99.43) v2(89.33,100.89) v2(89.93,30.1) v2(89.93,27.82) v2(89.92,27.03) v2(90.48,120.06) v2(90.48,17.83) v2(90.68,25.5) v2(91.18,17.86) v2(91.46,20.25) v2(91.46,19.65) v2(91.46,19.02) v2(91.71,18.47) v2(91.93,17.85) v2(92.05,20.25) v2(92.06,19.64) v2(92.06,19) v2(92.09,27.02) v2(92.18,120.07) v2(92.3,29.81) v2(92.3,28.29) v2(92.65,20.25) v2(92.66,19.64) v2(92.66,19) v2(92.85,26.26) v2(93.08,106.12) v2(93.3,21.94) v2(93.28,20.25) v2(93.3,19.64) v2(93.3,19) v2(93.42,128.87) v2(93.52,80.51) v2(93.55,5.37) v2(93.91,126.14) v2(94.35,29.81) v2(94.35,28.29) v2(94.38,26.26) v2(94.5,122.46) v2(94.55,73.16) v2(94.68,106.12) v2(94.73,21.94) v2(94.73,13.33) v2(95.22,82.62) v2(95.42,80.51) v2(95.54,72.85) v2(95.61,84.89) v2(95.87,29.05) v2(95.89,86.46) v2(95.95,21.68) v2(96.4,126.8) v2(96.56,70.94) v2(96.51,67.38) v2(96.74,107.72) v2(96.74,107.09) v2(96.73,72.36) v2(97.06,77.29) v2(97.13,82.6) v2(97.3,68.27) v2(97.38,107.72) v2(97.38,107.09) v2(97.42,29.99) v2(97.42,28.47) v2(97.48,26.03) v2(97.5,84.94) v2(97.57,70.62) v2(97.8,86.46) v2(98.7,5.37) v2(99.02,71.42) v2(99.02,69.8) v2(99.27,73.98) v2(99.45,29.99) v2(99.45,27.71) v2(99.45,26.18) v2(99.51,105.02) v2(99.51,102.86) v2(99.51,100.7) v2(99.51,98.54) v2(99.57,18.98) v2(99.57,16.56) v2(100,64.14) v2(100.52,105.02) v2(100.52,102.86) v2(100.52,100.7) v2(100.52,98.54) v2(100.8,26.29) v2(101.31,73.06) v2(101.3,65.57) v2(101.35,20.06) v2(101.35,15.8) v2(101.67,135.5) v2(101.69,61.13) v2(101.74,29.14) v2(101.74,27.61) v2(101.74,26.09) v2(101.79,133.21) v2(101.84,76.73) v2(101.79,64.05) v2(102.47,95.43) v2(102.47,93.54) v2(102.38,70.75) v2(102.53,76.72) v2(102.81,105.02) v2(102.81,102.86) v2(102.81,100.7) v2(102.81,98.54) v2(103.07,62.51) v2(103.06,16.56) v2(103.11,65.34) v2(103.21,76.83) v2(103.18,75.81) v2(103.19,18.91) v2(103.44,136.58) v2(103.44,132.32) v2(103.51,29.73) v2(103.51,28.2) v2(103.51,26.68) v2(103.74,105.02) v2(103.85,102.86) v2(103.85,100.7) v2(103.85,98.54) v2(103.85,5.37) v2(103.91,73.02) v2(103.91,71.07) v2(104.06,76.44) v2(104.3,95.49) v2(104.3,93.54) v2(104.45,63.89) v2(104.94,88.78) v2(105.04,29.73) v2(105.04,28.2) v2(105.16,133.09) v2(105.29,135.44) v2(105.3,68.75) v2(105.82,73.02) v2(105.82,71.07) v2(105.83,65.27) v2(106.17,105.02) v2(106.17,102.86) v2(106.17,100.7) v2(106.12,98.48) v2(106.1,94.67) v2(106.1,92.78) v2(106.71,73.83) v2(106.72,73.02) v2(106.76,72.4) v2(106.77,71.79) v2(107.07,88.8) v2(107.01,27.02) v2(107.13,105.02) v2(107.13,102.86) v2(107.13,100.7) v2(107.15,98.47) v2(107.44,62.69) v2(107.67,73.02) v2(107.68,29.81) v2(107.68,28.29) v2(107.77,26.26) v2(107.88,95.49) v2(108.13,34.09) v2(108.28,137.93) v2(108.32,93.73) v2(108.64,130.79) v2(108.84,27.02) v2(108.93,68.64) v2(109,5.37) v2(109.09,64.83) v2(109.29,91.21) v2(109.4,74.42) v2(109.48,105.02) v2(109.48,102.86) v2(109.48,100.7) v2(109.48,98.54) v2(109.48,92.7) v2(109.57,71.07) v2(109.66,94.03) v2(109.87,65.21) v2(109.95,88.78) v2(110.19,27.88) v2(110.52,74.42) v2(110.52,72.32) v2(110.51,68.64) v2(111.05,93.85) v2(111.13,26.26) v2(111.48,73.08) v2(111.89,27.02) v2(112.08,68.64) v2(112.09,67.31) v2(112.08,64.3) v2(112.08,33.5) v2(112.46,88.78) v2(112.43,70.42) v2(112.66,91.47) v2(112.62,29.81) v2(112.62,28.29) v2(112.77,98.48) v2(112.78,100.7) v2(112.88,125.91) v2(112.9,26.26) v2(113.31,74.41) v2(113.38,71.77) v2(113.66,68.64) v2(113.65,67.31) v2(113.67,27.02) v2(113.85,64.3) v2(113.84,63.68) v2(114.16,5.37) v2(114.36,74.42) v2(114.29,71.72) v2(114.56,92.13) v2(114.75,29.81) v2(114.75,28.29) v2(114.97,88.78) v2(115.14,75.21) v2(115.12,73.02) v2(115.17,65.19) v2(115.23,68.64) v2(115.79,74.32) v2(115.79,71.07) v2(116.02,105.02) v2(115.99,103.41) v2(116.02,100.7) v2(116.17,91.91) v2(116.58,29.69) v2(116.58,28.16) v2(116.58,25.88) v2(116.74,73.18) v2(116.74,71.87) v2(116.76,63.3) v2(116.81,68.64) v2(116.78,34.41) v2(117.22,33.9) v2(117.47,88.78) v2(117.74,75.21) v2(117.7,71.72) v2(118.08,26.26) v2(118.38,68.64) v2(118.4,65.75) v2(118.47,62.22) v2(118.55,74.39) v2(118.54,63.76) v2(118.56,33.77) v2(118.65,73.09) v2(118.65,70.49) v2(118.9,125.38) v2(119,26.09) v2(119.19,95.17) v2(119.19,93.37) v2(119.19,91.52) v2(119.19,16.25) v2(119.18,15.5) v2(119.36,107.17) v2(119.31,5.37) v2(119.38,105.02) v2(119.38,100.7) v2(119.58,74.32) v2(119.6,71.72) v2(119.79,16.26) v2(119.79,15.51) v2(120,121.38) v2(119.98,88.78) v2(120.53,111.75) v2(120.5,64.38) v2(120.5,63.08) v2(120.5,60.46) v2(120.65,67.04) v2(121.06,74.32) v2(121.06,73.02) v2(121.08,95.24) v2(121.09,93.5) v2(121.09,91.67) v2(121.08,71.07) v2(121.73,118.93) v2(121.73,112.07) v2(121.97,68.75) v2(122.07,102.99) v2(122.12,63.73) v2(122.12,61.13) v2(122.11,29.84) v2(122.11,29.2) v2(122.49,88.78) v2(122.94,73) v2(122.97,71.07) v2(122.96,66.8) v2(123.14,112.06) v2(123.33,118.38) v2(123.36,115.56) v2(123.89,130.05) v2(124.25,75.21) v2(124.21,64.38) v2(124.21,62.43) v2(124.41,136.25) v2(124.42,67.03) v2(124.46,5.37) v2(124.53,112.07) v2(124.63,60.01) v2(124.8,92.24) v2(124.88,74.32) v2(124.88,73.67) v2(124.88,73.02) v2(124.88,71.72) v2(124.88,70.42) v2(125,88.78) v2(125.16,75.49) v2(125.33,82.43) v2(125.33,80.81) v2(125.61,138.29) v2(125.72,73.02) v2(125.72,71.07) v2(125.91,67.02) v2(126.11,64.38) v2(126.11,61.78) v2(126.27,74.54) v2(126.49,136.52) v2(126.91,140.35) v2(126.98,74.6) v2(127.1,68.75) v2(127.25,87.33) v2(127.45,89.79) v2(127.64,94.2) v2(127.64,92.3) v2(127.64,73.04) v2(127.63,71.07) v2(127.71,112.51) v2(127.71,63.73) v2(128.03,80.4) v2(128.19,78.92) v2(128.21,76.51) v2(128.21,67.04) v2(128.35,130.52) v2(128.46,101.88) v2(128.48,74.25) v2(128.77,111.68) v2(129.05,101.88) v2(129.15,87.97) v2(129.15,86.02) v2(129.26,140.34) v2(129.23,136.45) v2(129.61,123.43) v2(129.58,63.8) v2(129.58,61.74) v2(129.62,5.37) v2(129.73,130.52) v2(129.69,66.97) v2(130.05,138.61) v2(130.26,92.38) v2(130.27,70.25) v2(130.5,125.92) v2(130.57,68.6) v2(130.62,110.96) v2(131.06,86.02) v2(131,82.67) v2(131.21,130.51) v2(131.66,70.56) v2(132,87.97) v2(132.12,80.25) v2(132.65,122.23) v2(132.73,99.36) v2(132.68,80.25) v2(132.84,95.43) v2(132.95,85.35) v2(133.42,95.43) v2(133.75,21.64) v2(133.78,65.55) v2(133.91,29.62) v2(134.77,5.37) v2(134.81,116.32) v2(134.87,86.67) v2(134.79,20.88) v2(135.04,84.6) v2(135.09,29.81) v2(135.09,28.29) v2(135.25,21.64) v2(135.54,89.02) v2(135.51,18.6) v2(135.82,86.67) v2(135.97,122.02) v2(136.17,124.52) v2(136.12,33.76) v2(136.36,76.78) v2(136.35,70.63) v2(136.4,89.65) v2(136.62,28.29) v2(136.91,117.83) v2(137.05,22.41) v2(137.64,65.88) v2(137.82,85.67) v2(137.82,82.67) v2(137.81,79.64) v2(137.82,76.67) v2(137.81,73.68) v2(137.82,70.68) v2(137.92,93.63) v2(138.01,140.34) v2(138.47,29.81) v2(138.47,28.29) v2(138.86,102.25) v2(138.85,21.64) v2(139.31,72.52) v2(139.4,81.71) v2(139.92,5.37) v2(140.15,113.97) v2(140.27,33.59) v2(140.65,21.64) v2(140.78,28.29) v2(140.92,77.91) v2(141.02,116.91) v2(141.34,79.66) v2(141.71,81.39) v2(141.77,76.15) v2(141.87,84.95) v2(141.87,70.79) v2(142.07,69.01) v2(142.05,67.62) v2(142.12,113.85) v2(142.31,29.81) v2(142.31,28.29) v2(142.45,21.64) v2(142.6,77.91) v2(142.64,72.57) v2(142.72,86.79) v2(142.92,140.33) v2(143.04,84.97) v2(143.05,70.77) v2(143.16,83.21) v2(143.43,81.39) v2(143.58,76.12) v2(143.64,74.16) v2(143.95,29.81) v2(143.95,28.29) v2(144.25,69.02) v2(144.36,72.56) v2(144.86,33.9) v2(145.13,112.17) v2(145.08,5.37) v2(145.3,79.47) v2(145.29,20.88) v2(145.54,116.7) v2(145.61,133.09) v2(146.05,20.12) v2(146.71,115.11) v2(146.75,113.97) v2(147.01,28.29) v2(147.34,25.33) v2(147.55,20.12) v2(147.96,133.54) v2(149.05,21.64) v2(149.05,20.12) v2(149.27,29.81) v2(149.27,28.29) v2(149.3,140.35) v2(150.31,60.95) v2(150.5,0.5) v2(150.62,119.24) v2(150.85,21.64) v2(150.85,20.12) v2(151.15,28.29) v2(151.58,4.3) v2(151.58,3.53) v2(152.21,4.31) v2(152.21,3.55) v2(152.63,29.75) v2(152.64,25.34) v2(152.65,20.12) v2(152.91,4.3) v2(152.91,3.53) v2(153.19,133.05) v2(153.55,4.31) v2(153.55,3.55) v2(154.15,29.81) v2(154.15,28.29) v2(154.24,4.3) v2(154.24,3.53) v2(154.64,125.95) v2(154.9,140.33) v2(154.88,4.31) v2(154.88,3.55) v2(155.16,33.62) v2(155.51,107.37) v2(155.58,0.5) v2(156.26,71.64) v2(156.29,125.62) v2(156.8,28.81) v2(156.8,27.28) v2(156.91,106.99) v2(156.91,106.35) v2(157.09,123.79) v2(158.05,22.53) v2(158.08,61.67) v2(158.44,125.4) v2(158.44,62.13) v2(158.54,28.53) v2(158.54,27.01) v2(158.9,61.71) v2(159.85,22.53) v2(160.42,138.33) v2(160.66,0.5) v2(160.68,123.46) v2(161.64,28.67) v2(161.64,27.14) v2(161.65,22.53) v2(161.65,21.01) v2(163.21,28.67) v2(163.21,27.14) v2(163.45,22.53) v2(163.45,21.01) v2(164.72,26.9) v2(164.74,22.53) v2(165.74,0.5) v2(165.84,30.52) v2(165.84,28.24) v2(165.99,140.33) v2(167.32,29.81) v2(167.55,103.71) v2(167.56,28.43) v2(167.56,26.9) v2(167.96,106.92) v2(168.61,29.81) v2(170.2,29.81) v2(170.2,28.29) v2(170.2,26.76) v2(170.82,0.5) v2(172.03,140.33) v2(172.25,29.81) v2(173.43,29.92) v2(173.43,28.4) v2(173.43,26.87) v2(175.38,33.56) v2(175.77,28.29) v2(175.77,26.76) v2(176.84,59.6) v2(176.81,58.96) v2(177.47,59.6) v2(177.45,58.96) v2(177.6,22.56) v2(178.08,140.33) v2(178.13,59.6) v2(178.12,58.92) v2(178.56,86.86) v2(178.55,3.95) v2(178.59,29.81) v2(178.59,28.29) v2(178.59,26.76) v2(178.81,59.6) v2(178.85,34.17) v2(179.48,59.6) v2(179.48,58.92) v2(180.11,59.6) v2(180.13,58.91) v2(180.22,100.18) v2(180.41,101.53) v2(180.43,28.29) v2(180.53,103.31) v2(180.84,58.89) v2(181.33,82.64) v2(181.68,34.17) v2(181.84,5.35) v2(181.95,29.81) v2(181.95,28.29) v2(182.05,22.55) v2(182.44,103.32) v2(182.44,101.53) v2(182.5,99.43) v2(182.82,140.33) v2(183.43,34.17) v2(183.92,99.46) v2(183.96,29.81) v2(183.96,28.29) v2(183.96,26.76) v2(184.47,103.33) v2(184.47,101.53) v2(185.65,34.09) v2(185.83,27.91) v2(185.83,26.38) v2(187.14,75.11) v2(187.1,27.91) v2(187.1,26.38) v2(187.45,138.34) v2(187.76,5.35) v2(188.34,85.78) v2(188.53,70.6) v2(188.5,69.94) v2(188.64,29.81) v2(188.64,28.29) v2(188.63,26.76) v2(188.65,22.55) v2(189.19,138.36) v2(189.19,70.6) v2(189.18,69.93) v2(189.87,70.6) v2(189.85,69.92) v2(190.54,70.6) v2(190.52,69.99) v2(190.63,27.98) v2(190.95,22.52) v2(191.09,53.05) v2(191.23,70.6) v2(191.23,69.98) v2(191.51,45.27) v2(191.71,136.45) v2(191.84,70.6) v2(191.84,69.95) v2(191.8,53.04) v2(191.96,22.52) v2(192.15,140.33) v2(192.16,29.81) v2(192.16,28.29) v2(192.2,45.27) v2(192.79,22.5) v2(192.9,45.27) v2(193.46,22.52) v2(193.67,5.35) v2(194.05,27.78) v2(194.05,26.26) v2(194.31,140.33) v2(194.29,22.5) v2(194.57,136.58) v2(194.96,76.01) v2(195.33,138.17) v2(195.48,109.01) v2(195.48,108.4) v2(195.48,107.79) v2(195.61,76.01) v2(195.61,75.31) v2(196.6,132.92) v2(196.61,114.89) v2(197.17,32.25) v2(197.17,31.61) v2(198,26.79) v2(198,26.15) v2(198.91,127.31) v2(199.59,5.37) v2(201.23,35.3) v2(201.23,33.77) v2(201.42,77.32) v2(202,15.42) v2(202.63,15.42) v2(203.9,90.1) v2(204.16,93.46) v2(204.16,91.88) v2(204.46,125.01) v2(204.64,72.63) v2(204.64,70.86) v2(204.64,68.89) v2(205.43,93.78) v2(205.55,90.1) v2(205.5,5.37) v2(205.62,92) v2(206.49,72.67) v2(206.48,70.86) v2(206.52,69.38) v2(207.2,116.46) v2(207.2,115.24) v2(207.2,114.1) v2(207.39,93.84) v2(207.39,91.81) v2(207.46,90.03) v2(208.35,116.46) v2(208.35,115.24) v2(208.35,114.1) v2(208.37,70.84) v2(208.41,72.69) v2(208.38,69.37) v2(209.49,116.46) v2(209.49,115.24) v2(209.49,114.1) v2(210.04,127.31) v2(210.58,5.37) v2(211.46,52.21) v2(211.78,60.32) v2(211.78,59.68) v2(212.37,137.14) v2(212.38,133.65) v2(212.38,132.9) v2(212.49,127.69) v2(213.81,54.51) v2(213.95,53.24) v2(214.14,116.41) v2(214.19,124.96) v2(214.42,127.7) v2(215.08,62.21) v2(215.2,134.55) v2(215.33,132.13) v2(215.53,62.67) v2(215.66,5.37) v2(215.95,53.66) v2(216.22,124.32) v2(216.61,116.28) v2(216.97,123.69) v2(217.12,114.71) v2(217.49,135.94) v2(217.49,130.86) v2(218.25,124.96) v2(218.19,62.67) v2(218.89,131.37) v2(218.95,127.66) v2(219.65,134.67) v2(219.78,132.39) v2(220.74,5.37) v2(220.86,78.02) v2(221.11,77.08) v2(221.11,76.44) v2(223.61,82.72) v2(223.61,81.71) v2(223.61,80.69) v2(224.62,82.72) v2(224.62,81.71) v2(224.62,80.69) v2(225.64,82.72) v2(225.64,81.71) v2(225.64,80.69) v2(225.82,5.37) v2(226.38,31.49) v2(226.4,26.05) v2(226.77,125.39) v2(227.21,115.9) v2(228.16,34.06) v2(231.24,24.4) v2(231.41,108.83) v2(231.4,104.95) v2(231.38,100.62) v2(231.42,97.97) v2(231.4,78.53) v2(231.4,73.25) v2(231.4,67.97) v2(231.4,62.68) v2(231.4,57.4) v2(231.4,46.83) v2(231.41,20.59) v2(231.41,15.51) v2(231.54,83.79) v2(231.55,41.6) v2(231.97,95.41) v2(231.97,52.04) v2(232.01,34.74) v2(232.31,5.36) v2(232.4,10.75) v2(233,87.66) v2(233.91,91.98) v2(234.74,116.92) v2(236.01,7.71) v2(238.06,136.83) v2(238.06,135.56) v2(238.06,134.29) v2(239.12,118.49) v2(239.33,136.83) v2(239.33,135.56) v2(239.33,134.29) v2(239.7,118.49) v2(240.11,117.26) v2(240.6,136.83) v2(240.6,135.56) v2(240.6,134.29) v2(241.87,136.83) v2(241.87,135.56) v2(241.87,134.29) v2(243.08,119.07) v2(244.16,124.2) v2(246.02,120.45) v2(251.61,120.45) v2(253,122.57) v2(254.6,124.22) v2(254.76,136.52) v2(254.76,135.25) v2(254.76,133.98) v2(256.03,136.52) v2(256.03,135.25) v2(256.03,133.98) v2(257.19,120.47) v2(257.3,136.52) v2(257.3,135.25) v2(257.3,133.98) v2(258.57,136.52) v2(258.57,135.25) v2(258.57,133.98) v2(261.47,123.08) v2(261.43,122.42) v2(262.78,120.47) v2(265.75,139.5) v2(266.5,137.63) v2(267.97,133.15) v2(269.52,137.71) v2(270.21,139.5) v2(271.78,133.02) v2(275.19,132.77) v2(275.85,129.72) v2(284.66,139.69) v3(21.34,57.33) v3(33.86,44.36) v3(34.85,51.02) v3(44.06,16.37) v3(45.98,16.88) v3(59.84,23.65) v3(71.19,104) v3(73.41,124.51) v3(73.48,101.39) v3(75.25,99.3) v3(78.43,127.5) v3(79.82,127.69) v3(82.43,28.69) v3(87,113.34) v3(88.86,97.91) v3(93.35,18.22) v3(94.3,125.66) v3(97.03,106.35) v3(99.82,109.27) v3(101.67,33.2) v3(106.43,62.21) v3(106.49,128.9) v3(107.51,129.85) v3(117.22,36.12) v3(119.83,106.1) v3(120.02,14.21) v3(129.29,131.37) v3(156.09,107.56) v3(157.75,31.46) v3(161.13,25.86) v3(192.92,71.24) v3(193.8,64.51) v3(207.9,108.32) v3(213.43,130.04) v3(218.54,65.41) v3(240.41,132.2) v3(259.78,134.86) v3(259.84,134.61) v4(34.44,54.42) v4(34.46,53.72) v4(34.55,55.73) v4(34.55,55.1) v4(35.08,54.42) v4(35.09,53.72) v4(35.18,55.73) v4(35.18,55.1) v4(35.71,54.42) v4(35.73,53.72) v4(35.82,55.73) v4(35.82,55.1) v4(36.35,54.42) v4(36.36,53.72) v4(36.45,55.73) v4(36.45,55.1) v4(37.09,55.73) v4(37.09,55.1) v4(41.53,44.92) v4(41.6,46.63) v4(42.17,44.92) v4(42.23,46.63) v4(72.23,103.37) v4(72.21,102.7) v4(72.86,103.37) v4(72.85,102.7) v4(73.52,103.36) v4(73.51,102.68) v4(74.17,103.38) v4(74.17,102.68) v4(86.41,112.18) v4(87.05,112.18) v4(87.68,112.18) v4(88.34,112.2) v4(96.88,111.31) v4(96.88,110.42) v4(96.88,109.53) v4(96.88,108.64) v4(97.52,111.31) v4(97.52,110.42) v4(97.52,109.53) v4(97.52,108.64) v4(98.15,111.31) v4(98.15,110.42) v4(98.15,109.53) v4(98.15,108.64)
