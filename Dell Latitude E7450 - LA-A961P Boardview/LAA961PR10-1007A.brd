# Allegro board LAA961PR10-1007A.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
D_LAD0: length 40.5
  TOP w0.102: UE1.B29 183.94,97.34 184.07,97.47 184.07,98.16 183.85,98.38 v2(183.76,98.38)
  IN2 w0.122: v2(172.74,123.82) 172.74,116.33 178.07,111 178.07,105.16 183.48,99.75 183.48,99.24 183.76,98.96 v2(183.76,98.38)
  BOTTOM w0.102: v2(172.74,123.82) v1(170.91,123.82) 169.93,124.79 168.77,124.79 168.02,125.54 168.02,127.39 167.75,127.66 JDOCK1.97
D_LAD1: length 41.6
  TOP w0.102: v1(172.87,125.86) 172.48,125.86 v2(172.21,126.13) ; UE1.B28 183.44,97.56 v2(183.66,97.79)
  IN2 w0.122: v2(183.66,97.79) 183.34,98.11 183.34,98.88 183.21,99.01 183.21,99.67 177.82,105.06 177.82,110.9 172.32,116.4 172.32,126.02 v2(172.21,126.13)
  BOTTOM w0.102: JDOCK1.99 168.25,126.69 169.41,125.53 171.62,125.53 v2(172.21,126.13)
D_LAD2: length 45.9
  TOP w0.102: v2(172.25,126.74) v1(171.6,126.74) ; v2(182.41,94.47) 182.37,94.5 182.37,95.43 182.69,95.74 UE1.A25
  IN2 w0.122: v2(172.25,126.74) 172.09,126.74 171.8,126.45 171.8,120.01 172.07,119.74 172.07,116.29 177.57,110.79 177.57,104.09 178.03,103.63 178.03,102.37 178.68,101.72 179.62,101.72 182.14,99.2 182.14,96.68 182.33,96.49 182.33,94.54 v2(182.41,94.47)
  BOTTOM w0.102: JDOCK1.103 169.25,126.67 170.16,125.76 171.15,125.76 172.13,126.74 v2(172.25,126.74)
D_LAD3: length 42.3
  TOP w0.102: UE1.A24 182.19,95.82 181.91,95.55 v2(181.91,94.78) ; v1(170.78,125.62) 170.93,125.77 v2(170.93,126.29)
  IN2 w0.122: v2(181.91,94.78) 181.91,96.26 181.31,96.86 181.31,98.63 180.69,99.24 179.05,99.24 177.53,100.77 177.53,103.42 177.07,103.88 177.07,110.26 170.93,116.41 v2(170.93,126.29)
  BOTTOM w0.102: v2(170.93,126.29) 169.75,127.47 JDOCK1.105
D_LFRAME#: length 38.2
  TOP w0.102: v2(170.94,126.88) v1(170.2,126.88) ; UE1.B23 180.94,97.8 v2(180.89,97.85)
  IN2 w0.122: v2(170.94,126.88) 170.77,126.88 170.45,126.56 170.45,116.53 176.82,110.16 176.82,103.78 177.28,103.32 177.28,100.66 179.08,98.86 180.15,98.86 180.45,98.57 180.45,98.29 v2(180.89,97.85)
  BOTTOM w0.102: v2(170.94,126.88) 170.5,127.32 170.5,127.71 170.75,127.96 JDOCK1.109
D_SERIRQ: length 49.1
  TOP w0.102: UE1.A20 180.19,94.65 v2(179.95,94.42) 180.03,94.33 RPE8.3 ; v2(170.94,130.13) v1(170.94,130.93)
  IN2 w0.122: v2(179.95,94.42) 179.57,94.03 179.17,94.03 178.91,94.3 178.91,94.56 178.66,94.81 178.66,96.88 178.42,97.12 178.42,98.82 176.78,100.46 176.78,103.11 176.33,103.57 176.33,109.95 169.95,116.33 169.95,128.65 170.94,129.64 v2(170.94,130.13)
  BOTTOM w0.102: v2(170.94,130.13) 171.92,130.13 172.25,129.8 JDOCK1.115
DAI_12MHZ#: length 156.2
  TOP w0.102: v2(200.99,48.75) 200.68,49.06 200.68,51.09 201.48,51.9 203.93,51.9 206.69,54.65 206.69,57.14 207.1,57.55 207.1,61.64 205.79,62.96 205.44,62.96 203.91,64.48 203.74,64.48 RA30.1
  IN1 w0.084: v2(157.36,53.17) 157.41,53.17 157.87,52.71 164.01,52.71 166.8,49.93 184.8,49.93 185.3,49.43 190.22,49.43 191.03,48.61 200.14,48.61 200.47,48.94 200.8,48.94 v2(200.99,48.75)
  IN2 w0.122: v2(157.36,53.17) 157.37,53.19 157.37,62.33 157.84,62.8 158.99,62.8 159.63,63.44 159.63,67.77 160.41,68.56 160.41,69.75 161.14,70.47 162.1,70.47 163.11,71.49 163.11,72.58 164.92,74.4 164.92,76.61 164.17,77.36 164.17,78.09 164.49,78.41 164.49,79.73 164.05,80.18 164.05,81.06 164.59,81.59 164.59,84.33 164.45,84.47 164.45,88.39 165.61,89.55 165.61,92.46 166.38,93.23 166.38,97.74 165.23,98.89 165.23,100.21 167.01,102 167.01,108.71 167.77,109.46 167.77,126.1 v2(166.94,126.93)
  BOTTOM w0.102: R41.1 165.99,125.23 v1(166.29,125.52) 166.94,126.18 v2(166.94,126.93) 166.12,127.75 164.91,127.75 164.75,127.91 JDOCK1.89
DAI_BCLK#: length 156.8
  TOP w0.102: RA31.1 204.18,64.57 205.56,63.19 205.88,63.19 207.33,61.74 207.33,57.46 206.92,57.04 206.92,54.56 203.71,51.35 201.26,51.35 200.9,50.99 200.9,49.7 201.59,49.01 v2(201.59,49)
  IN1 w0.084: v2(201.59,49) 201.44,49.15 200.38,49.15 200.05,48.82 193.24,48.82 192.42,49.64 185.38,49.64 184.88,50.14 166.88,50.14 163.74,53.28 161.34,53.28 161.03,53.59 156.57,53.59 156.15,53.17 v2(156.15,53.17)
  IN2 w0.122: v2(156.15,53.17) 156.15,53.3 156.67,53.82 156.67,66.22 159.37,68.93 159.37,70.57 160.64,71.84 160.64,73.23 162,74.59 162,75.5 162.93,76.43 162.93,77.47 162.05,78.35 162.05,83.55 162.28,83.77 162.28,84.71 163.46,85.9 163.46,86.41 162.53,87.34 162.53,88.73 164.32,90.53 164.32,97.54 163.99,97.87 163.99,98.56 164.13,98.7 164.13,100.52 165.98,102.37 165.98,109.08 166.77,109.88 166.77,123.29 162.96,127.1 v2(162.94,127.1)
  BOTTOM w0.102: JDOCK1.77 161.75,127.87 162.51,127.1 v2(162.94,127.1) 162.94,125.91 v1(162.55,125.52) 162.23,125.2 R6.1
DAI_DI: length 139.8
  TOP w0.102: v2(209.72,67.62) 209.16,67.06 208.91,67.06 208.68,67.28 UA1.24 ; v1(165.2,125.86) 165.67,126.33 v2(165.67,126.93)
  IN2 w0.122: v2(158.78,63.71) 159.13,64.06 159.13,67.98 159.92,68.76 159.92,69.95 160.93,70.97 161.89,70.97 162.61,71.69 162.61,72.81 163.68,73.87 163.68,78.34 164,78.66 164,79.53 163.55,79.97 163.55,81.26 164.09,81.8 164.09,84.13 163.96,84.26 163.96,89.46 164.82,90.32 164.82,94.86 165.15,95.19 165.15,98.26 164.73,98.68 164.73,100.42 166.52,102.2 166.52,108.92 167.27,109.67 167.27,125.33 v2(165.67,126.93)
  IN3 w0.122: v2(158.78,63.71) 158.75,63.68 158.75,63.2 157.48,61.93 157.47,61.93 157.47,58.45 158.47,57.45 192.11,57.45 197.11,62.45 197.11,65.18 198.07,66.14 203.96,66.14 205.43,67.62 v2(209.72,67.62)
  BOTTOM w0.102: JDOCK1.83 163.25,128.78 163.25,128.02 164.02,127.24 165.36,127.24 v2(165.67,126.93)
DAI_DO#: length 153
  TOP w0.102: v1(166.82,126.05) 166.31,126.56 v2(166.31,126.93) ; v2(201.63,50.88) 203.56,50.88 207.15,54.46 207.15,56.95 207.56,57.36 207.56,61.83 205.98,63.41 205.7,63.41 205.04,64.07 RA32.1
  IN2 w0.122: v2(166.31,126.93) 167.52,125.72 167.52,109.57 166.77,108.81 166.77,102.1 164.98,100.31 164.98,98.78 165.4,98.37 165.4,95.09 165.07,94.76 165.07,90.22 164.21,89.36 164.21,84.36 164.34,84.23 164.34,81.7 163.8,81.16 163.8,80.08 164.24,79.63 164.24,78.56 163.92,78.24 163.92,77.26 164.68,76.51 164.68,74.5 162.86,72.68 162.86,71.59 161.99,70.72 161.04,70.72 160.16,69.85 160.16,68.66 159.38,67.88 159.38,63.54 158.89,63.05 157.74,63.05 157.12,62.43 157.12,53.56 v2(156.73,53.17)
  IN3 w0.122: v2(156.73,53.17) 158.08,54.52 168.39,54.52 171.91,51 186.47,51 187.56,49.9 199.62,49.9 200.6,50.88 v2(201.63,50.88)
  BOTTOM w0.102: v2(166.31,126.93) 165.74,127.5 164.15,127.5 163.75,127.9 JDOCK1.85
DAI_LRCK#: length 137.6
  TOP w0.102: v2(165.1,126.74) 164.3,126.74 v1(163.83,127.21) ; v2(206.19,66.92) 206.28,67.01 UA1.18
  IN2 w0.122: v2(165.1,126.74) 165.1,125.34 167.02,123.42 167.02,109.77 166.22,108.98 166.22,102.26 164.37,100.41 164.37,98.59 164.24,98.46 164.24,97.97 164.57,97.65 164.57,90.42 163.71,89.56 163.71,85.8 162.52,84.61 162.52,83.67 162.3,83.45 162.3,78.52 163.43,77.4 163.43,73.98 161.99,72.54 161.99,72.38 159.67,70.06 159.67,68.87 156.92,66.12 156.92,64.05 157.29,63.68 v2(158.18,63.68)
  IN3 w0.122: v2(206.19,66.92) 204.98,65.71 198,65.71 197.36,65.08 197.36,62.35 192.22,57.2 158.37,57.2 157.22,58.35 157.22,62.06 158.18,63.02 v2(158.18,63.68)
  BOTTOM w0.102: v2(165.1,126.74) 164.85,126.99 163.9,126.99 163.12,127.77 162.47,127.77 162.25,127.99 JDOCK1.79
DAT_DDC2_DOCK: length 45.7
  IN4 w0.084: v2(152.4,133.63) 152.6,133.43 152.6,130.88 150.47,128.74 147.41,128.74 141.55,122.88 141.55,116.39 140.97,115.81 140.97,113.34 139.35,111.72 139.35,110.9 141.19,109.06 141.19,108.63 v2(140.97,108.41)
  BOTTOM w0.102: UV8.M4 148.47,110 148.25,110 147.54,109.29 145.95,109.29 145.71,109.53 141.57,109.53 141.16,109.12 141.16,108.6 v2(140.97,108.41) ; JDOCK1.46 152.75,136.02 152.9,135.87 152.9,135.7 152.61,135.41 152.61,133.83 v2(152.4,133.63)
DAT_KBD: length 83.5
  TOP w0.102: v2(197.84,93.37) 197.76,93.37 v1(197.4,93.74) 197.11,94.03 197.11,95.69 197.29,95.87 RPE2.7 ; UE2.B41 202.03,93 202.31,93.28 v2(202.31,93.41)
  IN1 w0.084: v2(202.31,93.41) 201.91,93.01 201.31,93.01 201.26,93.06 198.16,93.06 v2(197.84,93.37)
  IN4 w0.084: v2(161.55,134.1) 161.75,133.9 167.49,133.9 167.57,133.81 169.41,133.81 174.54,128.68 179.87,128.68 183.89,124.66 190.86,124.66 v2(191.47,124.06)
  BOTTOM w0.102: v2(161.55,134.1) 162.25,134.81 JDOCK1.80 ; v2(191.47,124.06) 191.47,121.33 192.09,120.7 192.09,117.08 192.84,116.34 197.64,116.34 198.5,115.47 198.5,108.39 198.67,108.21 198.67,102.56 198.58,102.47 198.58,98.43 198.34,98.19 198.34,96.62 198.03,96.31 198.03,93.56 v2(197.84,93.37)
DAT_MSE: length 81
  TOP w0.102: v2(161.93,131.63) v1(161.93,132.38) ; v2(199.45,92.66) 199.1,92.66 198.24,93.53 198.24,93.66 198.19,93.71 198.19,94.53 197.84,94.87 RPE2.5 ; v2(202.39,92.36) 201.98,92.76 201.55,92.76 201.29,92.5 UE2.B42
  IN1 w0.084: v2(202.39,92.36) 201.97,92.78 199.57,92.78 v2(199.45,92.66)
  IN2 w0.122: v2(190.82,93.87) 191.22,94.27 191.22,95.95 190.34,96.83 190.34,105.49 189.17,106.67 183.11,106.67 173.53,116.24 173.53,128.53 171.23,130.83 164.53,130.83 164.33,130.64 162.89,130.64 161.93,131.6 v2(161.93,131.63)
  IN3 w0.122: v2(199.45,92.66) 199.39,92.66 197.87,94.19 194.86,94.19 193.99,95.06 192.01,95.06 v2(190.82,93.87)
  BOTTOM w0.102: JDOCK1.73 160.75,130.45 v2(161.93,131.63)
DAT_TP_SIO: length 54.3
  TOP w0.102: RZ18.2 CZ30.1 203.81,56.96 203.81,56.38 v1(203.72,56.28) 203.35,55.92 JKBTP1.13 203.35,53.79 202.15,52.58 199.56,52.58 198.47,53.67 v2(197.56,53.67) ; UE2.B40 201.3,93.5 201.39,93.41 v2(201.73,93.41)
  IN2 w0.122: v2(201.73,93.41) 201.25,92.94 201.25,87.18 200.8,86.72 200.8,84.18 200.88,84.1 200.88,80.86 200.76,80.75 200.76,71.83 200.96,71.63 200.96,66.26 201.26,65.96 201.26,59.2 200.64,58.58 200.64,57.22 197.96,54.54 197.96,54.06 v2(197.56,53.67)
DC_BLOCK_GC: length 47.4
  TOP w0.254: PU800.7 v2(21.91,31.62)
  IN3 w0.254: v2(21.91,31.62) 21.91,31.97 23.07,33.12 27.03,33.12 29.5,35.6 34.6,35.6 35.72,36.72 42.91,36.72 43.8,37.61 49.15,37.61 50.66,39.12 50.66,45.57 51.34,46.24 v2(51.34,49.39)
  BOTTOM w0.102: v2(51.34,49.39) 51.92,49.98 v1(51.92,51.5)
  BOTTOM w0.254: v2(51.34,49.39) 51.29,49.34 PR700.2
DC_IN_SS: length 3.4
  TOP w0.102: v1(15.71,33.06) 16.13,33.48 PR831.2
  TOP w0.254: PR831.2 16.36,34.54 PU800.34
DC_TEST_A3_B3: length 0.7
  BOTTOM w0.089: UC1.A3 137.68,89.74 UC1.B3
DC_TEST_A4: length 7.5
  BOTTOM w0.089: RC192.1 v1(142.81,91.63) 139.69,91.63 138.72,90.67 137.52,90.67 137.11,90.26 UC1.A4
DC_TEST_A60: length 8.8
  BOTTOM w0.109: RC193.1 93.99,91.1 v1(96.14,91.1) 101.46,91.1 102.09,90.48 UC1.A60
DC_TEST_A61_B61: length 0.7
  BOTTOM w0.076: UC1.A61 101.43,89.67 UC1.B61
DC_TEST_A62: length 8.2
  BOTTOM w0.089: 97.45,90.15 100.67,90.15 UC1.A62
  BOTTOM w0.102: 97.45,90.15 v1(94.86,90.15) 94.52,90.49 93.4,90.49 RC193.2
DC_TEST_AV1: length 25.7
  TOP w0.102: v2(143.36,67.62) 143.36,67.43 148.58,62.21 154.98,62.21 156.72,63.95 156.72,65.01 157.32,65.61 RC194.1
  BOTTOM w0.076: UC1.AV1 139.26,68.95 139.91,68.3 v1(142.53,68.3) 142.68,68.3 v2(143.36,67.62)
DC_TEST_AW1: length 26.7
  TOP w0.102: v2(140.77,67.61) 142.71,65.67 144.65,65.67 v1(147.66,62.66) 148.44,61.88 154.97,61.88 156.95,63.86 156.95,64.91 157.42,65.38 159.02,65.38 159.32,65.08 159.98,65.08 RC194.2
  BOTTOM w0.076: v2(140.77,67.61) 140.76,67.62 139.42,67.62 UC1.AW1
DC_TEST_AW63: length 7.9
  BOTTOM w0.089: UC1.AW63 99.55,68.21 96.86,65.51 v1(96.59,65.51) 96.31,65.51 95.66,64.86
  BOTTOM w0.102: 95.66,64.86 95.01,64.2 RC195.1
DC_TEST_AY2_AW2: length 0.7
  BOTTOM w0.076: UC1.AW2 138.16,67.75 UC1.AY2
DC_TEST_AY3_AW3: length 0.7
  BOTTOM w0.076: UC1.AY3 137.55,68.24 UC1.AW3
DC_TEST_AY60: length 9.9
  BOTTOM w0.089: 95.66,64.54 96.32,65.19 96.79,65.19 98.76,67.16 101.59,67.16 UC1.AY60
  BOTTOM w0.102: 95.66,64.54 v1(94.95,63.82) 94.41,63.29 RC195.2
DC_TEST_AY61_AW61: length 0.7
  BOTTOM w0.076: UC1.AY61 101.41,68.21 UC1.AW61
DC_TEST_AY62_AW62: length 0.7
  BOTTOM w0.076: UC1.AW62 100.76,68.2 UC1.AY62
DC_TEST_B62_B63: length 0.7
  BOTTOM w0.254: UC1.B63 100.32,89.54 UC1.B62
DC_TEST_C1_C2: length 0.7
  BOTTOM w0.089: UC1.C2 138.29,89.13 UC1.C1
DDI1_LANE_N0: length 46.2
  TOP w0.102: CV72.1 116.18,119.36 115.61,119.36 v2(115.38,119.13)
  IN1 w0.091: v2(104.3,92.24) 104.62,92.57 104.69,92.57 104.87,92.75 104.87,96.88 105.21,97.22 113.35,97.22 116.59,100.46 116.59,105.26 116.23,105.62 116.23,111.83 116.71,112.3 116.71,116.05 116.51,116.25 115.48,116.25 115.38,116.36 115.38,116.79 115.48,116.89 115.91,116.89 116.11,117.09 116.11,118.27 115.91,118.48 115.64,118.48 115.31,118.81 115.31,119.05 v2(115.38,119.13)
  BOTTOM w0.076: UC1.C54 105.72,89.08 105.55,89.26 105.37,89.26 105.16,89.46 105.13,89.57 105.13,89.7 105.15,89.76 105.17,89.77 105.19,89.85 105.19,90.07 105.13,90.19 105.13,90.63 104.77,90.99 104.02,91.74 103.88,91.88 103.88,92.32 103.97,92.41 104.13,92.41 v2(104.3,92.24)
DDI1_LANE_N0_C: length 2.7
  TOP w0.102: CV72.2 118.01,119.14 118.2,119.14 118.87,118.47 119.09,118.47 119.18,118.38 UV7.4
DDI1_LANE_N1: length 46.4
  TOP w0.102: v2(115.38,117.64) 116.12,117.64 CV74.1
  IN1 w0.091: v2(102.47,92.24) 101.99,92.72 101.5,92.72 101.14,93.08 101.14,93.87 101.56,94.3 101.56,98.77 102.77,99.97 112.67,99.97 113.44,100.74 113.44,106.08 114.12,106.76 114.12,113.72 113.64,114.2 113.64,117.92 113.98,118.26 114.95,118.26 115.17,118.03 115.17,117.85 v2(115.38,117.64)
  BOTTOM w0.076: v2(102.47,92.24) 102.42,92.29 102.42,92.45 102.5,92.52 102.65,92.52 102.7,92.57 102.82,92.57 102.9,92.49 102.9,91.36 103.54,90.73 103.54,89.97 103.5,89.93 103.41,89.93 103.37,89.9 103.37,89.74 103.41,89.7 103.51,89.7 103.54,89.68 103.54,89.55 103.42,89.44 103.42,89.35 UC1.B58
DDI1_LANE_N1_C: length 2.6
  TOP w0.102: CV74.2 118.02,117.33 118.34,117.33 118.57,117.55 118.78,117.55 119.01,117.33 119.01,117.33 119.16,117.18 UV7.7
DDI1_LANE_N2: length 39.9
  TOP w0.102: v2(115.48,114.96) 115.48,115.24 115.65,115.41 116.11,115.41 116.26,115.56 116.38,115.56 CV76.1
  IN1 w0.091: v2(115.48,114.96) 115.21,114.69 115.21,114.55 116.07,113.69 116.07,112.57 115.59,112.1 115.59,106.1 114.94,105.45 114.94,99.76 113.04,97.86 104.33,97.86 103.85,97.39 103.85,94.71 104.01,94.55 104.18,94.55 104.3,94.66 v2(104.3,94.84)
  BOTTOM w0.076: UC1.B55 105.69,89.61 105.9,89.82 105.9,90.55 104.88,91.56 104.88,94.33 104.65,94.57 104.35,94.57 104.3,94.62 v2(104.3,94.84)
DDI1_LANE_N2_C: length 2.8
  TOP w0.102: CV76.2 117.67,115.2 117.99,115.51 118.33,115.51 118.48,115.66 118.54,115.73 118.54,115.97 118.66,116.08 119.28,116.08 119.38,115.98 UV7.10
DDI1_LANE_N3: length 39.9
  TOP w0.102: v2(115.42,112.84) 115.79,113.21 116,113.21 116.25,113.45 116.25,113.65 116.39,113.8 116.69,113.8 116.77,113.73 CV78.1
  IN1 w0.091: v2(102.5,94.19) 102.75,94.45 102.96,94.45 103.14,94.63 103.14,97.12 102.94,97.32 102.55,97.32 102.44,97.43 102.44,97.73 102.57,97.86 103.2,97.86 103.4,98.06 103.4,98.98 103.51,99.09 113.23,99.09 114.26,100.12 114.26,105.74 114.94,106.42 114.94,113.06 115.02,113.14 115.12,113.14 v2(115.42,112.84)
  BOTTOM w0.076: UC1.A57 104.04,90.26 104.16,90.15 104.26,90.15 104.35,90.24 104.35,90.52 103.27,91.59 103.27,94.24 103.02,94.48 102.59,94.48 102.5,94.39 v2(102.5,94.19)
DDI1_LANE_N3_C: length 3
  TOP w0.102: UV7.13 119.38,114.78 119.27,114.89 119.14,114.89 118.66,114.4 118.66,114.2 118.18,113.72 118.03,113.72 CV78.2
DDI1_LANE_P0: length 46.3
  TOP w0.102: v2(114.8,119.13) 115.24,119.57 116.64,119.57 CV71.1
  IN1 w0.091: v2(114.8,119.13) 114.8,119.08 115.57,118.3 115.84,118.3 115.94,118.2 115.94,117.17 115.84,117.06 115.41,117.06 115.21,116.86 115.21,116.28 115.41,116.08 116.44,116.08 116.54,115.98 116.54,112.38 116.06,111.9 116.06,105.54 116.42,105.19 116.42,100.54 113.28,97.39 105.14,97.39 104.7,96.96 104.7,92.82 104.62,92.74 104.45,92.74 v2(104.3,92.89)
  BOTTOM w0.076: v2(104.3,92.89) 104,92.6 103.89,92.6 103.69,92.39 103.69,91.8 103.88,91.61 104.97,90.52 104.97,90.16 105.03,89.99 105.03,89.88 104.98,89.76 104.97,89.73 104.97,89.54 105.01,89.39 105.11,89.24 UC1.C55
DDI1_LANE_P0_C: length 2.7
  TOP w0.102: CV71.2 117.99,119.36 118.29,119.36 118.96,118.69 119.09,118.69 119.18,118.78 UV7.3
DDI1_LANE_P1: length 46.4
  TOP w0.102: v2(114.8,117.64) 115.2,118.05 115.6,118.05 115.79,117.86 116.32,117.86 116.37,117.91 CV73.1
  IN1 w0.091: v2(114.8,117.64) 115,117.85 115,117.96 114.87,118.09 114.05,118.09 113.81,117.85 113.81,114.28 114.3,113.79 114.3,106.69 113.61,106 113.61,100.67 112.74,99.8 102.84,99.8 101.73,98.7 101.73,94.22 101.31,93.8 101.31,93.15 101.57,92.89 v2(102.47,92.89)
  BOTTOM w0.076: UC1.C58 103.48,88.87 103.78,89.17 103.78,89.42 103.73,89.47 103.73,90.81 103.09,91.44 103.09,92.57 102.9,92.76 102.6,92.76 v2(102.47,92.89)
DDI1_LANE_P1_C: length 2.6
  TOP w0.102: UV7.6 119.25,117.58 119.22,117.54 119.1,117.54 118.87,117.77 118.48,117.77 118.25,117.54 118.02,117.54 CV73.2
DDI1_LANE_P2: length 40
  TOP w0.102: CV75.1 116.46,115.78 116.17,115.78 116.02,115.62 115.56,115.62 v2(114.9,114.96)
  IN1 w0.091: v2(104.3,94.19) 104.11,94.38 103.94,94.38 103.68,94.64 103.68,97.46 104.26,98.04 112.97,98.04 114.76,99.83 114.76,105.52 115.42,106.17 115.42,112.17 115.89,112.65 115.89,113.62 115.04,114.48 115.04,114.82 v2(114.9,114.96)
  BOTTOM w0.076: v2(104.3,94.19) 104.48,94.38 104.57,94.38 104.69,94.26 104.69,91.48 105.72,90.45 105.72,89.91 105.64,89.83 105.62,89.83 105.42,90.03 UC1.A55
DDI1_LANE_P2_C: length 2.7
  TOP w0.102: CV75.2 118.02,115.73 118.24,115.73 118.33,115.82 118.33,116.06 118.57,116.3 119.19,116.3 119.27,116.38 UV7.9
DDI1_LANE_P3: length 39.9
  TOP w0.102: v2(115.42,113.43) 115.91,113.43 116.03,113.54 116.03,113.74 116.3,114.02 116.49,114.02 CV77.1
  IN1 w0.091: v2(102.5,94.84) 102.71,94.63 102.89,94.63 102.97,94.71 102.97,97.04 102.87,97.15 102.48,97.15 102.27,97.35 102.27,97.8 102.5,98.03 103.13,98.03 103.23,98.14 103.23,99.06 103.44,99.26 113.16,99.26 114.09,100.19 114.09,105.82 114.77,106.49 114.77,113.13 114.95,113.31 115.31,113.31 v2(115.42,113.43)
  BOTTOM w0.076: UC1.B57 104.04,89.66 104.54,90.16 104.54,90.59 103.46,91.67 103.46,94.31 103.1,94.67 102.66,94.67 v2(102.5,94.84)
DDI1_LANE_P3_C: length 3
  TOP w0.102: CV77.2 118,113.94 118.09,113.94 118.44,114.29 118.44,114.49 119.05,115.1 119.26,115.1 119.33,115.18 UV7.12
DDI2_LANE_N0: length 166.9
  IN1 w0.091: v2(242.97,124.2) 242.99,124.2 243.24,123.95 243.24,123.75 242.83,123.34 240.68,123.34 239.64,122.29 236.55,122.29 236.37,122.47 230,122.47 229.1,123.36 224.25,123.36 223.87,123.75 217.63,123.75 217.15,123.26 212.62,123.26 211.83,122.47 181.22,122.47 180.72,121.97 151.8,121.97 151.26,122.5 142.03,122.5 141.14,121.62 133.94,121.62 128.02,115.69 126.91,115.69 124.86,113.64 120.73,113.64 119.21,112.12 119.21,111.85 120.26,110.79 120.26,110.67 119.97,110.37 119.84,110.37 119.06,111.15 118.74,111.15 118.39,110.8 118.39,110.48 119.17,109.7 119.17,109.57 117.06,107.47 117.06,100.27 112.7,95.91 109.46,95.91 108.73,95.18 108.73,94.89 108.41,94.58 107.93,94.58 107.88,94.63 v2(107.88,94.84)
  BOTTOM w0.076: v2(107.88,94.84) 106.92,93.89 106.92,91.43 107.47,90.88 107.47,90.16 107.53,89.99 107.53,89.88 107.51,89.82 107.49,89.76 107.47,89.73 107.47,89.54 107.52,89.39 107.54,89.35 UC1.C51
  BOTTOM w0.102: CV508.2 243.22,124.72 243.22,124.45 v2(242.97,124.2)
DDI2_LANE_N1: length 166.7
  IN1 w0.091: v2(245.33,124.22) 245.15,124.04 245.15,123.8 243.8,122.46 241.64,122.46 240.45,121.27 230.04,121.27 228.77,122.55 223.91,122.55 223.53,122.93 218,122.93 217.39,122.32 213.19,122.32 212.02,121.15 191.51,121.15 191.03,121.63 181.96,121.63 181.48,121.15 151.6,121.15 151.46,121.01 141.71,121.01 141.5,120.8 134.28,120.8 128.36,114.87 127.38,114.87 125.4,112.89 125.4,111.94 124.56,111.1 121.9,111.1 117.9,107.1 117.9,99.94 112.41,94.45 110.96,94.45 109.93,93.42 109.49,93.42 109.25,93.17 107.42,93.17 106.96,93.63 106.29,93.63 v2(106.1,93.43)
  BOTTOM w0.076: v2(106.1,93.43) 105.88,93.65 105.34,93.65 105.24,93.56 105.24,93.28 105.31,93.21 105.54,93.21 105.72,93.03 105.72,92.38 105.53,92.19 105.39,92.19 105.3,92.1 105.3,91.74 106.26,90.78 106.26,89.43 106.55,89.14 UC1.C53
  BOTTOM w0.102: CV506.2 245.18,124.65 245.18,124.37 v2(245.33,124.22)
DDI2_LANE_N2: length 169.6
  IN1 w0.091: v2(108.73,91.41) 108.73,91.49 108.85,91.62 108.92,91.62 108.97,91.68 109.19,91.68 109.26,91.61 111.04,91.61 114.18,94.75 114.27,94.75 119.98,100.46 119.98,106.18 124.2,110.41 124.93,110.41 126.06,111.54 126.06,112.45 127.83,114.22 129.25,114.22 135.18,120.15 141.78,120.15 141.99,120.36 151.8,120.36 151.93,120.5 183.59,120.5 183.8,120.3 185.71,120.3 185.92,120.5 213.38,120.5 213.88,121 217,121 218.29,122.28 223.23,122.28 223.61,121.9 228.5,121.9 229.78,120.62 240.93,120.62 241.98,121.67 243.98,121.67 244.88,122.58 251,122.58 251.47,123.04 252.61,123.04 252.99,123.43 252.99,124.1 253.17,124.27 253.54,124.27 253.66,124.15 253.66,123.92 253.52,123.78 v2(253.42,123.78)
  BOTTOM w0.076: v2(108.73,91.41) 108.54,91.22 108.54,91.1 108.77,90.88 108.77,89.46 108.8,89.42 108.8,89.2 108.75,89.14 108.75,88.99 108.84,88.9 109,88.9 UC1.C49
  BOTTOM w0.102: v2(253.42,123.78) 253.6,123.96 253.6,124.69 CV504.2
DDI2_LANE_N3: length 169.7
  IN1 w0.084: 106.85,91.61 106.23,91.61
  IN1 w0.091: 106.23,91.61 v2(106.1,91.48) ; 106.85,91.61 107.82,90.65 111.01,90.65 114.26,93.91 114.34,93.91 120.65,100.21 120.65,104.84 125.35,109.54 125.35,109.78 127.07,111.5 127.07,112.55 128,113.48 129.42,113.48 134.99,119.05 145.27,119.05 145.93,119.72 152.06,119.72 152.2,119.86 182.82,119.86 183.44,119.24 189.61,119.24 190.23,119.86 216.77,119.86 218.06,121.15 220.97,121.15 221.11,121.29 222.82,121.29 222.94,121.17 227.73,121.17 228.92,119.98 241.34,119.98 242.32,120.96 244.24,120.96 245.21,121.93 252.04,121.93 252.24,122.12 252.24,122.42 v2(252.39,122.57)
  BOTTOM w0.076: UC1.A53 106.66,90.37 106.66,90.55 106.61,90.6 106.48,90.6 106.42,90.66 106.42,90.83 106.45,90.86 106.61,90.86 106.66,90.91 106.66,91.06 106.61,91.11 106.49,91.11 106.42,91.19 106.42,91.28 106.49,91.35 106.49,91.68 106.34,91.84 106.2,91.84 106.1,91.74 v2(106.1,91.48)
  BOTTOM w0.102: v2(252.39,122.57) 252.25,122.71 252.25,122.97 252.02,123.19 251.43,123.19 CV502.2
DDI2_LANE_P0: length 167
  IN1 w0.091: v2(243.55,124.2) 243.41,124.05 243.41,123.68 242.9,123.17 240.76,123.17 239.71,122.12 236.48,122.12 236.3,122.3 229.93,122.3 229.03,123.19 224.18,123.19 223.79,123.57 217.71,123.57 217.22,123.09 212.69,123.09 211.9,122.3 181.3,122.3 180.79,121.79 151.72,121.79 151.19,122.32 142.1,122.32 141.22,121.44 134.02,121.44 128.09,115.51 126.98,115.51 124.93,113.47 120.8,113.47 119.38,112.05 119.38,111.92 120.44,110.87 120.44,110.59 120.04,110.2 119.77,110.2 118.99,110.97 118.81,110.97 118.57,110.73 118.57,110.55 119.34,109.77 119.34,109.5 117.24,107.39 117.24,100.2 112.78,95.74 109.53,95.74 108.9,95.11 108.9,94.82 108.49,94.4 108.09,94.4 v2(107.88,94.19)
  BOTTOM w0.076: v2(107.88,94.19) 107.5,94.19 107.12,93.81 107.12,91.5 107.64,90.98 107.64,90.19 107.7,90.07 107.7,89.85 107.67,89.77 107.66,89.76 107.64,89.7 107.64,89.57 107.67,89.46 107.88,89.26 108.05,89.26 108.22,89.08 UC1.C50
  BOTTOM w0.102: CV507.2 243.44,124.72 243.44,124.31 v2(243.55,124.2)
DDI2_LANE_P1: length 166.6
  IN1 w0.091: v2(106.1,94.08) 106.1,93.88 106.18,93.8 107.03,93.8 107.49,93.34 109.18,93.34 109.42,93.59 109.85,93.59 110.89,94.63 112.34,94.63 117.72,100.01 117.72,107.17 121.83,111.28 124.49,111.28 125.23,112.01 125.23,112.96 127.31,115.04 128.28,115.04 134.21,120.97 141.43,120.97 141.64,121.18 151.38,121.18 151.52,121.32 181.4,121.32 181.89,121.8 191.1,121.8 191.58,121.32 211.95,121.32 213.12,122.49 217.32,122.49 217.93,123.1 223.6,123.1 223.98,122.72 228.84,122.72 230.12,121.44 240.38,121.44 241.56,122.63 243.73,122.63 244.97,123.87 244.97,124.04 244.79,124.22 v2(244.74,124.22)
  BOTTOM w0.076: UC1.B54 106.07,89.37 106.07,90.7 105.11,91.66 105.11,92.18 105.31,92.38 105.45,92.38 105.53,92.46 105.53,92.95 105.46,93.02 105.23,93.02 105.05,93.2 105.05,93.63 105.26,93.84 105.98,93.84 106.1,93.96 v2(106.1,94.08)
  BOTTOM w0.102: CV505.2 244.96,124.72 244.96,124.44 v2(244.74,124.22)
DDI2_LANE_P2: length 169.7
  IN1 w0.091: v2(108.72,91.98) 108.85,91.85 109.26,91.85 109.33,91.78 110.97,91.78 114.11,94.92 114.2,94.92 119.81,100.53 119.81,106.26 124.13,110.58 124.86,110.58 125.88,111.61 125.88,112.52 127.76,114.4 129.18,114.4 135.1,120.33 141.71,120.33 141.92,120.54 151.72,120.54 151.86,120.68 183.66,120.68 183.87,120.47 185.64,120.47 185.85,120.68 213.31,120.68 213.81,121.17 216.93,121.17 218.21,122.46 223.3,122.46 223.68,122.07 228.57,122.07 229.85,120.8 240.86,120.8 241.91,121.85 243.91,121.85 244.81,122.75 250.93,122.75 251.39,123.22 252.54,123.22 252.82,123.5 252.82,124.17 253.1,124.45 253.61,124.45 253.84,124.22 253.84,123.98 v2(254.04,123.78)
  BOTTOM w0.076: v2(108.72,91.98) 108.35,91.6 108.35,91.03 108.57,90.8 108.57,89.37 UC1.B50
  BOTTOM w0.102: v2(254.04,123.78) 253.81,124.01 253.81,124.72 CV503.2
DDI2_LANE_P3: length 170
  IN1 w0.091: v2(106.1,92.19) 106.1,91.96 106.22,91.84 106.33,91.84 106.38,91.79 106.92,91.79 107.89,90.82 110.93,90.82 114.19,94.08 114.27,94.08 120.47,100.28 120.47,104.91 125.18,109.62 125.18,109.86 126.89,111.57 126.89,112.62 127.93,113.66 129.35,113.66 134.92,119.23 145.19,119.23 145.86,119.89 151.99,119.89 152.13,120.03 182.89,120.03 183.51,119.41 189.54,119.41 190.16,120.03 216.7,120.03 217.99,121.32 220.89,121.32 221.04,121.46 222.89,121.46 223.01,121.34 227.8,121.34 228.99,120.15 241.27,120.15 242.25,121.13 244.16,121.13 245.14,122.1 251.97,122.1 252.06,122.2 252.06,122.31 v2(251.81,122.57)
  BOTTOM w0.076: v2(106.1,92.19) 106.26,92.03 106.42,92.03 106.68,91.76 106.68,91.43 106.85,91.27 106.85,90.06 106.55,89.76 UC1.B53
  BOTTOM w0.102: CV501.2 251.19,122.91 251.26,122.98 251.93,122.98 252.03,122.88 252.03,122.8 v2(251.81,122.57)
DDR3_DRAMRST#: length 86.9
  TOP w0.102: v2(65.97,22.56) 66.49,23.08 RD3.1 CD6.1
  IN4 w0.084: v2(65.97,22.56) 66.45,23.04 95.99,23.04 97.61,21.41 110.97,21.41 111.46,21.9 119.3,21.9 120.49,23.09 125.99,23.09 130.48,18.6 v2(134.88,18.6)
  BOTTOM w0.102: JDIMM1.30 65.85,23.94 65.85,22.67 v2(65.97,22.56) ; JDIMM2.30 141.85,22.71 141.77,22.63 141.77,20.56 141.1,19.89 CD35.1 136.51,19.1 135.38,19.1 v2(134.88,18.6)
DDR3_DRAMRST#_CPU: length 97.9
  TOP w0.102: v2(85.74,57.02) v1(85.74,55.12) 85.74,49.33 78.41,42 78.41,40.73 72.91,35.23 72.91,32.96 70.12,30.17 70.12,28.69 68.61,27.18 68.61,26.83 67.63,25.85 RD2.2 RD3.2
  BOTTOM w0.076: UC1.AV15 129.9,68.68 129.9,68.17 129.98,68.09 129.98,67.83 129.9,67.76 129.9,67.51 130.09,67.33 130.09,66.17 130.28,65.98 130.28,65.03 130.36,64.95 130.36,61.26 CC101.1
  BOTTOM w0.102: v2(85.74,57.02) 128.86,57.02 131.09,59.25 CC101.1
DDR_A_BS0: length 63.6
  IN1 w0.089: 117.34,60.77 118.1,61.53 118.1,62.46 118.15,62.52 118.15,64.19 v2(118.4,64.43)
  IN1 w0.132: v2(92.3,30.57) 92.3,31.54 92.42,31.67 93.17,31.67 93.3,31.8 93.3,33.63 93.77,34.11 94.58,34.11 96.43,35.95 99.27,35.95 99.64,36.32 99.82,36.32 100.19,35.95 100.38,35.95 100.66,36.23 100.66,36.42 100.29,36.79 100.29,36.98 100.57,37.26 100.76,37.26 101.13,36.89 101.31,36.89 101.59,37.17 101.59,37.35 101.22,37.72 101.22,37.91 101.5,38.19 101.69,38.19 102.06,37.82 102.25,37.82 102.53,38.1 102.53,38.29 102.16,38.66 102.16,38.85 102.44,39.13 102.62,39.13 102.99,38.76 103.18,38.76 103.46,39.04 103.46,39.22 103.09,39.59 103.09,39.78 103.37,40.06 103.56,40.06 103.93,39.69 104.12,39.69 104.4,39.97 104.4,40.16 104.03,40.53 104.03,40.71 104.31,40.99 104.49,40.99 104.86,40.62 105.05,40.62 105.33,40.9 105.33,41.09 104.96,41.46 104.96,41.65 105.24,41.93 105.43,41.93 105.8,41.56 105.98,41.56 106.26,41.84 106.26,42.03 105.89,42.4 105.89,42.58 117.34,54.03 117.34,60.77
  BOTTOM w0.076: UC1.AU35 117.78,69.44 117.78,69.38 117.51,69.11 117.51,67.39 117.54,67.37 117.54,65.29 v2(118.4,64.43)
  BOTTOM w0.17: v2(92.3,30.57) 92.14,30.57 91.95,30.76 91.95,32.14 JDIMM1.109
DDR_A_BS1: length 64.7
  IN1 w0.089: v2(118.4,65.08) 118.95,64.52 118.95,61.94 117.73,60.71
  IN1 w0.132: v2(92.85,27.02) 92.98,27.16 92.98,30.9 93.8,31.71 93.8,32.78 96.59,35.57 100.54,35.57 106.81,41.84 106.81,42.02 106.44,42.4 106.44,42.58 106.73,42.87 106.9,42.87 107.28,42.49 107.46,42.49 107.75,42.77 107.75,42.96 107.37,43.33 107.37,43.51 107.66,43.8 107.84,43.8 108.21,43.43 108.4,43.43 108.68,43.71 108.68,43.89 108.31,44.27 108.31,44.45 108.59,44.73 108.77,44.73 109.15,44.36 109.33,44.36 109.61,44.64 109.61,44.83 109.24,45.2 109.24,45.38 109.53,45.67 109.71,45.67 110.08,45.29 110.27,45.29 110.55,45.58 110.55,45.76 110.17,46.14 110.17,46.32 117.73,53.87 117.73,60.71
  BOTTOM w0.076: v2(118.4,65.08) 117.71,65.77 117.71,67.43 117.68,67.46 117.68,68.64 UC1.AV35
  BOTTOM w0.17: v2(92.85,27.02) 92.33,26.5 92.33,25.84 91.65,25.15 JDIMM1.108
DDR_A_BS2: length 60.8
  IN1 w0.132: v2(80.79,29.05) 80.79,28.8 80.89,28.7 81.33,28.7 81.43,28.8 81.43,32.39 80.68,33.15 80.68,34.17 91.26,44.75 93.24,44.75 97.8,49.31 98.41,49.92 99.5,49.92 105.09,55.52 106.89,55.52 107.86,56.48 107.86,59.02 108.1,59.27 108.1,59.27 112.74,63.91 112.74,65.71 v2(113.67,66.64)
  BOTTOM w0.076: v2(113.67,66.64) 114.07,67.03 114.07,67.11 114.07,67.11 114.07,67.46 114.07,67.46 UC1.AY41
  BOTTOM w0.17: JDIMM1.79 82.95,31.21 v2(80.79,29.05)
DDR_A_CAS#: length 63.3
  IN1 w0.089: 118.88,60.76 119.53,61.41 119.53,68.16 v2(118.4,69.29)
  IN1 w0.132: 118.88,60.76 118.88,53.39 117.38,51.88 117.38,49.37 115.7,47.68 115.51,47.68 114.99,48.2 114.81,48.2 114.52,47.91 114.52,47.73 115.04,47.21 115.04,47.03 114.76,46.75 114.58,46.75 114.06,47.27 113.88,47.27 113.59,46.98 113.59,46.8 114.11,46.28 114.11,46.09 113.83,45.81 113.64,45.81 113.12,46.33 112.94,46.33 112.66,46.04 112.66,45.86 113.17,45.35 113.17,45.16 112.89,44.88 112.71,44.88 112.19,45.4 112.01,45.4 111.72,45.11 111.72,44.93 112.24,44.41 112.24,44.22 111.96,43.94 111.77,43.94 111.25,44.46 111.07,44.46 110.79,44.18 110.79,44 111.31,43.48 111.31,43.29 111.03,43.01 110.84,43.01 110.32,43.53 110.14,43.53 101.02,34.41 98.19,34.41 v2(94.35,30.57)
  BOTTOM w0.076: v2(118.4,69.29) 118.54,69.29 UC1.AU34
  BOTTOM w0.17: v2(94.35,30.57) 93.75,31.17 JDIMM1.115
DDR_A_D0: length 64.7
  IN4 w0.084: v2(94.15,72.7) 93.33,71.88 93.33,69.1 88.05,63.82 88.05,49.3 87.51,48.76 87.51,41.83 87.59,41.74 88.02,41.74 88.1,41.66 88.1,41.34 88.02,41.25 87.59,41.25 87.51,41.17 87.51,40.85 87.59,40.76 88.02,40.76 88.1,40.68 88.1,39.57 88.53,39.14 88.53,39.02 88.43,38.92 88.43,38.8 88.66,38.58 88.78,38.58 88.88,38.68 89,38.68 89.23,38.45 89.23,38.33 89.13,38.23 89.13,38.11 89.35,37.88 89.47,37.88 89.57,37.98 89.69,37.98 89.92,37.75 89.92,37.64 89.82,37.54 89.82,37.42 90.05,37.19 90.17,37.19 90.27,37.29 90.39,37.29 90.61,37.06 90.61,36.94 90.51,36.84 90.51,36.72 90.74,36.49 90.86,36.49 90.96,36.6 91.08,36.6 91.31,36.37 91.31,36.25 91.21,36.15 91.21,36.03 91.43,35.8 91.55,35.8 91.65,35.9 91.77,35.9 92,35.67 92,35.56 91.9,35.45 91.9,35.34 92.13,35.11 92.25,35.11 92.35,35.21 92.47,35.21 93.35,34.33 93.35,33.55 96.58,30.31 96.58,29.37 96.72,29.23 v2(97.42,29.23)
  BOTTOM w0.076: UC1.AH63 99.93,74.99 99.8,74.86 99.11,74.86 98.41,74.16 96.18,74.16 94.72,72.7 94.62,72.7
  BOTTOM w0.102: 94.62,72.7 v2(94.15,72.7) ; v2(97.42,29.23) 98.05,29.86 98.05,30.64 97.95,30.73 JDIMM1.129
DDR_A_D1: length 65.2
  IN4 w0.084: v2(94.91,73.65) 94.47,73.65 93.02,72.2 93.02,69.23 87.74,63.94 87.74,49.43 87.2,48.89 87.2,39.6 93.04,33.76 93.04,33.42 96.27,30.18 96.27,28.85 v2(97.42,27.71)
  BOTTOM w0.076: UC1.AH62 100.64,75.19 100.44,75.19 100.26,75.28 99.99,75.28 99.73,75.02 99.04,75.02 98.37,74.35 96.14,74.35 95.44,73.65 v2(94.91,73.65)
  BOTTOM w0.102: JDIMM1.131 98.55,28.84 v2(97.42,27.71)
DDR_A_D2: length 63.9
  IN4 w0.084: v2(101.74,28.38) 101.41,28.38 101.29,28.25 101.29,26.91 101.16,26.78 100.8,26.78 100.67,26.91 100.67,30.56 98.13,33.1 97.5,33.1 97.28,33.31 97.28,34.09 90.72,40.66 90.72,62.79 95.99,68.06 95.99,69.81 97.74,71.56 97.74,72.14 v2(97.12,72.77)
  BOTTOM w0.076: v2(97.12,72.77) 97.6,72.77 97.83,72.99 98.78,72.99 99.05,73.26 99.55,73.26 99.79,73.51 100.06,73.51 UC1.AK63
  BOTTOM w0.102: v2(101.74,28.38) 101.35,28.38 101.22,28.5 101.22,30.88 101.55,31.21 JDIMM1.141
DDR_A_D3: length 64.4
  IN4 w0.084: v2(96.28,71.92) 96.28,71.33 95.76,70.82 95.76,68.28 90.4,62.92 90.4,40.53 96.97,33.96 96.97,33.18 97.37,32.78 98,32.78 100.36,30.43 100.36,25.94 100.49,25.82 101.09,25.82 101.22,25.94 101.22,26.34 101.35,26.47 101.61,26.47 101.74,26.59 v2(101.74,26.85)
  BOTTOM w0.076: v2(96.28,71.92) 96.82,71.92 97.25,72.35 97.43,72.35 97.9,72.83 98.85,72.83 99.12,73.1 99.62,73.1 99.86,73.34 100.31,73.34 100.6,73.63 UC1.AK62
  BOTTOM w0.102: v2(101.74,26.85) 101.74,27.1 101.61,27.23 101.38,27.23 101.25,27.1 101.25,23.94 JDIMM1.140
DDR_A_D4: length 65.9
  IN4 w0.084: v2(99.45,25.42) 97.81,27.06 97.81,30.16 97.18,30.79 96.54,30.79 94.36,32.98 94.36,33.75 88.41,39.7 88.41,42.09 87.82,42.68 87.82,48.63 87.95,48.76 88.23,48.76 88.36,48.88 88.36,63.69 93.64,68.97 93.64,71.57 95.29,73.23 v2(95.29,74.16)
  BOTTOM w0.076: UC1.AH61 101.11,75.37 100.44,75.37 100.34,75.42 100.3,75.44 99.92,75.44 99.67,75.2 98.98,75.2 98.3,74.51 95.65,74.51 v2(95.29,74.16)
  BOTTOM w0.102: JDIMM1.132 98.85,24.99 99.28,25.42 v2(99.45,25.42)
DDR_A_D5: length 66.5
  IN4 w0.084: v2(99.45,26.94) 98.13,28.27 98.13,30.29 97.31,31.11 96.67,31.11 94.68,33.1 94.68,33.88 88.73,39.83 88.73,42.21 88.19,42.76 88.19,47.26 88.27,47.34 88.59,47.34 88.67,47.42 88.67,47.75 88.59,47.83 88.27,47.83 88.19,47.91 88.19,48.24 88.27,48.32 88.59,48.32 88.67,48.4 88.67,63.56 93.96,68.84 93.96,71.27 v2(95.04,72.36)
  BOTTOM w0.076: 95.66,72.36 96.01,72.36 97.26,73.61 99.43,73.61 99.66,73.84 99.75,73.84 100,74.09 100.29,74.09 100.45,74.02 100.58,74.02 100.74,74.09 100.94,74.09 100.99,74.07 101.08,74.03 101.1,74.02 101.29,74.02 101.3,74.03 101.68,74.03 101.69,74.02 101.94,74.02 102.14,74.22 UC1.AH60
  BOTTOM w0.102: v2(99.45,26.94) 98.25,25.74 98.25,23.94 JDIMM1.130 ; 95.66,72.36 v2(95.04,72.36)
DDR_A_D6: length 64.9
  IN4 w0.084: v2(97.42,73.24) 97.42,73.52 97.54,73.65 98.34,73.65 98.47,73.52 98.47,72.05 96.25,69.82 96.25,69.43 96.37,69.3 97.4,69.3 97.52,69.17 97.52,68.89 97.4,68.76 96.37,68.76 96.25,68.63 96.25,67.88 91.03,62.66 91.03,40.79 98.36,33.46 98.36,33.31 100.98,30.69 100.98,29.64 101.11,29.51 101.61,29.51 101.74,29.64 v2(101.74,29.9)
  BOTTOM w0.076: UC1.AK61 101.15,73.74 101.01,73.88 100.9,73.93 100.77,73.93 100.75,73.92 100.67,73.88 100.62,73.85 100.41,73.85 100.25,73.93 100.07,73.93 99.81,73.67 99.72,73.67 99.48,73.43 98.99,73.43 98.71,73.16 97.5,73.16 v2(97.42,73.24)
  BOTTOM w0.102: v2(101.74,29.9) 101.74,29.65 101.86,29.53 102.37,29.53 102.5,29.65 102.5,30.34 102.37,30.47 101.86,30.47 101.74,30.6 101.74,30.84 101.86,30.96 102.02,30.96 102.15,31.09 JDIMM1.143
DDR_A_D7: length 65.8
  IN4 w0.084: v2(95.84,71.5) 95.84,71.34 95.43,70.93 95.43,68.38 90.09,63.05 90.09,40.4 96.04,34.45 96.04,33.67 97.24,32.47 97.87,32.47 100.05,30.3 100.05,24.65 100.17,24.52 100.38,24.52 100.46,24.61 100.46,24.88 100.59,25.01 100.82,25.01 100.95,24.88 100.95,24.65 101.08,24.52 101.75,24.52 101.88,24.65 101.88,25.2 101.75,25.33 v2(101.74,25.33)
  BOTTOM w0.076: UC1.AK60 101.9,73.74 101.61,73.45 101.37,73.45 101.35,73.47 101.09,73.47 100.96,73.34 100.54,73.34 100.38,73.18 99.93,73.18 99.69,72.93 99.19,72.93 98.9,72.64 97.96,72.64 97.45,72.13 97.26,72.13 96.64,71.5 v2(95.84,71.5)
  BOTTOM w0.102: JDIMM1.142 101.85,23.94 101.85,25.21 v2(101.74,25.33)
DDR_A_D8: length 73.8
  IN1 w0.084: v2(59.01,30.57) 59.31,30.87 59.31,31.4 59.22,31.49 58.84,31.49 58.76,31.57 58.76,31.89 58.84,31.98 59.22,31.98 59.31,32.06 59.31,32.38 59.22,32.47 58.84,32.47 58.76,32.55 58.76,32.87 58.84,32.96 59.22,32.96 59.31,33.04 59.31,36.38 63.6,40.67 63.6,41.81 67.84,46.05 67.99,46.05 68.42,45.62 68.55,45.62 69.05,46.12 69.05,46.24 68.44,46.85 68.44,47.03 68.61,47.2 68.79,47.2 69.4,46.59 69.51,46.59 69.74,46.82 69.74,46.94 69.1,47.58 69.1,47.76 69.27,47.92 69.45,47.92 70.09,47.28 70.21,47.28 70.44,47.51 70.44,47.63 69.99,48.08 69.99,48.2 70.22,48.42 70.34,48.42 70.78,47.98 70.9,47.98 75.09,52.16 78.15,55.23 78.15,56.83 81.77,60.44 81.77,60.7 84.52,63.45 89.05,63.45 94.68,69.08 96.92,69.08 97.42,69.58 97.42,69.92 v2(97.18,70.16)
  BOTTOM w0.076: UC1.AM63 100.01,72.56 99.88,72.43 99.39,72.43 99.11,72.15 98.26,72.15 97.92,71.81 97.92,71.5 97.18,70.75 v2(97.18,70.16)
  BOTTOM w0.102: v2(59.01,30.57) 58.95,30.63 58.95,32.14 JDIMM1.7
DDR_A_D9: length 74.6
  IN1 w0.084: v2(57.48,25.62) 57.06,25.62 56.96,25.72 56.96,26.47 56.88,26.56 56.62,26.56 56.52,26.66 56.52,26.95 56.62,27.05 56.88,27.05 56.96,27.13 56.96,27.95 57.82,28.81 57.82,36.43 59.37,37.98 59.58,37.98 62.66,41.06 62.66,42.89 69.33,49.55 69.33,49.71 80.83,61.22 80.83,62.2 83.02,64.39 88.66,64.39 95.4,71.13 95.99,71.13 96.42,71.56 96.74,71.56 v2(96.97,71.32)
  BOTTOM w0.076: v2(96.97,71.32) 97.51,71.32 97.76,71.56 97.76,71.88 98.19,72.31 99.04,72.31 99.32,72.59 99.81,72.59 100.07,72.85 100.31,72.85 100.6,72.56 UC1.AM62
  BOTTOM w0.102: JDIMM1.4 58.05,23.94 58.05,25.05 v2(57.48,25.62)
DDR_A_D10: length 73
  IN1 w0.084: v2(97.8,68.64) 97.85,68.69 98.06,68.69 98.17,68.58 98.17,68.49 96.48,66.8 94.77,66.8 89.74,61.77 86.06,61.77 79.83,55.55 79.83,54.53 77.98,52.68 77.98,52.57 78.06,52.48 78.06,52.34 77.86,52.14 77.72,52.14 77.63,52.22 77.52,52.22 77.29,51.99 77.29,51.87 77.37,51.79 77.37,51.65 77.17,51.44 77.02,51.44 76.94,51.53 76.82,51.53 76.59,51.3 76.59,51.18 76.68,51.1 76.68,50.95 76.47,50.75 76.33,50.75 76.25,50.83 76.13,50.83 75.9,50.6 75.9,50.49 75.98,50.4 75.98,50.26 75.78,50.06 75.64,50.06 75.55,50.14 75.44,50.14 67.64,42.34 67.52,42.34 67.25,42.61 67.13,42.61 66.9,42.38 66.9,42.26 67.17,41.99 67.17,41.87 61.53,36.23 61.53,33.78 61.33,33.58 61.33,32.72 61.25,32.64 61.07,32.64 60.98,32.55 60.98,32.23 61.07,32.15 61.25,32.15 61.33,32.06 61.33,31.74 61.25,31.66 61.07,31.66 60.98,31.57 60.98,31.25 61.07,31.17 61.23,31.17 61.33,31.07 61.33,30.61 61.23,30.51 61.16,30.51 61.06,30.41 61.06,30.12 61.16,30.02 61.23,30.02 61.33,29.92 61.33,28.77 61.23,28.66 60.83,28.66 60.7,28.79 v2(60.7,29.05)
  BOTTOM w0.076: v2(97.8,68.64) 97.37,68.64 97.27,68.74 97.27,69.04 97.37,69.14 97.75,69.14 97.86,69.24 97.86,69.63 98.91,70.68 99.27,70.68 99.92,71.33 100.06,71.33 UC1.AP63
  BOTTOM w0.102: v2(60.7,29.05) 60.7,28.79 60.8,28.69 61.2,28.69 61.3,28.79 61.3,30.03 61.95,30.68 61.95,32.14 JDIMM1.17
DDR_A_D11: length 74.1
  IN1 w0.084: v2(62.55,26) 62.55,25.84 62.42,25.71 60.8,25.71 60.67,25.84 60.67,26.24 60.8,26.37 62.03,26.37 62.15,26.5 62.15,26.8 62.03,26.93 60.77,26.93 60.65,27.05 60.65,27.45 60.77,27.58 61.56,27.58 61.65,27.66 61.65,33.45 61.84,33.65 61.84,36.1 75.42,49.68 75.85,49.68 78.56,52.4 78.56,52.82 80.14,54.4 80.14,55.42 86.19,61.46 89.87,61.46 94.9,66.48 96.41,66.48 98.68,68.75 98.68,68.97 98.62,69.04 v2(98.2,69.04)
  BOTTOM w0.076: v2(98.2,69.04) 98.2,69.73 98.98,70.51 99.34,70.51 99.74,70.91 100.31,70.91 100.6,71.2 UC1.AP62
  BOTTOM w0.102: v2(62.55,26) 62.25,25.7 JDIMM1.18
DDR_A_D12: length 75.2
  IN1 w0.084: v2(57.48,27.14) 58.13,27.8 58.13,36.3 59.5,37.67 59.71,37.67 62.97,40.93 62.97,42.76 69.64,49.42 69.64,49.58 75.21,55.15 75.33,55.15 75.65,54.83 75.8,54.83 76,55.03 76,55.18 75.67,55.5 75.67,55.62 81.14,61.09 81.14,62.07 83.15,64.07 88.79,64.07 94.62,69.9 96.33,69.9 97.37,70.95 v2(97.37,71.72)
  BOTTOM w0.076: UC1.AM61 101.36,72.45 100.96,72.85 100.54,72.85 100.38,73.01 100,73.01 99.74,72.76 99.25,72.76 98.97,72.48 98.13,72.48 97.37,71.72 v2(97.37,71.72)
  BOTTOM w0.102: v2(57.48,27.14) 58.36,26.27 58.36,25.3 58.65,25.01 JDIMM1.6
DDR_A_D13: length 76.1
  IN1 w0.084: v2(59.01,29.05) 58.45,29.61 58.45,34.01 58.55,34.11 58.89,34.11 58.99,34.21 58.99,34.52 58.91,34.6 58.53,34.6 58.45,34.68 58.45,35.01 58.53,35.09 58.91,35.09 58.99,35.17 58.99,36.51 63.29,40.8 63.29,42.63 69.59,48.93 71.41,48.93 75.4,52.92 76.13,53.64 77.05,54.56 77.05,54.68 76.74,54.99 76.74,55.13 76.94,55.34 77.08,55.34 77.39,55.03 77.51,55.03 77.84,55.36 77.84,56.96 81.45,60.57 81.45,61.94 82.48,62.97 82.6,62.97 83.04,62.53 83.16,62.53 83.38,62.76 83.38,62.88 82.95,63.31 82.95,63.43 83.28,63.76 88.92,63.76 94.55,69.4 96.46,69.4 v2(96.73,69.67)
  BOTTOM w0.076: v2(96.73,69.67) 97.43,69.67 98.77,71.01 99.13,71.01 99.79,71.66 100.29,71.66 100.45,71.59 100.58,71.59 100.74,71.66 100.94,71.66 100.99,71.64 101.08,71.6 101.1,71.59 101.94,71.59 102.14,71.79 UC1.AM60
  BOTTOM w0.102: JDIMM1.5 58.35,32.14 58.35,29.71 v2(59.01,29.05)
DDR_A_D14: length 73.8
  IN1 w0.084: v2(96.94,67.77) 96.33,67.77 96.27,67.71 96.09,67.71 96.01,67.63 96.01,67.21 95.91,67.11 95.62,67.11 95.52,67.21 95.52,67.63 95.44,67.71 95.24,67.71 89.61,62.08 85.93,62.08 85.5,61.66 85.39,61.66 85.08,61.97 84.96,61.97 84.74,61.74 84.74,61.62 85.04,61.32 85.04,61.2 84.81,60.97 84.69,60.97 84.39,61.27 84.27,61.27 84.04,61.04 84.04,60.93 84.35,60.62 84.35,60.5 84.12,60.28 84,60.28 83.9,60.38 83.75,60.38 83.55,60.17 83.55,60.03 83.65,59.93 83.65,59.81 79.52,55.68 79.52,54.66 68.39,43.54 68.27,43.54 67.85,43.95 67.67,43.95 67.51,43.79 67.51,43.61 67.92,43.19 67.92,43.07 67.7,42.84 67.58,42.84 67.16,43.26 66.98,43.26 66.81,43.09 66.81,42.91 66.86,42.87 66.86,42.78 66.3,42.22 66.3,42.04 66.54,41.8 66.54,41.68 66.31,41.46 66.19,41.46 65.86,41.79 65.68,41.79 65.51,41.62 65.51,41.44 65.84,41.11 65.84,40.99 65.62,40.76 65.5,40.76 65.31,40.95 65.13,40.95 64.96,40.78 64.96,40.6 65.15,40.41 65.15,40.3 61.22,36.36 61.22,35.86 61.13,35.77 60.77,35.77 60.67,35.67 60.67,35.38 60.77,35.28 61.11,35.28 61.22,35.18 61.22,34.89 61.11,34.79 60.8,34.79 60.67,34.66 60.67,34.43 60.8,34.3 61.13,34.3 61.22,34.22 61.22,33.91 60.67,33.36 60.67,30.6 v2(60.7,30.57)
  BOTTOM w0.076: UC1.AP61 101.25,71.2 101.01,71.45 100.9,71.5 100.77,71.5 100.75,71.49 100.67,71.45 100.67,71.45 100.62,71.42 100.41,71.42 100.25,71.5 99.85,71.5 99.2,70.84 98.84,70.84 96.94,68.94 v2(96.94,67.77)
  BOTTOM w0.102: JDIMM1.15 61.35,32.14 61.35,31.05 60.87,30.57 v2(60.7,30.57)
DDR_A_D15: length 75.2
  IN1 w0.084: v2(98.59,69.43) 99,69.03 99,68.82 96.35,66.17 95.02,66.17 89.93,61.08 86.4,61.08 80.45,55.14 80.45,53.85 80.13,53.52 80.01,53.52 79.91,53.61 79.79,53.61 79.57,53.38 79.57,53.27 79.66,53.17 79.66,53.05 79.43,52.83 79.31,52.83 79.22,52.92 79.1,52.92 78.87,52.69 78.87,52.57 78.97,52.48 78.97,52.36 75.98,49.37 75.55,49.37 65.37,39.19 65.37,39.07 65.63,38.81 65.63,38.67 65.43,38.46 65.29,38.46 65.04,38.71 64.89,38.71 64.69,38.51 64.69,38.37 64.94,38.12 64.94,37.97 64.74,37.77 64.59,37.77 64.34,38.02 64.2,38.02 64,37.82 64,37.67 64.25,37.42 64.25,37.28 64.04,37.08 63.9,37.08 63.65,37.33 63.51,37.33 63.3,37.12 63.3,36.98 63.58,36.7 63.58,36.56 63.38,36.35 63.23,36.35 62.96,36.63 62.81,36.63 62.53,36.35 62.53,36.21 62.68,36.06 62.68,35.95 62.15,35.43 62.15,33.52 61.96,33.32 61.96,32.6 62.08,32.47 62.33,32.47 62.43,32.37 62.43,32.08 62.33,31.98 62.08,31.98 61.96,31.85 61.96,27.36 62.02,27.3 62.48,27.3 62.55,27.36 v2(62.55,27.53)
  BOTTOM w0.076: UC1.AP60 101.91,70.98 101.68,70.98 101.61,70.91 101.37,70.91 101.36,70.92 100.97,70.92 100.96,70.91 100.54,70.91 100.38,70.75 99.81,70.75 99.41,70.35 99.04,70.35 98.59,69.9 v2(98.59,69.43)
  BOTTOM w0.102: v2(62.55,27.53) 61.65,26.63 JDIMM1.16
DDR_A_D16: length 60.2
  IN4 w0.084: v2(105.04,28.97) 105.35,28.97 105.48,28.84 105.48,27.85 105.6,27.72 105.86,27.72 105.99,27.85 105.99,29.62 105.86,29.75 105.56,29.75 105.44,29.87 105.44,30.94 103.46,32.92 103.46,34.4 94.41,43.46 94.41,61.44 98.01,65.04 98.07,65.04 101.4,68.37 101.4,68.98 101.71,69.29 102.68,69.29 103.35,69.96 103.35,70.98 103.26,71.07 v2(102.96,71.07)
  BOTTOM w0.089: v2(102.96,71.07) 103.28,71.4 UC1.AP58
  BOTTOM w0.102: JDIMM1.159 106.95,32.14 106.95,29.94 105.77,28.76 105.25,28.76 v2(105.04,28.97)
DDR_A_D17: length 59.3
  IN4 w0.084: v2(102.96,70.42) 102.98,70.42 103.11,70.29 103.11,70.09 102.98,69.97 102.6,69.97 102.28,69.65 101.63,69.65 96.87,64.89 96.87,64.34 94.09,61.57 94.09,43.33 94.41,43.01 94.41,42.9 94.09,42.58 94.09,42.4 94.26,42.24 94.44,42.24 94.72,42.52 94.9,42.52 95.07,42.35 95.07,42.17 94.76,41.86 94.76,41.68 94.93,41.52 95.11,41.52 95.41,41.82 95.59,41.82 95.76,41.66 95.76,41.48 95.46,41.17 95.46,40.99 95.62,40.82 95.8,40.82 96.11,41.13 96.29,41.13 96.46,40.96 96.46,40.78 96.15,40.48 96.15,40.3 96.32,40.13 96.5,40.13 96.8,40.44 96.98,40.44 97.15,40.27 97.15,40.09 96.88,39.82 96.88,39.64 97.05,39.47 97.23,39.47 97.45,39.7 97.72,39.7 103.15,34.27 103.15,32.79 105.04,30.89 v2(105.04,30.49)
  BOTTOM w0.089: UC1.AR58 103.28,70.75 v2(102.96,70.42)
  BOTTOM w0.102: JDIMM1.157 106.35,32.14 106.35,30.05 106.25,29.95 105.81,29.95 105.7,30.05 105.7,30.79 105.6,30.89 105.14,30.89 105.04,30.79 v2(105.04,30.49)
DDR_A_D18: length 62.5
  IN4 w0.084: v2(103.9,72.39) 103.46,72.82 103.46,73.62 103.11,73.97 102.8,73.97 102.31,73.47 102.31,73.29 99.88,70.86 99.88,69.89 96.65,66.67 96.32,66.67 92.03,62.38 92.03,41.06 98.72,34.37 98.94,34.37 99.45,33.86 99.45,33.5 102.64,30.31 102.64,28.32 v2(103.51,27.44)
  BOTTOM w0.089: UC1.AM57 104,72.39 v2(103.9,72.39)
  BOTTOM w0.102: JDIMM1.146 103.05,26.98 v2(103.51,27.44)
DDR_A_D19: length 63.6
  IN4 w0.084: v2(103.86,73.67) 103.37,74.16 102.69,74.16 102.03,73.49 102.03,73.25 99.61,70.83 99.61,69.86 96.74,66.99 96.2,66.99 91.62,62.41 91.62,41.03 98.64,34.01 98.86,34.01 99.14,33.73 99.14,33.37 102.33,30.18 102.33,27.68 102.46,27.55 102.94,27.55 103.06,27.42 103.06,27.11 102.94,26.98 102.56,26.98 102.43,26.85 102.43,26.53 102.56,26.41 102.94,26.41 103.06,26.28 103.06,26.04 103.19,25.92 v2(103.51,25.92)
  BOTTOM w0.076: v2(103.86,73.67) 104.19,74 UC1.AK57
  BOTTOM w0.102: JDIMM1.148 103.65,23.94 103.65,25.78 v2(103.51,25.92)
DDR_A_D20: length 62.5
  IN4 w0.084: v2(102.97,72.98) 102.97,73.08 102.91,73.14 102.84,73.14 102.71,73.02 102.71,72.65 102.59,72.53 102.13,72.53 100.27,70.66 100.27,69.73 92.73,62.19 92.73,41.79 96.41,38.11 97.12,38.11 97.9,37.33 97.98,37.25 97.98,37.07 97.69,36.78 97.69,36.67 97.92,36.44 98.04,36.44 98.46,36.85 98.64,36.85 98.8,36.69 98.8,36.51 98.39,36.09 98.39,35.97 98.62,35.74 98.73,35.74 99.15,36.16 99.33,36.16 99.55,35.94 99.55,35.76 99.13,35.35 99.13,35.23 99.36,35 99.48,35 99.89,35.42 100.07,35.42 100.24,35.25 100.24,35.07 99.82,34.65 99.82,34.54 100.05,34.31 100.17,34.31 100.59,34.72 100.77,34.72 101.41,34.08 101.41,33.9 100.81,33.29 100.81,33.2 v2(103.51,30.49)
  BOTTOM w0.089: v2(102.97,72.98) 103.33,73.35 UC1.AL58
  BOTTOM w0.102: JDIMM1.149 103.95,32.14 103.95,31.04 104.08,30.92 104.5,30.92 104.63,30.79 104.63,30.28 104.5,30.15 103.64,30.15 103.51,30.28 v2(103.51,30.49)
DDR_A_D21: length 63.3
  IN4 w0.084: v2(103.51,28.97) 103.51,28.71 103.39,28.58 103.07,28.58 102.95,28.69 102.95,30.44 99.88,33.51 99.88,34.04 97.13,36.78 96.82,36.78 96.75,36.78 96.58,36.95 96.58,37.13 96.91,37.45 96.91,37.63 96.74,37.8 96.56,37.8 96.24,37.48 96.06,37.48 95.89,37.65 95.89,37.82 95.98,37.91 95.98,38.09 95.81,38.26 95.64,38.26 95.54,38.17 95.36,38.17 95.2,38.34 95.2,38.52 95.29,38.61 95.29,38.79 95.12,38.95 94.94,38.95 94.85,38.86 94.67,38.86 94.5,39.03 94.51,39.21 94.59,39.3 94.59,39.48 94.43,39.65 94.25,39.65 94.16,39.56 93.98,39.56 93.81,39.73 93.81,39.91 93.9,39.99 93.9,40.17 93.73,40.34 93.56,40.34 93.47,40.26 93.29,40.26 93.12,40.43 93.12,40.6 93.21,40.69 93.21,40.87 93.04,41.03 92.35,41.73 92.35,62.25 96.57,66.48 96.71,66.48 100.09,69.86 100.09,70.73 102.08,72.71 102.47,72.71 102.53,72.77 102.53,73.17 v2(102.96,73.59)
  BOTTOM w0.076: UC1.AK58 103.41,74.17 103.28,74.3 102.85,74.3 102.72,74.17 102.72,73.72 102.85,73.59 v2(102.96,73.59)
  BOTTOM w0.102: JDIMM1.147 103.35,32.14 103.35,31.01 103.11,30.77 103.11,29.37 v2(103.51,28.97)
DDR_A_D22: length 60.1
  IN4 w0.084: v2(103.91,70.42) 103.91,69.99 98.67,64.75 98.67,64.75 95.03,61.11 95.03,43.71 104.63,34.11 104.63,32.63 106.06,31.2 106.06,30.43 106.61,29.88 106.61,29.06 106.74,28.93 107.01,28.93 107.14,28.81 107.14,28.55 107.01,28.43 106.74,28.43 106.61,28.3 106.61,28.08 106.74,27.95 107.46,27.95 107.59,27.83 107.59,27.59 107.46,27.46 106.74,27.46 106.61,27.34 106.61,26.75 106.74,26.62 107.58,26.62 107.77,26.82 v2(107.77,27.02)
  BOTTOM w0.089: UC1.AR57 103.98,70.42 v2(103.91,70.42)
  BOTTOM w0.102: v2(107.77,27.02) 106.65,25.9 106.65,23.94 JDIMM1.158
DDR_A_D23: length 61.8
  IN4 w0.084: v2(107.77,25.5) 107.77,25.07 107.65,24.95 106.44,24.95 106.31,25.07 106.31,25.49 106.44,25.61 107.08,25.61 107.2,25.74 107.2,25.98 107.08,26.1 106.43,26.1 106.3,26.23 106.3,29.75 105.75,30.3 105.75,31.07 104.29,32.53 104.29,34.02 94.72,43.59 94.72,61.31 101.71,68.3 101.98,68.3 103.53,69.85 103.53,71.34 v2(103.91,71.72)
  BOTTOM w0.089: v2(103.91,71.72) 104.24,72.05 UC1.AN57
  BOTTOM w0.102: v2(107.77,25.5) 107.56,25.71 107.36,25.71 107.25,25.6 107.25,23.94 JDIMM1.160
DDR_A_D24: length 70.2
  IN1 w0.084: v2(104.86,71.07) 104.47,70.68 104.47,70.19 103.62,69.34 100.78,69.34 96.39,64.95 95.53,64.95 90.44,59.86 86.9,59.86 81.67,54.63 81.67,53.34 76.48,48.16 76.06,48.16 67.8,39.9 67.8,39.11 64.75,36.06 64.75,32.39 63.26,30.89 63.26,26.89 v2(64.65,25.5)
  BOTTOM w0.089: UC1.AP55 105.19,71.4 v2(104.86,71.07)
  BOTTOM w0.102: JDIMM1.24 64.05,23.94 64.05,24.9 v2(64.65,25.5)
DDR_A_D25: length 69.4
  IN1 w0.084: v2(104.86,70.42) 104.86,70.34 103.67,69.15 101.03,69.15 96.52,64.64 95.66,64.64 90.57,59.55 87.03,59.55 81.98,54.5 81.98,53.21 76.61,47.84 76.19,47.84 68.11,39.77 68.11,38.98 65.06,35.93 65.06,32.26 63.57,30.77 63.57,28.1 v2(64.65,27.02)
  BOTTOM w0.089: v2(104.86,70.42) 105.19,70.75 UC1.AR55
  BOTTOM w0.102: v2(64.65,27.02) 63.45,25.82 63.45,23.94 JDIMM1.22
DDR_A_D26: length 72.1
  IN1 w0.084: v2(105.82,72.37) 106.3,72.37 106.38,72.3 106.38,71.65 106.98,71.05 106.98,69.5 105.58,68.1 103.31,68.1 102.83,67.62 102.13,67.62 101.71,67.19 101.71,66.62 97.58,62.49 96.32,62.49 91.05,57.22 88.81,57.22 83.74,52.16 83.74,51.8 67.26,35.32 67.26,33.07 67.07,32.87 67.07,28.22 66.72,27.87 65.96,27.87 65.86,27.77 65.86,27.43 65.96,27.33 66.36,27.33 66.44,27.25 v2(66.44,27.02)
  BOTTOM w0.089: v2(105.82,72.37) 106.14,72.7 UC1.AM54
  BOTTOM w0.102: JDIMM1.36 67.65,26 66.63,27.02 v2(66.44,27.02)
DDR_A_D27: length 73
  IN1 w0.084: v2(105.77,73.67) 106.02,73.42 106.93,73.42 107.16,73.19 107.16,72.32 107.27,72.21 107.27,69.49 105.66,67.87 103.94,67.87 103.42,67.35 103.42,66.85 102.68,66.11 102.39,66.11 101.31,65.03 101.31,64.93 99.69,63.31 98.84,63.31 97.59,62.06 96.33,62.06 91.18,56.91 88.93,56.91 84.19,52.17 84.19,51.81 67.58,35.19 67.58,32.94 67.38,32.74 67.38,27.74 67.66,27.46 67.66,25.97 67.19,25.5 v2(66.44,25.5)
  BOTTOM w0.076: UC1.AK54 106.09,74 v2(105.77,73.67)
  BOTTOM w0.102: JDIMM1.34 67.05,23.94 67.05,24.92 66.47,25.5 v2(66.44,25.5)
