# Allegro board LAA961PR10-1007A.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCH_GPIO69: length 8
  BOTTOM w0.076: 143.12,87.56 v1(142.36,87.56) 140.33,87.56 140.16,87.39 138.32,87.39 UC1.E2
  BOTTOM w0.102: RPC8.4 145.28,86.97 144.69,87.56 143.12,87.56
PCH_GPIO73: length 32.5
  TOP w0.102: RPC1.7 161.3,67.15 161.23,67.08 159.97,67.08 158.95,66.07 157.13,66.07 156.07,65.01 v1(156.07,64.29) 156.07,63.95 154.79,62.67 148.77,62.67 143.94,67.5 143.94,67.86 143.6,68.19 142,68.19 v2(141.42,67.61)
  BOTTOM w0.076: v2(141.42,67.61) 141.04,67.23 138.08,67.23 137.88,67.43 137.88,67.77 137.83,67.83 137.83,68.43 137.6,68.66 137.38,68.66 137.2,68.84 137.2,69.06 136.84,69.42 UC1.AU4
PCH_GPIO76: length 7.8
  BOTTOM w0.076: UC1.P1 139,82.29 139.32,82.62 v1(141.1,82.62) 141.5,82.62 141.81,82.31 143.68,82.31
  BOTTOM w0.089: RPC6.7 144.46,81.53 143.68,82.31
PCH_GPIO80: length 11.6
  TOP w0.102: RPC3.5 147.68,83.46 147.54,83.59 v1(145.52,83.59) 142.95,83.59 v2(142.58,83.23)
  BOTTOM w0.076: v2(142.58,83.23) 141.79,84.03 140.41,84.03 139.72,83.34 138.7,83.34 138.4,83.04 UC1.N2
PCH_GPIO85: length 15.7
  TOP w0.089: v2(135.76,83.42) v1(136.33,83.99) 136.65,84.31 136.65,85.86 137.02,86.22 137.91,86.22 141.93,90.24 141.93,90.25 142.29,90.62 142.29,91.92
  TOP w0.102: RPC16.7 142.56,94.8 142.29,94.53 142.29,91.92
  BOTTOM w0.089: v2(135.76,83.42) 135.53,83.19 UC1.N6
PCH_GPIO87: length 18.4
  TOP w0.102: v2(135.11,81.59) 135.54,81.16 136.48,81.16 136.95,81.63 138.42,81.63 138.88,82.09 v1(146.47,82.09) 147.93,82.09 148.37,81.65 150.81,81.65 151.13,81.97 151.13,82.29 151.29,82.44 RPC18.7
  BOTTOM w0.089: UC1.R7 134.88,81.82 v2(135.11,81.59)
PCH_INTVRMEN: length 37.9
  TOP w0.102: RC1.2 162.38,54.86 v1(162.11,54.59) 161.88,54.37 v2(161.88,53.85)
  IN1 w0.084: v2(161.88,53.85) 161.68,54.06 145.68,54.06 137.4,62.33 v2(137.4,62.36)
  BOTTOM w0.076: UC1.AV7 134.4,68.68 134.4,67.05
  BOTTOM w0.089: v2(137.4,62.36) 137.37,62.39 137.37,63.56 134.4,66.54 134.4,67.05
PCH_JTAG_JTAGX: length 46.4
  TOP w0.102: RC112.2 66.98,68.64 66.98,68.6 RC115.2 67.77,67.81 v2(68.02,67.81)
  TOP w0.109: v2(77.84,74.49) v1(77.24,75.09) 76.84,75.49 76.84,76.62 RC18.1
  IN1 w0.084: v2(96.41,77.29) 96.41,77.3 95.56,78.15 93,78.15 92.44,78.72 89.14,78.72 88.57,78.15 84.78,78.15 83.9,77.27 81.12,74.49 v2(77.84,74.49)
  IN2 w0.122: v2(77.84,74.49) 77.42,74.07 77.42,68.64 75.52,66.75 69.08,66.75 v2(68.02,67.81)
  BOTTOM w0.076: 97.83,76.71 98.2,76.34 UC1.AE63
  BOTTOM w0.102: v2(96.41,77.29) 96.99,76.71 97.83,76.71
PCH_JTAG_TCK: length 65.7
  TOP w0.102: v2(95.76,77.29) 94.69,77.29 RC21.1 ; JXDP1.55 69.75,45.87 70.09,45.54 70.88,45.54 71.8,46.45 71.8,57.77 70.64,58.93 v3(70.64,64.7) 70.64,67.5 69.26,68.89 RC119.2 69.47,69.33 v2(69.47,70.18)
  IN1 w0.084: v2(69.47,70.18) 69.47,70.2 72.49,73.21 76.09,73.21 76.76,73.89 81.17,73.89 84.98,77.69 88.77,77.69 89.33,78.25 92.24,78.25 92.81,77.69 95.37,77.69 v2(95.76,77.29)
  BOTTOM w0.076: UC1.AE62 100.62,76.12 100.41,76.12 100.28,76.06 100.25,76.05 100,76.05 99.89,76.15 97.45,76.15
  BOTTOM w0.102: 97.45,76.15 96.67,76.15 95.76,77.05 v2(95.76,77.29)
PCH_JTAG_TDI: length 79.4
  TOP w0.102: v2(65.13,71.9) 66.35,71.9 v2(67.41,70.83) RC99.1 ; RPC21.7 91.85,75.54 92.01,75.38 97.13,75.38 v2(99.02,77.27) ; v2(62.61,60.16) 64.24,60.16 64.53,60.46 66.47,60.46 v3(66.61,60.32) 66.99,60.32 69.75,57.55 JXDP1.56
  IN1 w0.084: v2(62.61,60.16) 63.12,60.68 63.12,63.63 62.56,64.19 62.56,66.55 62.88,66.87 62.88,69.66 v2(65.13,71.9) ; v2(67.41,70.83) 70.94,74.35 75.62,74.35 77.56,76.3 82.03,76.3 84.52,78.79 88.61,78.79 88.96,79.14 92.61,79.14 92.96,78.79 95.88,78.79 96.28,78.39 97.89,78.39 v2(99.02,77.27)
  BOTTOM w0.076: UC1.AD61 101.24,77.38 100.72,77.38 100.48,77.14 100.48,76.97 100.31,76.8 99.49,76.8 v2(99.02,77.27)
PCH_JTAG_TDO: length 55.2
  TOP w0.102: v2(101.19,76.71) 100.88,76.41 98.61,76.41 97.35,75.15 92.7,75.15 92.59,75.04 v3(91,75.04) RPC21.6 ; v2(68.65,67.81) 68.28,67.44 RC118.2 RC98.1
  IN1 w0.084: v2(101.19,76.71) 93.12,76.71 92.05,77.79 89.52,77.79 88.96,77.22 85.17,77.22 81.37,73.42 78,73.42 77.77,73.18 v2(77,73.18)
  IN2 w0.122: v2(77,73.18) 77.17,73.02 77.17,68.75 75.42,67 69.46,67 v2(68.65,67.81)
  BOTTOM w0.076: v2(101.19,76.71) 101.23,76.68 101.49,76.41 UC1.AE61
PCH_JTAG_TMS: length 79.3
  TOP w0.102: RPC21.8 91.85,76.04 92.28,75.61 96.7,75.61 v2(98.37,77.27) ; v2(68.16,70.84) 68.16,71.22 v3(67.63,71.75) 66.93,72.44 63.69,72.44 62.12,70.87 v2(62.12,70.22) UC7.9 ; JXDP1.58 70.25,57.37 66.84,60.79 v2(62.66,60.79)
  IN1 w0.084: v2(68.16,70.84) 71.47,74.14 75.7,74.14 77.65,76.09 82.12,76.09 84.61,78.57 88.7,78.57 89.05,78.93 92.52,78.93 92.88,78.57 95.79,78.57 96.19,78.18 97.45,78.18 v2(98.37,77.27) ; v2(62.12,70.22) 62.6,69.74 62.6,66.89 62.35,66.64 62.35,64.1 62.66,63.79 v2(62.66,60.79)
  BOTTOM w0.076: UC1.AD62 100.39,76.64 100.39,76.64 100.38,76.63 99,76.63 v2(98.37,77.27)
PCH_JTAG_TRST#: length 46.1
  TOP w0.102: v2(61.01,67.15) 60.43,67.73 RC109.2 ; v2(82.39,64.39) 81.19,65.59 v3(77.03,65.59) v2(73.92,65.59)
  IN2 w0.122: v2(61.01,67.15) 61.01,67 61.53,66.48 63.38,66.48 64.77,65.08 73.41,65.08 v2(73.92,65.59)
  BOTTOM w0.089: 95.66,66.98 96.81,66.98 99.76,69.93 100.33,69.93 100.65,69.6 UC1.AU62
  BOTTOM w0.102: v2(82.39,64.39) 82.63,64.63 89.41,64.63 93.28,68.51 93.83,68.51 95.36,66.98 95.66,66.98
PCH_OPI_COMP: length 6.7
  BOTTOM w0.076: 131.12,65.35 130.83,65.63 130.83,66.17 130.73,66.28 130.73,66.87 130.64,66.96 130.49,67.11 130.49,67.99 UC1.AW15
  BOTTOM w0.305: 131.12,65.35 131.31,65.16 v1(131.31,64.94) 131.31,63.3 131.55,63.05 131.55,62.81 131.64,62.72 131.64,62.72 RC178.1
PCH_PCIE_RCOMP: length 9.1
  BOTTOM w0.127: v1(120.21,95.46) 121.15,96.4 RC149.2
  BOTTOM w0.305: UC1.A27 123.09,90.38 123.09,90.57 123.58,91.06 123.58,94.37 122.38,95.57 122.38,95.81 RC149.2
PCH_PCIE_WAKE#: length 119.4
  TOP w0.102: RPC5.7 154.02,74.99 153.6,74.57 v1(149.51,74.57) 148.86,74.57 145.72,71.43 139.39,71.43 138.02,72.79 137.09,72.79 136.61,73.27 v2(136.38,73.27) ; UE2.A44 199.77,90.25 199.62,90.1 199.13,90.1 v2(198.88,89.84) 198.56,89.53 RE274.2
  IN4 w0.084: v2(198.19,104.08) 197.65,104.62 187.63,104.62 187.08,104.07 178.13,104.07 176.68,102.62 175.48,102.62 172.48,99.62 172.48,99.08 171.7,98.3 171.7,96.48 171.24,96.02 171.24,94.2 168.48,91.44 165.66,91.44 163.29,89.07 160.83,89.07 154.6,82.85 154.6,81.67 152.37,79.45 151.53,79.45 150.94,78.86 149.93,78.86 149.55,79.24 146.06,79.24 145.61,78.79 140.12,78.79 138.51,77.18 138.51,74.55 138.12,74.16 136.97,74.16 136.38,73.57 v2(136.38,73.27)
  BOTTOM w0.076: UC1.AJ5 136.18,74.34 136.38,74.14 v2(136.38,73.27)
  BOTTOM w0.102: v2(198.88,89.84) 198.12,90.6 198.12,92.38 197.41,93.09 197.41,93.64 197.55,93.78 197.55,96.51 197.86,96.82 197.86,98.39 198.1,98.63 198.1,103.98 v2(198.19,104.08)
PCH_PLTRST#: length 35.8
  TOP w0.102: v2(159.54,75.19) 159.53,75.2 RC219.2 RC89.2 160.15,76.8 RC88.2 RC87.2 160.39,78.13 v1(161.11,78.86) 161.44,79.19 v2(161.44,79.95)
  IN1 w0.084: v2(159.54,75.19) 157.9,76.83 157.34,76.83 156.94,76.42 155.67,76.42 155,75.76 152.32,75.76 151.68,75.11 148.38,75.11 147.03,73.76 140,73.76 138.13,75.63 136.8,75.63 136.59,75.43 135.46,75.43 v2(135.06,75.83)
  BOTTOM w0.076: UC1.AG7 134.88,75.65 v2(135.06,75.83)
  BOTTOM w0.102: UC5.1 161.8,80.14 161.61,79.95 v2(161.44,79.95) 161.31,79.95 161.15,80.1 UC5.2
PCH_PLTRST#_EC: length 344.7
  TOP w0.102: RC106.1 66.74,57.97 v1(66.83,58.06) 67.06,58.28 v2(67.48,58.28) ; UE2.B30 v2(203.62,95.94) ; UE1.B22 180.44,97.37 180.48,97.41 180.48,98.1 v2(180.86,98.48) ; v2(189.11,42.79) 188.59,42.79 184.52,46.86 184.52,50.97 186.85,53.3 UZ1.16
  IN1 w0.084: v2(154.96,53.17) 155.85,52.28 163.77,52.28 166.38,49.67 184.66,49.67 186.88,47.45 186.88,45.01 v2(189.11,42.79) ; v2(180.86,98.48) 181.19,98.81 184.27,98.81 184.6,99.14 189.97,99.14 190.25,98.86 200.11,98.86 200.73,98.25 201.33,98.25 201.84,98.76 202.58,98.76 202.9,98.44 202.9,97.8 203.62,97.08 v2(203.62,95.94)
  IN2 w0.122: v2(61.34,41.71) 61.34,41.21 62.37,40.19 63.59,40.19 65.3,38.48 70.59,38.48 79.47,47.35 134.68,47.35 138.3,50.98 152.76,50.98 v2(154.96,53.17) 156.17,54.38 156.17,66.68 158.22,68.72 158.22,69.93 157.79,70.35 157.79,72.7 v2(159.71,74.62)
  IN4 w0.084: v2(67.48,58.28) 67.48,52.55 64.52,49.58 64.52,46.04 61.34,42.86 v2(61.34,41.71) ; v2(180.86,98.48) 180.47,98.09 180.47,97.48 180.19,97.2 179.66,97.2 178.32,95.85 178.32,95.25 176.34,93.27 176.34,91.13 173.37,88.16 173.37,86.98 v2(173.5,86.85) 173.2,86.56 173.2,81.94 171.73,80.47 168.46,80.47 167.35,79.35 167.16,79.35 165.05,77.24 164.12,77.24 164.04,77.33 v2(162.46,77.33) 162.27,77.14 161.71,77.14 159.98,75.42 159.98,74.9 v2(159.71,74.62)
  BOTTOM w0.102: 183.49,87.14 183.12,86.76 179.54,86.76 179.14,86.35 174,86.35 v2(173.5,86.85) ; 183.49,87.14 186.33,87.14 186.55,87.35 JNGFF1.58 ; 183.49,87.14 183.05,87.58 JNGFF1.44 ; v2(189.11,42.79) 187.99,43.91 187.99,46.74 189.41,48.16 197.63,48.16 198.95,49.48 207.53,49.48 209.93,51.88 209.93,56.49 209.47,56.95 209.24,56.95 208.83,57.36 208.83,58.91 209.47,59.56 209.47,61.28 209.7,61.51 215.85,61.51 216.11,61.76 216.11,63.14 216.45,63.48 JNGFF2.42 ; JLPDE1.8 159.91,74.41 v2(159.71,74.62) ; v2(162.46,77.33) 162.55,77.42 162.55,77.83 160.1,80.28 160.1,82.17 UC5.4 160.5,82.92 160.81,83.23 162.19,83.23 162.66,82.76 164.53,82.76 RC304.1
PCH_RSMRST#: length 18.5
  TOP w0.102: RE88.1 199.31,89.69 v2(199.45,89.69) 199.52,89.75 UE2.A45 ; UZ6.1 186,87.55 v1(186.76,86.8) 187.07,86.48 v2(187.45,86.48)
  IN3 w0.122: v2(199.45,89.69) 199.35,89.69 198.81,89.14 193.93,89.14 193.13,88.35 189.32,88.35 v2(187.45,86.48)
PCH_RSMRST#_Q: length 79.2
  TOP w0.102: UZ6.4 184.1,90.2 v2(184.19,90.28) ; RC91.2 v2(162.47,60.72) 161.52,59.77 157.29,59.77 155.45,57.93 142.08,57.93 140.28,59.73 v1(140.28,62.61) 140.28,63.22 138.6,64.89 136.85,64.89 136.4,65.34 v2(136.4,65.83)
  IN2 w0.122: v2(162.47,60.72) 164.01,62.26 164.01,65.01 164.53,65.53 v2(164.85,65.53)
  IN4 w0.084: v2(164.85,65.53) 164.85,69.44 171.46,76.05 172.49,76.05 175.21,78.77 177.46,78.77 v2(178.53,79.84) 178.53,79.84 179.35,80.66 181.02,80.66 183.24,82.88 183.24,86.1 184.19,87.05 v2(184.19,90.28)
  BOTTOM w0.076: v2(136.4,65.83) 135.84,65.83 135.15,66.51 135.15,67.99 135.38,68.23 UC1.AW6
PCH_RTCRST#: length 222.2
  TOP w0.089: 138.61,67.85 140.31,66.15
  TOP w0.102: 138.61,67.85 136.4,67.85 135.6,68.66 135.6,68.76 v2(135.07,69.29) ; 140.31,66.15 142.21,64.25 142.21,60.67 143.02,59.86 152.05,59.86 152.72,60.53 155.27,60.53 157.33,62.59 159.79,62.59 160.62,63.41 162.09,63.41 163.16,64.48 CC4.2 RC8.2 ; v2(219.59,102.47) 219.85,102.2 JAPS1.9
  IN2 w0.089: v2(135.07,69.29) 135.07,69.27 135.58,68.76 135.58,65.33 138.24,62.67 138.24,58.92
  IN2 w0.122: 138.24,58.92 138.24,55.55 132.01,49.33 87.64,49.33 v2(84.78,52.19)
  IN4 w0.084: v2(219.59,102.47) 218.53,102.47 215.19,99.13 213.08,99.13 208.79,103.42 197.96,103.42 197.29,102.75 194.99,102.75 194.33,103.42 192.79,103.42 192.13,102.75 190.7,102.75 190.12,103.33 187,103.33 186.53,102.85 178.75,102.85 178.35,102.45 177.48,102.45 175.71,100.69 174.2,100.69 172.98,99.46 172.98,97.1 171.7,95.83 171.7,94.01 168.67,90.98 165.91,90.98 163.54,88.61 162.2,88.61 160.4,86.81 160.4,86.1 159.96,85.65 158.06,85.65 155.13,82.72 155.13,81.55 152.57,78.98 151.73,78.98 151.04,78.3 148.4,78.3 147.93,78.77 145.96,78.77 145.74,78.54 140.11,78.54 138.75,77.18 138.75,73.97 137.86,73.08 137.29,73.08 136.78,72.57 136.78,70.41 136.46,70.09 135.64,70.09 135.07,69.52 v2(135.07,69.29)
  BOTTOM w0.076: UC1.AU7 134.95,69.29 v2(135.07,69.29)
  BOTTOM w0.102: v2(84.78,52.19) 84.17,52.8 CMOS1.2
PCH_RTCX1: length 9.9
  BOTTOM w0.076: 136.56,67.03 136.56,67.92 UC1.AW5
  BOTTOM w0.102: RC7.1 RC4.2 142.05,63.73 141.79,63.73 v1(141.08,64.44) 138.84,66.68 136.9,66.68 136.56,67.03
PCH_RTCX1_R: length 3.1
  BOTTOM w0.102: RC4.1 143.02,63.68 CC1.2 143.85,63.65 YC1.1
PCH_RTCX2: length 15.2
  BOTTOM w0.102: YC1.2 146.35,61.76 145.4,60.81 CC2.2 v1(144.43,60.44) 143.44,60.44 RC7.2 141.99,61.89 141.99,63.07 138.56,66.49 136.81,66.49 136.37,66.93 136.37,67.1 136.37,67.5 UC1.AY5
PCH_SMB_ALERT#: length 30.4
  TOP w0.102: RPC7.8 162,72.51 161.56,72.06 161.17,72.06 161.1,72.13 v1(160.85,72.13) 160.19,71.47 v2(159.68,71.47)
  IN1 w0.084: v2(144.16,70.77) 145.17,70.77 145.55,70.4 147.16,70.4 149.25,72.49 152.25,72.49 156.3,68.44 157.8,68.44 158.24,68.89 158.24,70.22 158.59,70.56 159.39,70.56 159.68,70.86 v2(159.68,71.47)
  BOTTOM w0.076: UC1.AN2 138.62,72.26 139.01,72.26 139.22,72.05 139.49,72.05 139.64,71.9 140.92,71.9 141.33,71.49 143.45,71.49 v2(144.16,70.77)
PCH_SPI_CLK: length 79
  TOP w0.102: RC227.2 170.38,66.71 v2(170.38,65.82) ; v2(193.11,60.43) 193.11,58.07 v1(191.96,56.92) 191.64,56.61 RZ26.1
  IN1 w0.084: v2(193.11,60.43) 192.35,61.19 189.75,61.19 189.52,60.97 185.82,60.97 183.84,62.96 173.22,62.96 172,64.18 172,65.07 171.63,65.44 170.76,65.44 v2(170.38,65.82) 169.44,66.76 167.82,66.76 166.67,67.9 166.67,74.56 166.13,75.1 166.13,78 165.3,78.82 164.31,78.82 163.55,79.59 161.95,79.59 161.67,79.31 160.92,79.31 159.97,80.26 158.17,80.26 158.06,80.37 155.53,80.37 154.85,79.69 152.13,79.69 151.03,78.59 139.92,78.59 139.5,78.17 v2(137.82,78.17)
  BOTTOM w0.076: UC1.AA3 137.52,78.47 v2(137.82,78.17)
  BOTTOM w0.102: JSPI1.8 169.89,66.31 v2(170.38,65.82)
PCH_SPI_CS0#: length 52
  TOP w0.102: v2(171.26,65.86) RC228.2
  IN1 w0.084: v2(171.26,65.86) 171.26,65.95 170.24,66.97 167.9,66.97 166.89,67.98 166.89,74.68 166.34,75.23 166.34,78.09 165.39,79.03 164.4,79.03 163.64,79.8 161.86,79.8 161.58,79.52 161.01,79.52 160.06,80.47 158.26,80.47 158.15,80.58 155.44,80.58 154.77,79.9 152.04,79.9 150.94,78.8 139.62,78.8 139.36,79.06 135.64,79.06 v2(135.06,79.64)
  BOTTOM w0.089: UC1.Y7 134.88,79.46 v2(135.06,79.64)
  BOTTOM w0.102: JSPI1.10 170.89,66.24 v2(171.26,65.86)
PCH_SPI_CS1#: length 46.4
  TOP w0.102: v2(167.57,65.87) 167.57,66.35 RC224.2
  IN1 w0.084: v2(167.57,65.87) 167.57,66.11 166.04,67.64 166.04,74.29 165.49,74.83 165.49,76.59 163.89,78.19 161.06,78.19 160.07,79.18 158.45,79.18 158.17,78.9 157.79,78.9 156.96,79.74 155.79,79.74 155.12,79.06 152.39,79.06 151.29,77.96 146.71,77.96 146.05,77.3 143.77,77.3 v2(143.16,77.91)
  BOTTOM w0.076: UC1.Y4 137.25,78.88 137.64,78.88 137.68,78.84 138.46,78.84 138.63,79 138.94,79 139.06,79.13 141.94,79.13 v1(142.63,78.44) v2(143.16,77.91)
  BOTTOM w0.102: JSPI1.2 166.89,66.22 167.23,65.87 v2(167.57,65.87)
PCH_SPI_CS2#: length 74.3
  TOP w0.102: RZ17.1 191.66,57.48 192.39,58.21 v2(192.39,60.29) v1(192.39,60.9)
  IN1 w0.084: v2(141.48,77.91) 141.48,77.88 142.85,76.5 145.35,76.5 145.89,75.96 147.2,75.96 147.74,76.5 149.16,76.5 149.46,76.81 151.27,76.81 152.72,78.26 157.3,78.26 157.5,78.06 160.01,78.06 160.92,77.14 162.07,77.14 162.3,76.91 163.79,76.91 164.66,76.04 164.66,74.45 165.14,73.97 165.14,72.96 164.93,72.75 164.93,67.61 166.58,65.96 166.58,65.46 167.24,64.8 168.62,64.8 169.28,64.15 170.6,64.15 173.63,61.12 183.96,61.12 185.14,59.93 189.4,59.93 189.61,59.72 191.81,59.72 v2(192.39,60.29)
  BOTTOM w0.076: UC1.AC2 138.4,77.8 138.7,78.09 138.94,78.09 139.07,77.96 139.42,77.96 139.99,78.53 140.86,78.53 v2(141.48,77.91)
PCH_SPI_CS2#_R: length 2.1
  TOP w0.102: UZ1.22 189.72,57.2 RZ17.2
PCH_SPI_DIN: length 72.6
  TOP w0.102: RZ30.1 190.05,61.73 190.29,61.48 190.29,60.83 v2(190.21,60.76) ; v2(169.29,65.86) RC226.2
  IN1 w0.084: v2(137.25,78.17) 137.63,77.8 139.37,77.8 139.96,78.38 151.12,78.38 152.21,79.48 154.94,79.48 155.62,80.16 157.97,80.16 158.09,80.05 159.89,80.05 161.32,78.61 165.19,78.61 165.91,77.89 165.91,75.02 166.46,74.47 166.46,67.82 167.73,66.54 168.61,66.54 v2(169.29,65.86) 169.93,65.23 171.55,65.23 171.79,64.99 171.79,64.09 173.85,62.03 184.39,62.03 185.67,60.76 v2(190.21,60.76)
  BOTTOM w0.076: v2(137.25,78.17) 136.87,78.56 UC1.AA4
  BOTTOM w0.102: JSPI1.6 168.89,66.27 v2(169.29,65.86)
PCH_SPI_DO: length 73.5
  TOP w0.102: v2(168.4,65.86) RC225.2 ; RZ29.1 191.51,58.94 v2(191.51,60.31)
  IN1 w0.084: v2(191.51,60.31) 189.92,60.31 189.69,60.55 185.51,60.55 184.28,61.78 173.8,61.78 170.84,64.74 169.53,64.74 v2(168.4,65.86) 167.94,65.4 167.48,65.4 167.17,65.71 167.17,66.21 165.83,67.55 165.83,74.18 165.28,74.73 165.28,76.5 163.81,77.97 160.98,77.97 159.98,78.97 158.53,78.97 158.26,78.69 157.71,78.69 156.87,79.53 155.88,79.53 155.2,78.85 152.48,78.85 151.38,77.75 146.8,77.75 146.14,77.09 142.76,77.09 142.04,77.81 v2(142.04,77.91)
  BOTTOM w0.076: UC1.AA2 138.4,78.55 138.7,78.84 139.01,78.84 139.13,78.96 140.98,78.96 v1(141.27,78.68) v2(142.04,77.91)
  BOTTOM w0.102: v2(168.4,65.86) 167.89,66.38 JSPI1.4
PCH_SPI_DO2: length 51.5
  TOP w0.102: RC229.2 172.34,66.35 v2(171.86,65.87)
  IN1 w0.084: v2(171.86,65.87) 171.86,66.34 170.98,67.22 168.73,67.22 168,67.96 168,73.88 166.55,75.33 166.55,78.17 165.48,79.24 164.49,79.24 163.69,80.04 161.97,80.04 161.62,80.39 160.44,80.39 160.16,80.68 158.35,80.68 158.23,80.79 155.36,80.79 154.68,80.11 151.95,80.11 150.85,79.02 139.65,79.02 139.44,79.23 136.12,79.23 v2(135.71,79.64)
  BOTTOM w0.089: v2(135.71,79.64) 135.53,79.46 UC1.Y6
  BOTTOM w0.102: JSPI1.12 171.89,65.89 v2(171.86,65.87)
PCH_SPI_DO3: length 53.8
  TOP w0.102: v2(171.39,64.82) v1(171.93,65.36) 173.28,66.72 RC230.2
  IN1 w0.084: v2(171.39,64.82) 171.19,65.02 169.55,65.02 168.85,65.71 168.85,66.01 168.57,66.28 167.69,66.28 166.25,67.73 166.25,74.39 165.7,74.93 165.7,77.81 165.11,78.4 161.14,78.4 159.71,79.84 158,79.84 157.88,79.95 155.71,79.95 155.03,79.27 152.3,79.27 151.2,78.17 146.59,78.17 146.24,77.83 146.24,77.74 146.02,77.51 145.1,77.51 v2(144.69,77.92)
  BOTTOM w0.076: UC1.AF1 138.95,76.3 139.17,76.52 140.16,76.52 140.96,75.72 144.33,75.72 144.69,76.09 v2(144.69,77.92)
  BOTTOM w0.102: v2(171.39,64.82) 172.89,66.32 JSPI1.14
PCI_CLK_LPC_0: length 45.4
  TOP w0.102: v2(130.28,71.54) 130.38,71.54 130.98,70.93 130.98,69.6 131.69,68.89 131.69,66.37 133.03,65.03 133.03,64.1 v1(135.06,62.06) 141.22,55.91 157.52,55.91 159.22,57.61 162.71,57.61 162.79,57.53 163.59,57.53 RC72.1 RC74.1
  BOTTOM w0.076: UC1.AN15 130.6,71.86 v2(130.28,71.54)
PCI_CLK_LPC_1: length 44
  TOP w0.102: RC70.1 RC67.1 162.41,55.77 161.94,55.3 140.96,55.3 v1(133.41,62.86) 131.83,64.43 131.83,65.64 131.3,66.17 131.3,68.75 130.73,69.32 130.73,70.44 v2(130.28,70.89)
  BOTTOM w0.076: UC1.AP15 130.6,71.21 v2(130.28,70.89)
PCIE_PRX_GLANTX_N3: length 125.7
  TOP w0.102: CL2.2 199.38,115.86 198.62,115.86 198.07,115.32 197.34,115.32 v2(197.16,115.14)
  IN1 w0.091: v2(132,86.62) 132.27,86.88 132.55,86.88 132.76,87.09 132.76,87.6 132.58,87.78 132.58,89.45 132.75,89.61 134.43,89.61 135.43,90.62 148.2,90.62 149.92,92.33 152.56,92.33 153.29,91.6 157.95,91.6 158.72,90.83 161.06,90.83 162.43,89.46 167.78,89.46 168.09,89.15 169.6,89.15 171.16,87.6 171.16,87.29 173.9,84.55 176.75,84.55 180.4,80.9 184.42,80.9 185.49,79.83 188.24,79.83 189.82,78.25 190.99,78.25 191.82,79.08 196.38,79.08 197.77,77.69 198.9,77.69 199.2,77.39 200.15,77.39 200.87,78.11 201.24,78.11 v2(201.45,77.91)
  BOTTOM w0.089: v2(132,86.62) 132.13,86.62 UC1.G11
  BOTTOM w0.102: v2(197.16,115.14) 197.35,115.33 197.47,115.33 197.68,115.13 197.68,105.71 196.94,104.97 196.94,103.57 197.34,103.18 197.34,99.01 197.14,98.82 197.14,97.91 196.71,97.47 196.71,96.6 196.71,96.6 196.71,93.92 196.62,93.83 196.62,90.6 199.35,87.87 199.9,87.87 200.6,87.18 200.6,84.17 200.88,83.89 200.88,82.43 200.94,82.37 200.94,79.06 200.73,78.85 200.73,78.35 200.98,78.09 201.27,78.09 v2(201.45,77.91)
PCIE_PRX_GLANTX_N3_C: length 5.4
  TOP w0.102: UL1.39 204.75,116.64 204.57,116.83 v4(203.96,116.83) 202.63,116.83 202.52,116.72 202.28,116.47 202.28,116.45 201.88,116.06 201.86,116.06 201.65,115.85 200.95,115.85 CL2.1
PCIE_PRX_GLANTX_P3: length 125.8
  TOP w0.102: v2(197.16,115.73) 197.35,115.54 197.98,115.54 198.53,116.08 199.38,116.08 CL1.2
  IN1 w0.091: v2(201.45,78.49) 201.24,78.29 200.8,78.29 200.08,77.56 199.27,77.56 198.97,77.86 197.84,77.86 196.45,79.25 191.75,79.25 190.92,78.42 189.89,78.42 188.31,80 185.56,80 184.49,81.07 180.47,81.07 176.82,84.72 173.97,84.72 171.33,87.36 171.33,87.67 169.67,89.33 168.16,89.33 167.85,89.64 162.5,89.64 161.13,91 158.79,91 158.02,91.77 153.36,91.77 152.63,92.5 149.84,92.5 148.13,90.79 135.36,90.79 134.36,89.79 132.68,89.79 132.41,89.52 132.41,87.7 132.59,87.52 132.59,87.16 132.48,87.05 132.27,87.05 v2(132,87.32)
  BOTTOM w0.089: UC1.F11 132.33,87 v2(132,87.32)
  BOTTOM w0.102: v2(201.45,78.49) 201.27,78.31 201.07,78.31 200.94,78.44 200.94,78.76 201.15,78.97 201.15,82.46 201.09,82.52 201.09,83.98 200.81,84.26 200.81,87.27 199.99,88.09 199.44,88.09 196.84,90.69 196.84,93.74 196.93,93.83 196.93,96.69 196.93,96.69 196.93,97.38 197.36,97.82 197.36,98.73 197.55,98.92 197.55,103.27 197.16,103.66 197.16,104.88 197.89,105.62 197.89,115.22 197.56,115.55 197.34,115.55 v2(197.16,115.73)
PCIE_PRX_GLANTX_P3_C: length 5.3
  TOP w0.102: UL1.38 204.24,117.04 204.23,117.06 203.7,117.06 203.69,117.04 202.54,117.04 v4(201.91,116.42) 201.56,116.06 200.98,116.06 CL1.1
PCIE_PRX_MMITX_N1: length 152
  TOP w0.102: CR27.1 21.87,26.88 21.87,27.25 v2(21.68,27.44)
  IN4 w0.084: 94.62,74.61 94.64,74.61 94.65,74.62 95.98,74.62 96.2,74.4 103.43,74.4 103.83,74.79 114.2,74.79 114.99,75.58 123.02,75.58 124.2,76.76 124.2,82.94 126.41,85.16 127.45,85.16 128.77,86.47 128.77,86.66 128.84,86.73 129.09,86.73 v2(129.15,86.67)
  IN4 w0.091: 94.62,74.61 88.53,74.61 87.57,73.66 86.93,73.66 69.85,56.58 69.85,43.42 62.57,36.14 56.5,36.14 55.1,37.54 50.31,37.54 49.6,36.82 42.1,36.82 40.13,38.79 36.05,38.79 35.45,38.19 35.45,34.11 35.25,33.9 35.25,32.89 30.62,28.26 28.34,28.26 26.86,26.79 25.46,26.79 25.34,26.66 21.99,26.66 21.76,26.9 21.76,27.36 v2(21.68,27.44)
  BOTTOM w0.089: UC1.G17 129.48,86.35 v2(129.15,86.67)
PCIE_PRX_MMITX_N1_C: length 3.9
  TOP w0.102: CR27.2 21.81,25.35 v4(21.81,23.05) 21.81,22.41 21.69,22.29 UR1.8
PCIE_PRX_MMITX_P1: length 152
  TOP w0.102: CR26.1 22.08,26.88 22.08,27.25 v2(22.27,27.44)
  IN4 w0.084: 94.62,74.78 94.64,74.78 94.65,74.78 96.05,74.78 96.27,74.56 103.36,74.56 103.76,74.95 114.13,74.95 114.92,75.75 122.95,75.75 124.03,76.83 124.03,83.01 126.34,85.32 127.38,85.32 128.6,86.54 128.6,86.77 129.15,87.32 v2(129.15,87.32)
  IN4 w0.091: 94.62,74.78 88.46,74.78 87.5,73.83 86.86,73.83 69.68,56.65 69.68,43.5 62.5,36.32 56.57,36.32 55.17,37.71 50.24,37.71 49.52,36.99 42.17,36.99 40.21,38.96 35.98,38.96 35.28,38.26 35.28,34.18 35.07,33.97 35.07,32.96 30.55,28.43 28.26,28.43 26.79,26.96 25.39,26.96 25.27,26.84 22.06,26.84 21.93,26.97 21.93,27.11 22.25,27.44 v2(22.27,27.44)
  BOTTOM w0.089: UC1.F17 129.48,87 v2(129.15,87.32)
PCIE_PRX_MMITX_P1_C: length 3.9
  TOP w0.102: CR26.2 22.04,25.26 22.04,22.33 22.09,22.28 UR1.7
PCIE_PRX_SATATX_N6_L0: length 111
  IN1 w0.091: v2(215.01,53.61) 215.01,53.02 214.64,52.65 212.29,52.65 210,54.94 210,56.64 207.15,59.48 203.22,59.48 200.77,61.93 200.77,70.49 198.54,72.72 198.54,74.42 197.21,75.75 196.74,75.75 195.89,76.59 189.29,76.59 188.85,77.03 180.81,77.03 179.43,78.42 178.99,78.42 176.59,80.81 174.36,80.81 170.64,84.53 168.43,84.53 166.31,86.65 162.5,86.65 161.03,88.13 156.89,88.13 152.94,84.17 149.23,84.17 144.77,88.64 138.68,88.64 137.63,87.58 136.6,87.58 136.5,87.48 135.98,87.48 v2(135.82,87.32)
  BOTTOM w0.089: v2(135.82,87.32) 136.14,87 UC1.F5
  BOTTOM w0.102: v2(215.01,53.61) 214.82,53.8 214.82,54.69 214.56,54.95 v4(214.56,55.72) 214.56,57.25 214.7,57.39 JNGFF2.35
PCIE_PRX_SATATX_N6_L1: length 107.4
  IN1 w0.084: 135.31,88.16 135.3,88.15 135.3,87.1 135.41,86.99 135.41,85.82 135.26,85.66 135.07,85.66 134.88,85.48 v2(134.88,85.36)
  IN1 w0.091: v2(211.13,56.26) 211.54,56.68 211.54,56.74 210.64,57.64 209.9,57.64 208.49,59.06 208.49,59.63 207.97,60.15 204.33,60.15 202.86,61.61 202.75,61.61 201.41,62.96 201.41,71.86 199.21,74.06 199.21,74.73 195.58,78.35 192,78.35 191.25,77.6 189.55,77.6 189.3,77.86 185.29,77.86 184.84,78.3 183.72,78.3 183.27,77.86 181.81,77.86 180.47,79.19 179.75,79.19 175.94,83 173.26,83 170.83,85.43 169.13,85.43 166.64,87.92 162.15,87.92 161.16,88.91 156.76,88.91 152.8,84.94 149.61,84.94 147.16,87.4 147.16,88.1 145.73,89.53 137.46,89.53 136.34,88.41 135.56,88.41 135.31,88.16
  BOTTOM w0.089: v2(134.88,85.36) 135.2,85.04 UC1.J6
  BOTTOM w0.102: v2(211.13,56.26) 211.34,56.48 211.34,57.27 211.2,57.41 JNGFF2.21
PCIE_PRX_SATATX_P6_L0: length 111
  IN1 w0.091: v2(135.82,87.98) 136.15,87.65 136.43,87.65 136.53,87.76 137.56,87.76 138.61,88.81 144.84,88.81 149.3,84.35 152.87,84.35 156.82,88.3 161.1,88.3 162.58,86.82 166.39,86.82 168.5,84.71 170.71,84.71 174.43,80.99 176.66,80.99 179.06,78.59 179.5,78.59 180.88,77.21 188.92,77.21 189.36,76.76 195.97,76.76 196.81,75.92 197.28,75.92 198.71,74.49 198.71,72.79 200.94,70.56 200.94,62 203.29,59.65 207.23,59.65 210.17,56.71 210.17,55.01 212.36,52.83 214.57,52.83 214.84,53.09 214.84,53.2 v2(214.42,53.61)
  BOTTOM w0.089: UC1.E5 136.15,87.65 v2(135.82,87.98)
  BOTTOM w0.102: JNGFF2.33 214.2,57.38 214.35,57.24 214.35,56 214.33,55.98 214.33,55.45 214.35,55.44 214.35,54.86 214.61,54.6 214.61,53.8 v2(214.42,53.61)
PCIE_PRX_SATATX_P6_L1: length 107.4
  IN1 w0.084: 135.19,88.28 135.17,88.27 135.17,88.26 135.14,88.23 135.14,88.22 135.13,88.22 135.13,87.03 135.25,86.92 135.25,85.89 135.19,85.83 135.04,85.83 134.87,86 v2(134.87,86.01)
  IN1 w0.091: v2(211.71,56.26) 211.71,56.81 210.71,57.81 209.97,57.81 208.66,59.13 208.66,59.7 208.04,60.32 204.4,60.32 202.93,61.79 202.83,61.79 201.58,63.03 201.58,71.93 199.38,74.14 199.38,74.8 195.65,78.52 191.93,78.52 191.18,77.77 189.62,77.77 189.37,78.03 185.36,78.03 184.91,78.48 183.65,78.48 183.2,78.03 181.88,78.03 180.55,79.37 179.82,79.37 176.01,83.18 173.33,83.18 170.9,85.6 169.2,85.6 166.71,88.09 162.22,88.09 161.23,89.08 156.69,89.08 152.73,85.12 149.69,85.12 147.34,87.47 147.34,88.17 145.8,89.7 137.39,89.7 136.27,88.58 135.49,88.58 135.19,88.28
  BOTTOM w0.089: v2(134.87,86.01) 135.18,85.69 UC1.H6
  BOTTOM w0.102: JNGFF2.23 211.7,57.33 211.56,57.19 211.56,56.42 v2(211.71,56.26)
PCIE_PRX_WIGIGTX_N5: length 66.9
  IN1 w0.091: v2(133.91,86.61) 134.08,86.79 134.34,86.79 134.68,87.13 134.68,88.88 135.83,90.03 146.19,90.03 147.93,88.29 147.93,87.63 149.84,85.72 152.66,85.72 156.66,89.72 161.26,89.72 162.29,88.69 167.13,88.69 168.51,87.31 170.05,87.31 173.58,83.78 176.59,83.78 180.26,80.1 184.19,80.1 185.64,78.65 186.43,78.65 186.64,78.85 186.64,79.03 v2(186.84,79.23)
  BOTTOM w0.089: UC1.F10 133.53,87 v2(133.91,86.61)
  BOTTOM w0.102: JNGFF1.59 186.8,80.19 186.66,80.05 186.66,79.41 v2(186.84,79.23)
PCIE_PRX_WIGIGTX_P5: length 66.9
  IN1 w0.091: v2(133.91,87.37) 133.91,87.11 134.05,86.96 134.26,86.96 134.51,87.2 134.51,88.95 135.76,90.21 146.26,90.21 148.1,88.37 148.1,87.7 149.92,85.89 152.58,85.89 156.58,89.89 161.33,89.89 162.36,88.87 167.2,88.87 168.59,87.48 170.12,87.48 173.65,83.95 176.66,83.95 180.33,80.27 184.26,80.27 185.71,78.82 186.36,78.82 186.47,78.93 186.47,79.02 v2(186.26,79.23)
  BOTTOM w0.089: UC1.E10 133.36,87.59 133.58,87.37 v2(133.91,87.37)
  BOTTOM w0.102: JNGFF1.57 186.3,80.25 186.44,80.11 186.44,79.41 v2(186.26,79.23)
PCIE_PRX_WLANTX_N4: length 60.3
  IN1 w0.091: v2(180.81,82.34) 180.6,82.55 180.6,82.72 180.37,82.95 179.51,82.95 176.97,85.49 174.29,85.49 172.26,87.52 172.26,87.82 169.95,90.14 168.61,90.14 168.35,90.41 163.65,90.41 162.94,91.11 161.94,91.11 161.26,91.79 159.27,91.79 158.46,92.6 153.58,92.6 153.03,93.15 149.58,93.15 147.86,91.44 135.06,91.44 134.1,90.47 132.26,90.47 131.44,89.66 131.44,87.25 131.36,87.17 131.26,87.17 131.06,87.37 v2(131.06,87.37)
  BOTTOM w0.076: v2(131.06,87.37) 131.43,87 UC1.F13
  BOTTOM w0.102: v2(180.81,82.34) 180.65,82.17 180.65,81.98 180.8,81.83 JNGFF1.35
PCIE_PRX_WLANTX_P4: length 60.2
  IN1 w0.091: v2(131.06,86.62) 131.06,86.89 131.17,87 131.43,87 131.62,87.18 131.62,89.59 132.33,90.3 134.17,90.3 135.13,91.26 147.94,91.26 149.65,92.98 152.96,92.98 153.5,92.43 158.39,92.43 159.2,91.62 161.18,91.62 161.86,90.94 162.87,90.94 163.58,90.24 168.27,90.24 168.54,89.97 169.87,89.97 172.09,87.75 172.09,87.45 174.22,85.32 176.9,85.32 179.44,82.78 180.3,82.78 180.43,82.65 180.43,82.54 v2(180.23,82.34)
  BOTTOM w0.089: v2(131.06,86.62) 131.33,86.35 UC1.G13
  BOTTOM w0.102: v2(180.23,82.34) 180.43,82.13 180.43,82.01 180.3,81.88 JNGFF1.33
PCIE_PTX_GLANRX_N3: length 99.8
  TOP w0.102: CL6.1 201.13,111.38 201.13,110.79 200.73,110.39 199.46,110.39 v2(199.37,110.29)
  IN1 w0.091: v2(199.37,110.29) 199.16,110.5 196.52,110.5 195.52,111.5 188.97,111.5 187.09,109.62 178.31,109.62 176.05,107.37 172.57,107.37 169.6,104.4 165.35,104.4 164.08,103.13 161.34,103.13 160.89,103.58 148.79,103.58 147.76,102.55 145.35,102.55 144.9,102.11 140.12,102.11 138.92,103.3 134.22,103.3 133.24,104.28 131.67,104.28 129.68,102.28 126.85,102.28 126.75,102.18 124.84,102.18 124.57,101.92 124.57,97.66 121.69,94.78 121.69,92.69 121.5,92.5 121.32,92.5 v2(121.09,92.26)
  BOTTOM w0.076: UC1.C29 121.6,89.14 121.3,89.43 121.3,90.74 120.69,91.35 120.69,92.37 120.77,92.45 120.9,92.45 v2(121.09,92.26)
PCIE_PTX_GLANRX_N3_C: length 6.5
  TOP w0.102: CL6.2 201.02,112.54 200.92,112.64 200.92,113.21 v4(201.51,113.8) 202.99,115.28 203.57,115.28 203.58,115.29 204.14,115.29 204.38,115.53 204.7,115.53 204.79,115.44 UL1.42
PCIE_PTX_GLANRX_P3: length 99.7
  TOP w0.102: CL5.1 200.76,111.62 200.92,111.47 200.92,110.88 200.64,110.61 199.64,110.61 v2(199.37,110.88)
  IN1 w0.091: v2(121.09,92.91) 121.32,92.67 121.43,92.67 121.52,92.76 121.52,94.85 124.4,97.73 124.4,101.99 124.76,102.35 126.68,102.35 126.78,102.45 129.6,102.45 131.6,104.45 133.31,104.45 134.29,103.48 138.99,103.48 140.19,102.28 144.83,102.28 145.28,102.73 147.69,102.73 148.72,103.75 160.97,103.75 161.41,103.31 164.01,103.31 165.28,104.58 169.53,104.58 172.5,107.54 175.98,107.54 178.23,109.79 187.02,109.79 188.9,111.67 195.59,111.67 196.6,110.67 199.16,110.67 v2(199.37,110.88)
  BOTTOM w0.076: UC1.B30 121.11,89.37 121.11,90.67 120.5,91.27 120.5,92.45 120.69,92.64 120.81,92.64 v2(121.09,92.91)
PCIE_PTX_GLANRX_P3_C: length 6.6
  TOP w0.102: CL5.2 200.7,112.78 200.7,113.3 201.15,113.75 201.15,113.76 201.53,114.15 201.55,114.15 202.91,115.51 v4(203.22,115.51) 204.05,115.51 204.29,115.75 204.75,115.75 204.84,115.84 UL1.41
PCIE_PTX_MMIRX_N1: length 167.1
  TOP w0.102: v2(24.04,27.44) 23.94,27.33 23.94,26.81 CR25.1
  IN4 w0.084: 95.66,75.38 95.68,75.38 95.69,75.39 97.27,75.39 97.61,75.04 100.37,75.04 100.63,75.3 102.88,75.3 102.97,75.21 114.02,75.21 114.82,76 122.82,76 123.78,76.95 123.78,84.19 125.75,86.16 125.75,88.87 123.68,90.94 121.06,90.94 120.59,91.41 120.59,93.84 119.84,94.59 119.22,94.59 v2(119.19,94.56)
  IN4 w0.091: v2(24.04,27.44) 24.04,27.78 24.11,27.84 24.97,27.84 25.26,27.55 26.53,27.55 29.95,30.97 32.41,30.97 34.47,33.03 34.47,37.79 34.27,38 34.27,39.45 34.67,39.85 35.5,39.85 35.79,39.56 40.45,39.56 42.42,37.59 49.28,37.59 49.9,38.22 55.51,38.22 56.79,36.95 62.28,36.95 69.08,43.74 69.08,56.94 87.52,75.38 95.66,75.38
  BOTTOM w0.076: UC1.C30 120.76,89.08 120.52,89.32 120.35,89.32 120.21,89.46 120.18,89.57 120.18,89.7 120.2,89.76 120.21,89.77 120.24,89.85 120.24,90.07 120.16,90.22 120.16,90.44 119.76,90.84 119.76,93.06 119.92,93.21 119.92,94.34 119.69,94.56 v2(119.19,94.56)
PCIE_PTX_MMIRX_N1_C: length 4.4
  TOP w0.102: UR1.5 22.89,22.45 22.8,22.55 22.8,23.94 22.89,24.04 22.91,24.04 23.29,24.41 23.29,24.43 23.92,25.06 23.92,25.35 CR25.2
PCIE_PTX_MMIRX_P1: length 166.9
  TOP w0.102: v2(23.46,27.44) 23.72,27.17 23.72,26.96 CR24.1
  IN4 w0.084: 95.66,75.56 95.68,75.56 95.69,75.55 97.34,75.55 97.68,75.21 100.3,75.21 100.56,75.47 102.95,75.47 103.04,75.37 113.96,75.37 114.75,76.17 122.76,76.17 123.61,77.02 123.61,84.26 125.58,86.23 125.58,88.8 123.61,90.77 120.99,90.77 120.42,91.34 120.42,93.77 119.77,94.42 119.59,94.42 119.55,94.38 119.55,94.03 119.49,93.98 v2(119.19,93.98)
  IN4 w0.091: 95.66,75.56 87.45,75.56 68.91,57.01 68.91,43.82 62.21,37.12 56.86,37.12 55.59,38.39 49.83,38.39 49.2,37.77 42.49,37.77 40.53,39.73 35.86,39.73 35.58,40.02 34.6,40.02 34.09,39.52 34.09,37.93 34.3,37.72 34.3,33.1 32.34,31.14 29.88,31.14 26.46,27.72 25.33,27.72 25.04,28.01 24.04,28.01 v2(23.46,27.44)
  BOTTOM w0.076: UC1.C31 120.47,89.13 120.44,89.16 120.24,89.16 120.21,89.19 120.15,89.24 120.06,89.39 120.01,89.54 120.01,89.73 120.02,89.76 120.07,89.88 120.07,89.99 119.97,90.26 119.97,90.36 119.57,90.76 119.57,93.14 119.73,93.29 119.73,94.26 119.61,94.37 119.53,94.37 119.19,94.03 v2(119.19,93.98)
PCIE_PTX_MMIRX_P1_C: length 4.5
  TOP w0.102: UR1.6 22.49,22.44 22.58,22.53 22.58,24.03 v4(22.94,24.39) 23.7,25.15 23.7,25.33 23.4,25.63 CR24.2
PCIE_PTX_SATARX_N6_L0: length 124.8
  IN1 w0.084: 137.1,92.34 137.08,92.34 137.07,92.35 134.12,92.35 133.18,91.41 131.43,91.41 131.19,91.65 130.75,91.65 v2(130.27,91.17)
  IN1 w0.091: v2(215.65,54.17) 216.01,54.53 216.01,56.7 211.05,61.66 207.44,61.66 205.07,64.03 205.07,66.07 204.43,66.72 204.43,68.29 204.05,68.67 204.05,73.55 203.2,74.4 201.07,74.4 200.61,74.86 200.61,75.49 201.07,75.96 202.02,75.96 203,76.93 203,79.4 202.66,79.75 197.83,79.75 197.21,80.37 191.24,80.37 190.21,81.4 186.1,81.4 183.91,83.59 183.91,84.25 181.55,86.61 179.31,86.61 178.96,86.25 178.24,86.25 177.68,86.82 177.68,87.66 177.37,87.96 174.28,87.96 173.19,89.05 173.19,90.21 171.08,92.32 164.92,92.32 164.08,93.17 159.89,93.17 159.08,93.97 154.02,93.97 153.47,94.52 149.19,94.52 147.48,92.81 139.43,92.81 138.95,92.34 137.1,92.34
  BOTTOM w0.076: v2(130.27,91.17) 130.27,91.37 130.21,91.43 130.13,91.43 130.02,91.54 129.89,91.54 129.73,91.39 129.73,90.7 129.58,90.54 129.58,90.07 129.25,89.74 129.25,89.42 129.35,89.32 129.52,89.32 129.57,89.26 129.57,88.88 129.47,88.78 129.27,88.78 129.12,88.92 UC1.C17
  BOTTOM w0.102: CZ32.1 215.85,54.74 215.85,54.37 v2(215.65,54.17)
PCIE_PTX_SATARX_N6_L0_C: length 2.4
  BOTTOM w0.102: JNGFF2.39 215.7,57.32 215.85,57.17 215.85,56.39 CZ32.2
PCIE_PTX_SATARX_N6_L1: length 119.7
  IN1 w0.084: 137.62,91.73 137.6,91.73 137.59,91.74 134.65,91.74 133.8,90.88 131.31,90.88 129.83,89.41 129.83,88.62 129.94,88.52 130.52,88.52 130.66,88.66 130.66,88.92 130.55,89.03 v2(130.39,89.03)
  IN1 w0.091: 137.62,91.73 139.22,91.73 139.53,92.04 147.62,92.04 149.33,93.75 153.15,93.75 153.7,93.2 158.76,93.2 159.57,92.39 163.76,92.39 165.14,91.01 171.06,91.01 172.41,89.66 172.41,88.74 174.17,86.97 176.2,86.97 177.82,85.35 181.79,85.35 182.68,84.45 182.68,82.2 183.22,81.67 184.74,81.67 185.78,80.63 190.07,80.63 190.97,79.72 196.82,79.72 197.45,79.09 201.61,79.09 201.95,78.75 201.95,76.9 201.67,76.62 200.7,76.62 199.96,75.88 199.96,74.59 200.81,73.74 202.94,73.74 203.4,73.28 203.4,68.4 203.65,68.15 203.65,66.4 204.41,65.63 204.41,63.75 207.33,60.84 208.35,60.84 209.14,60.04 209.14,59.66 210.44,58.36 210.95,58.36 212.92,56.39 212.92,54.66 v2(212.64,54.39)
  BOTTOM w0.089: UC1.B14 130.47,89.68 130.37,89.68 130.1,89.41 130.1,89.27 130.34,89.03 v2(130.39,89.03)
  BOTTOM w0.102: v2(212.64,54.39) 212.83,54.57 212.83,54.75 CZ58.1
PCIE_PTX_SATARX_N6_L1_C: length 2.4
  BOTTOM w0.102: JNGFF2.27 212.7,57.27 212.84,57.13 212.84,56.39 CZ58.2
PCIE_PTX_SATARX_P6_L0: length 124.8
  IN1 w0.084: 137.1,92.51 137.08,92.51 137.07,92.51 134.05,92.51 133.12,91.57 131.5,91.57 131.26,91.82 v2(130.27,91.82)
  IN1 w0.091: 137.1,92.51 138.88,92.51 139.36,92.99 147.41,92.99 149.12,94.69 153.54,94.69 154.09,94.15 159.15,94.15 159.96,93.34 164.15,93.34 164.99,92.49 171.15,92.49 173.36,90.29 173.36,89.12 174.35,88.13 177.44,88.13 177.85,87.73 177.85,86.89 178.31,86.43 178.89,86.43 179.24,86.78 181.63,86.78 184.08,84.33 184.08,83.67 186.17,81.57 190.28,81.57 191.31,80.54 197.28,80.54 197.9,79.92 202.73,79.92 203.17,79.48 203.17,76.86 202.1,75.78 201.14,75.78 200.78,75.42 200.78,74.93 201.14,74.57 203.27,74.57 204.22,73.62 204.22,68.74 204.6,68.36 204.6,66.79 205.25,66.14 205.25,64.1 207.51,61.83 211.12,61.83 216.18,56.78 216.18,54.23 v2(216.24,54.17)
  BOTTOM w0.076: UC1.D17 129.25,88.48 128.82,88.9 128.82,89.2 129.06,89.44 129.06,89.79 129.42,90.14 129.42,90.65 129.54,90.77 129.54,91.46 129.81,91.74 130.19,91.74 v2(130.27,91.82)
  BOTTOM w0.102: CZ33.1 216.07,54.74 216.07,54.34 v2(216.24,54.17)
PCIE_PTX_SATARX_P6_L0_C: length 2.4
  BOTTOM w0.102: JNGFF2.41 216.2,57.32 216.07,57.19 216.07,56.39 CZ33.2
PCIE_PTX_SATARX_P6_L1: length 119.7
  IN1 w0.084: 137.62,91.9 137.6,91.9 137.59,91.9 134.58,91.9 133.73,91.05 131.24,91.05 129.67,89.47 129.67,88.56 129.87,88.36 130.02,88.36 130.1,88.27 v2(130.1,87.97)
  IN1 w0.091: v2(213.23,54.39) 213.09,54.53 213.09,56.46 211.02,58.53 210.51,58.53 209.31,59.73 209.31,60.12 208.42,61.01 207.4,61.01 204.59,63.82 204.59,65.7 203.82,66.47 203.82,68.23 203.57,68.47 203.57,73.36 203.01,73.92 200.88,73.92 200.13,74.66 200.13,75.81 200.77,76.44 201.74,76.44 202.12,76.83 202.12,78.82 201.68,79.26 197.53,79.26 196.89,79.9 191.05,79.9 190.14,80.8 185.85,80.8 184.81,81.84 183.29,81.84 182.86,82.27 182.86,84.52 181.86,85.52 177.9,85.52 176.27,87.14 174.25,87.14 172.58,88.81 172.58,89.73 171.13,91.18 165.21,91.18 163.83,92.57 159.64,92.57 158.83,93.37 153.77,93.37 153.22,93.92 149.26,93.92 147.55,92.21 139.46,92.21 139.15,91.9 137.62,91.9
  BOTTOM w0.089: v2(130.1,87.97) 129.96,88.11 129.96,88.99 UC1.C15
  BOTTOM w0.102: CZ59.1 213.05,54.73 213.05,54.57 v2(213.23,54.39)
PCIE_PTX_SATARX_P6_L1_C: length 2.4
  BOTTOM w0.102: CZ59.2 213.06,56.39 213.06,57.13 213.2,57.27 JNGFF2.29
PCIE_PTX_WIGIGRX_N5: length 90.7
  IN1 w0.091: v2(127.64,93.57) 128.06,93.15 128.15,93.15 130.97,95.97 131.49,95.97 133.21,97.69 143.61,97.69 144.63,96.68 146.67,96.68 147.7,97.72 169.81,97.72 175.2,92.32 176.09,92.32 176.45,91.96 178.36,91.96 180.77,89.54 183.47,89.54 188.35,84.66 188.7,84.66 188.81,84.76 188.81,84.92 v2(188.52,85.21)
  BOTTOM w0.076: v2(127.64,93.57) 127.2,93.12 126.96,93.12 125.98,92.14 125.98,90.2 125.71,89.93 125.71,89.52 125.52,89.34 125.52,89.21 125.66,89.07 UC1.C23
  BOTTOM w0.102: v2(188.52,85.21) 188.89,84.84 188.89,84.55 189.63,83.81 190.61,83.81 190.95,83.47 190.95,80.05 188.52,77.63 185.26,77.63 185.02,77.87 185.02,78.46 185.12,78.57 185.26,78.57 CZ22.1
PCIE_PTX_WIGIGRX_N5_C: length 2.1
  BOTTOM w0.102: CZ22.2 185.17,79.57 185.17,80.12 185.3,80.25 JNGFF1.53
PCIE_PTX_WIGIGRX_P5: length 90.7
  IN1 w0.091: v2(127.64,92.93) 127.69,92.98 128.22,92.98 131.04,95.8 131.56,95.8 133.29,97.52 143.54,97.52 144.55,96.51 146.74,96.51 147.78,97.54 169.73,97.54 175.13,92.15 176.02,92.15 176.38,91.78 178.28,91.78 180.7,89.37 183.4,89.37 188.28,84.48 188.78,84.48 188.98,84.69 188.98,85.08 v2(189.1,85.21)
  BOTTOM w0.076: v2(127.64,92.93) 127.04,92.93 126.17,92.06 126.17,90.12 125.9,89.85 125.9,89.5 126.03,89.37 126.03,88.59 UC1.C22
  BOTTOM w0.102: v2(189.1,85.21) 189.1,84.64 189.72,84.02 190.7,84.02 191.16,83.56 191.16,79.96 188.61,77.41 185.17,77.41 184.8,77.78 184.8,78.07 CZ21.1
PCIE_PTX_WIGIGRX_P5_C: length 2.2
  BOTTOM w0.102: CZ21.2 184.95,79.67 184.95,80.1 184.9,80.16 184.8,80.25 JNGFF1.51
PCIE_PTX_WLANRX_N4: length 95.5
  IN1 w0.091: v2(122.51,92.89) 122.75,93.13 123.27,93.13 123.6,93.46 123.6,95.77 125.03,97.2 127.56,97.2 129,98.64 129,99.06 129.35,99.41 129.35,100.97 131.95,103.56 132.98,103.56 133.88,102.66 137.65,102.66 138.84,101.46 145.48,101.46 145.93,101.91 163.77,101.91 164.56,102.7 167.39,102.7 v2(167.55,102.53)
  BOTTOM w0.076: UC1.B29 121.6,89.7 122.05,90.16 122.05,91.21 121.93,91.33 121.93,92.97 122.11,93.15 122.26,93.15 v2(122.51,92.89)
  BOTTOM w0.102: CZ14.1 179.33,78.08 179.33,77.7 179.11,77.49 174.77,77.49 172.72,79.53 172.72,83.04 172.2,83.56 167.84,83.56 166.64,84.76 166.64,86.35 166.08,86.91 166.08,92.71 167.96,94.59 167.96,102.47 167.9,102.53 v2(167.55,102.53)
PCIE_PTX_WLANRX_N4_C: length 2.2
  BOTTOM w0.102: JNGFF1.29 179.3,80.25 179.16,80.11 179.16,79.62 CZ14.2
PCIE_PTX_WLANRX_P4: length 95.4
  IN1 w0.091: v2(122.51,93.54) 122.75,93.31 123.2,93.31 123.43,93.53 123.43,95.84 124.96,97.38 127.49,97.38 128.83,98.72 128.83,99.13 129.18,99.48 129.18,101.04 131.87,103.73 133.05,103.73 133.95,102.83 137.72,102.83 138.91,101.63 145.41,101.63 145.85,102.08 163.7,102.08 164.48,102.87 167.31,102.87 v2(167.55,103.11)
  BOTTOM w0.076: UC1.A29 121.6,90.26 121.81,90.26 121.89,90.34 121.89,90.52 121.81,90.59 121.71,90.59 121.63,90.67 121.63,90.82 121.71,90.9 121.81,90.9 121.89,90.97 121.89,91.15 121.74,91.29 121.74,93.05 122.03,93.34 122.3,93.34 v2(122.51,93.54)
  BOTTOM w0.102: v2(167.55,103.11) 167.55,103.11 167.91,102.75 167.99,102.75 168.18,102.56 168.18,94.5 166.3,92.62 166.3,87 166.86,86.44 166.86,84.85 167.93,83.77 172.29,83.77 172.94,83.13 172.94,79.62 174.86,77.7 179.02,77.7 179.11,77.79 179.11,77.87 CZ13.1
PCIE_PTX_WLANRX_P4_C: length 2.1
  BOTTOM w0.102: CZ13.2 178.94,79.5 178.94,80.11 178.8,80.25 JNGFF1.27
PCIE_WAKE#: length 176
  TOP w0.102: RE275.1 171.67,100.92 171.67,96.27 172.82,95.11 174.31,95.11 174.66,94.76 v2(174.66,93.43) ; RE274.1 197.16,89.53 196.85,89.83 196.85,90.32 v2(194.87,92.3)
  IN3 w0.122: v2(194.87,92.3) 194.74,92.17 191.06,92.17 190.44,91.56 185.55,91.56 185.03,92.09 181.83,92.09 181.67,91.93 180.62,91.93 180.37,91.68 175.78,91.68 174.66,92.8 v2(174.66,93.43) ; v2(217.68,67.11) 217.68,65.78 213.39,61.48 209.54,61.48 209.21,61.81 206.57,61.81 205.68,62.71 205.68,62.71 203.94,64.45 200.89,64.45 198.12,61.68 197.98,61.68 197.98,61.68 197.63,61.68 197.63,61.68 197.05,61.68 189.57,54.21 v2(189.57,54.04)
  IN4 w0.084: v2(194.87,92.3) 194.65,92.08 192.01,92.08 191.9,92.19 191.26,92.19 190.8,91.73 189.13,91.73 186.41,89.01 v2(186.41,84.69) 185.95,84.22 185.95,81.76 188.72,78.98 188.72,78.48 188.47,78.22 183.45,78.22 182.61,77.38 176.79,77.38 174.84,75.43 174.84,71.96 173.04,70.16 168.51,70.16 166.98,68.63 166.98,60.57 168.4,59.15 173.25,59.15 174.88,57.52 178.37,57.52 181.42,54.47 189.13,54.47 v2(189.57,54.04)
  BOTTOM w0.102: JNGFF2.46 217.45,66.56 217.68,66.79 v2(217.68,67.11) ; v2(194.87,92.3) 194.64,92.08 v1(194.64,91.61) 194.64,91.06 194.19,90.61 193.5,90.61 193.18,90.92 193.18,92.04 192.97,92.26 190.9,92.26 190.72,92.08 188.58,92.08 187.55,91.04 JNGFF1.62 ; JNGFF1.47 183.8,81.97 184.28,82.45 184.28,83.81 184.06,84.03 184.06,84.48 184.27,84.69 v2(186.41,84.69)
PCIE_WAKE#_R: length 8.5
  TOP w0.102: RE35.2 172.85,101.18 RE275.2 173.41,101.21 v2(173.65,101.45) v1(174.23,101.45) ; v2(178.68,101.13) 178.65,101.09 UE1.B10
  IN3 w0.122: v2(173.65,101.45) 173.77,101.33 178.48,101.33 v2(178.68,101.13)
PD#: length 3.6
  TOP w0.102: RI34.2 RI35.1 220.94,81.53 v1(221.5,80.97) 221.51,80.96 UI7.5
PE_REXT: length 5.8
  TOP w0.102: 24.83,25.05 v1(24.29,24.51) 23.04,23.26 23.04,22.63 23.29,22.38
  TOP w0.109: 24.83,25.05 24.83,25.91 RR2.2 ; UR1.4 23.29,22.38
PECI_EC: length 204.3
  TOP w0.102: RE60.2 197.39,87.29 197.98,87.89 v2(197.98,88)
  IN1 w0.084: v2(82.37,77.52) 86.15,81.31 91.95,81.31 92.55,81.91 95.15,81.91 v2(95.87,82.62)
  BOTTOM w0.076: v2(95.87,82.62) 96.52,81.97 98.59,81.97 99.43,82.8 99.82,82.8 100,82.63 100.55,82.63 100.84,82.92 UC1.N62
  BOTTOM w0.102: v2(82.37,77.52) 82.37,76.03 78.88,72.55 v1(78.88,67) 78.88,51.94 83.6,47.22 154.91,47.22 159.57,51.88 165.97,51.88 171.51,57.42 187.74,57.42 189.97,59.64 193.79,59.64 196.74,62.59 196.74,65.12 197.86,66.23 198.6,66.23 200.21,67.84 200.21,77.08 199.41,77.88 199.41,80.35 199.72,80.66 199.72,82.59 199.48,82.83 199.48,86.25 197.98,87.75 v2(197.98,88)
PECI_EC_R: length 2.3
  TOP w0.102: UE2.A48 199.88,88.25 v1(199.21,87.58) 198.82,87.19 RE60.1
PGOOD_3V_5V: length 5.5
  TOP w0.254: PR107.1 PR108.2 42.62,28.25 42.62,27.7 42.79,27.54 43.25,27.54 43.94,26.84 v1(43.94,26.08) 44.55,25.47 PU100.7
PLTRST_LAN#: length 83
  TOP w0.102: v2(203.15,119.45) 203.65,118.95 206.02,118.95 206.15,118.83 UL1.36 ; RC89.1 158.61,77.01 160.29,78.68 160.29,79.78 162.02,81.51 162.02,84.54 164.31,86.84 164.31,96.54 v1(162.53,98.32) 161.56,99.29 v2(161.56,100.02)
  IN4 w0.084: v2(203.15,119.45) 202.72,119.88 190.69,119.88 187.69,116.87 182.56,116.87 181.74,117.69 177.39,117.69 174.39,114.69 174.39,114.68 170.35,110.65 170.35,110.32 167.63,107.6 167.62,107.6 165.56,105.54 165.56,103.18 163.73,101.35 162.61,101.35 161.56,100.3 v2(161.56,100.02)
PLTRST_MMI#: length 184.4
  TOP w0.102: UR1.15 18.67,20.24 18.54,20.37 18.16,20.37 v2(17.83,20.7) ; v1(162.38,76.8) 162.09,76.51 v2(161.83,76.51) 161.31,77.03 RC88.1
  IN2 w0.122: v2(161.83,76.51) 160.16,74.84 160.16,74.39 159.65,73.88 159.5,73.88 158.68,73.05 158.68,71.33 158.47,71.12 158.47,68.46 156.42,66.42 156.42,54.04 153.1,50.73 139.26,50.73 135.38,46.85 79.32,46.85 70.7,38.23 65.2,38.23 64.13,39.3 60.2,39.3 59.67,39.83 56.1,39.83 55.66,39.39 49.79,39.39 49.78,39.4 44.18,39.4 42.94,38.17 42.94,38.17 40.11,35.34 35.33,35.34 35.1,35.11 34.13,35.11 29.22,30.2 29.22,29.7 26.52,27 26.37,27 21.55,22.18 20.88,22.18 19.7,21.01 19.7,20.53 18.59,19.42 17.66,19.42 17.42,19.67 17.42,20.29 v2(17.83,20.7)
PLTRST_USH#: length 96.9
  TOP w0.102: v2(209.78,43.47) 209.69,43.56 209.69,52.92 v2(209.53,53.08) ; v2(162.88,81.91) 162.88,80.51 v1(162.5,80.13) 162.5,79.73 161.31,78.54 RC87.1 ; CZ68.1 223.3,46.66 JUSH1.6 223.3,44.29 223.08,44.07 221.15,44.07 v2(221,43.92)
  IN1 w0.084: v2(209.53,53.08) 209.51,53.08 208.66,53.92 208.66,55.03 205.44,58.26 202.87,58.26 201.99,59.14 200.12,59.14 198.57,60.69 198.57,61.92 196.76,63.73 196.76,65.34 198.47,67.05 198.47,67.5 197.6,68.37 197.6,69.58 197.08,70.11 195.11,70.11 193.8,71.41 190.59,71.41 188.52,73.48 180.58,73.48 179.91,74.15 177.41,74.15 170.78,80.78 169.8,80.78 168.75,81.83 165.68,81.83 165.18,82.33 163.3,82.33 162.88,81.91 v2(162.88,81.91) ; v2(221,43.92) 220.91,43.83 219.13,43.83 218.98,43.98 217.33,43.98 216.58,43.24 210.01,43.24 v2(209.78,43.47)
PLTRST_VMM2320#: length 50.1
  TOP w0.102: RC219.1 158.18,76.36 158.18,77.27 159.2,78.29 v2(159.2,78.57) v1(159.2,79.16)
  IN2 w0.122: v2(159.2,78.57) 159.2,79.78 158.24,80.74 158.24,90.24 163.26,95.26 163.26,97.35 159.86,100.75 159.86,103.85 159.13,104.58 159.13,112.4 158.93,112.6 158.93,116.24 157.99,117.17 v2(156.47,117.17)
  BOTTOM w0.102: v2(156.47,117.17) 156.05,116.75 156.05,116.5 155.72,116.17 UV8.A13
PM_APWROK: length 82.7
  TOP w0.102: UE2.A9 211.97,92.25 212.4,91.82 v2(212.4,91.69)
  IN4 w0.084: v2(212.4,91.69) 212.4,91.95 212.12,92.23 212.12,93.11 212.41,93.4 213.81,93.4 214.38,93.97 214.38,97.39 213.84,97.92 212.97,97.92 210.24,100.66 209.6,100.66 208.67,101.59 203.18,101.59 202.75,102.02 198.62,102.02 197.24,100.64 185.1,100.64 184.62,101.12 180.66,101.12 180.24,100.7 178.46,100.7 178.12,100.37 178.12,100.18 173.27,95.33 173.27,93.61 169.25,89.58 167.55,89.58 162.16,84.2 159.78,84.2 156.01,80.43 v2(156.01,79.05)
  BOTTOM w0.102: RC26.1 156.49,78.21 156.01,78.69 v2(156.01,79.05)
PM_APWROK_L: length 4.9
  BOTTOM w0.102: UC6.2 158.68,80.48 158.27,80.89 157.43,80.89 RC27.2 156.85,80.31 RC26.2 156.58,79.12 v1(155.9,79.81)
PM_APWROK_R: length 28.8
  TOP w0.102: v2(154.82,77.84) 154.82,77.97 v3(155.26,78.41)
  IN1 w0.084: v2(136.34,78.68) 136.34,78.56 137.36,77.54 139.86,77.54 141.65,75.75 147.29,75.75 147.79,76.25 149.21,76.25 149.55,76.6 151.36,76.6 152.79,78.03 154.63,78.03 v2(154.82,77.84)
  BOTTOM w0.089: v2(136.34,78.68) 136.18,78.52 UC1.AB5
  BOTTOM w0.102: v2(154.82,77.84) 154.82,80.51 156.05,81.74 157.92,81.74 158.03,81.84 UC6.4
PM_LANPHY_ENABLE: length 120.2
  TOP w0.102: v2(135.49,73.14) 135.8,72.83 136.67,72.83 136.9,72.6 137.95,72.6 139.31,71.24 146.21,71.24 149.06,74.09 153.87,74.09 RC92.2 ; RL7.1 206.21,106.37 206.12,106.37 205.5,105.74 203.33,105.74 v1(203.06,105.48) 201.41,103.83 v2(201.32,103.83)
  IN2 w0.122: v2(201.32,103.83) 201.32,103.69 200.57,102.95 200.57,98.03 201.01,97.6 201.01,87.67 200.12,86.79 200.12,83.75 v2(200.46,83.42)
  IN3 w0.089: 146.46,74.64 145.59,73.77 140.07,73.77 139.79,74.05 136.96,74.05 136.72,73.8 136.35,73.8 135.69,73.14 v2(135.49,73.14)
  IN3 w0.122: 146.46,74.64 148,76.18 148,77.79 150.1,79.89 154.05,79.89 154.64,80.47 163.44,80.47 164.43,81.46 197.09,81.46 198.68,83.05 200.09,83.05 v2(200.46,83.42)
  BOTTOM w0.076: v2(135.49,73.14) 135.19,72.84 UC1.AM7
PM_TEST_RST: length 10.6
  TOP w0.089: CC100.2 RC300.2 142.74,77.04 142.45,77.33 140.55,77.33 140.31,77.09 139.11,77.09 v1(138.72,77.47) 137.04,77.47 136.78,77.73 v2(136.36,77.73)
  BOTTOM w0.089: UC1.AC4 136.4,77.76 v2(136.36,77.73)
POA_WAKE#: length 4.6
  TOP w0.102: RPE5.3 213.16,86.58 212.84,86.9 211.09,86.9 210.58,87.4 UE2.B68
POWER_SW#_MB: length 74.4
  TOP w0.102: v2(222,60.79) 222.44,60.35 222.44,59.36 222.07,58.98 221.87,58.98 221.65,59.2 JIO1.1 ; CE10.1 217.3,79.71 RE33.2 217.32,79.3 v2(217.02,79) 217.02,78.58 v1(217.22,78.38) ; v2(227,76.37) 227.21,76.37 230.38,79.54 230.38,88.37 227.43,91.32 225.1,91.32 224.13,90.35 SW2.4 SW2.2 222.23,102.68 221.71,103.2 JAPS1.11
  IN1 w0.084: v2(222,60.79) 223.56,62.35 224.81,62.35 226.49,64.03 226.49,73.63 227,74.13 v2(227,76.37)
  BOTTOM w0.102: v2(217.02,79) 217.02,78.31 220.16,75.17 225.81,75.17 v2(227,76.37)
POWER_SW_IN#: length 17.7
  TOP w0.102: UE2.B67 209.12,88.34 v2(208.62,88.84) ; v2(214.76,80.55) 215.34,80.55 RE31.2 215.94,80.67 215.97,80.7 CE12.1 RE33.1 v1(215.34,79.68)
  BOTTOM w0.102: v2(214.76,80.55) 212.48,80.55 209.96,83.07 209.96,86.27 208.96,87.28 208.96,88.02 209.02,88.08 209.02,88.42 208.96,88.49 208.96,88.5 v2(208.62,88.84)
PROC_OPI_RCOMP: length 5.7
  BOTTOM w0.076: 130.88,65.01 130.64,65.26 130.64,66.13 130.47,66.3 130.47,66.86 130.26,67.07 130.26,67.57 UC1.AY15
  BOTTOM w0.305: 130.88,65.01 v1(130.88,63.62) 130.88,62.59 RC187.1
PROCHOT_GATE: length 2
  TOP w0.102: RE83.2 186.5,108.23 185.69,107.42 UE1.A50
PS8338_AUX: length 30.2
  TOP w0.102: UV7.55 121.13,120.89 v2(120.59,121.44) 119.73,122.3 RV554.2 ; v2(139.93,111.46) 140.42,111.94 UV600.24
  IN2 w0.114: v2(139.93,111.46) 140.12,111.65 140.12,112.07 138.09,114.1 133.63,114.1 129.61,118.13 129.61,119.98 127.68,121.91 126.79,121.91 125.5,120.62 121.1,120.62 120.75,120.97 120.75,121.29 120.59,121.44 v2(120.59,121.44)
PS8338_AUX#: length 30.2
  TOP w0.102: RV555.2 120.4,122.16 120.4,121.94 120.49,121.85 120.77,121.85 v2(121.17,121.44) 121.17,121.2 121.22,121.15 121.35,121.15 121.53,120.96 UV7.54 ; v2(140.51,111.46) 140.82,111.76 UV600.25
  IN2 w0.114: v2(121.17,121.44) 120.94,121.21 120.94,121.05 121.18,120.82 125.41,120.82 126.71,122.11 127.76,122.11 129.8,120.06 129.8,118.21 133.71,114.3 138.17,114.3 140.32,112.15 140.32,111.65 v2(140.51,111.46)
PS8338_CFG0: length 7
  TOP w0.102: v1(133.87,122.47) 134.46,122.47 135.36,121.57 RV601.2 136.12,121.57 136.22,121.67 138.34,121.67 138.84,122.16 139.37,122.16 139.62,121.92 UV600.59
