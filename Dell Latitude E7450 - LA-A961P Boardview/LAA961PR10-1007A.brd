# Allegro board LAA961PR10-1007A.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
EXPRESS_DET#: length 10
  TOP w0.102: T97.1 174.16,98.35 175.97,96.54 v2(175.97,96.22) ; UE1.B15 178.99,98.59 v2(179.16,98.42)
  IN1 w0.084: v2(175.97,96.22) 175.97,97.1 177.3,98.42 v2(179.16,98.42)
F-IMAX: length 4.7
  TOP w0.102: v2(92.14,101.91) v1(92.75,102.52)
  TOP w0.254: v2(92.14,101.91) 91.65,101.91 91.46,101.72 PR508.2
  BOTTOM w0.203: PR503.1 92.4,102.29 92.14,102.04 v2(92.14,101.91) 91.33,101.1 PU500.10
FAN1_PWM: length 214.7
  TOP w0.102: UE2.A24 205.87,98.13 v2(205.95,98.21) 206,98.26 206,98.91 206.12,99.04 RE48.2 ; v1(196.04,122.74) v2(196.04,121.8)
  IN3 w0.122: v2(78.46,90.65) 77.58,90.65 71.3,96.93 71.3,101.1 70.46,101.94 70.46,101.95 70.3,102.1 70.3,110.48 62.36,118.42 62.36,122.68 63.44,123.76 105.21,123.76 107.51,121.47 108.08,121.47 109.08,120.46 124.62,120.46 128.5,124.35 133,124.35 133.86,125.22 138.85,125.22 139.68,126.05 140.72,126.05 142.91,128.24 150.03,128.24 151.57,126.69 156.07,126.69 156.32,126.44 157.2,126.44 157.53,126.11 163.56,126.11 164.09,125.57 168.85,125.57 171.78,122.64 190.61,122.64 190.78,122.81 195.03,122.81 v2(196.04,121.8)
  BOTTOM w0.102: JFAN1.2 78.46,90.65 v2(78.46,90.65) ; v2(205.95,98.21) 205.64,97.91 204.92,97.91 204.51,98.31 204.51,99.05 203.55,100.02 203.55,101.67 202.08,103.13 202.08,106.9 201.08,107.91 201.08,116.22 196.04,121.26 v2(196.04,121.8)
FAN1_TACH: length 219.2
  TOP w0.102: v2(196.66,121.78) 196.66,121.71 v1(197.13,121.24) ; UE2.B22 207.62,95.96 v2(207.59,95.93) ; RE51.2 204.82,101.68 204.18,101.04 v2(204.18,100.99)
  IN2 w0.122: v2(207.59,95.93) 206.63,96.89 206.09,96.89 204.18,98.8 v2(204.18,100.99)
  IN3 w0.122: v2(196.66,121.78) 195.38,123.06 190.68,123.06 190.51,122.89 171.88,122.89 168.95,125.82 164.2,125.82 163.66,126.36 157.63,126.36 157.29,126.7 157.29,127.24 156.72,127.82 154.99,127.82 154.11,126.94 151.67,126.94 150.13,128.48 142.81,128.48 140.62,126.3 139.58,126.3 138.75,125.47 133.76,125.47 133.49,125.2 129,125.2 126.98,123.18 126.28,123.18 124.86,121.76 123.06,121.76 122.02,120.71 109.18,120.71 108.18,121.72 107.61,121.72 105.31,124.01 63.34,124.01 62.11,122.79 62.11,118.32 70.06,110.38 70.06,101.99 71.05,101 71.05,96.83 v2(78.47,89.4)
  BOTTOM w0.102: v2(196.66,121.78) 196.66,121.02 201.31,116.37 201.31,108 202.31,107 202.31,103.23 203.77,101.77 203.77,101.4 v2(204.18,100.99) ; JFAN1.3 v2(78.47,89.4)
FB_3V: length 3.1
  TOP w0.254: PR100.2 45.23,28.29 PR102.2 45.41,27.79 45.67,27.52 46.01,27.52 46.34,27.2 PU100.4
FB_5V: length 3.9
  TOP w0.254: PU100.2 47.14,27.2 47.46,27.52 48.16,27.52 48.53,27.89 48.53,28.3 PR104.1 48.87,28.32 PR101.1
FB_+V1.05SP:
  vias: v1(194.45,65.28)
FFS_INT2: length 133.8
  TOP w0.102: v2(159.46,87.02) 159.62,87.18 RC158.2 ; UN1.9 218.15,117.36 217.54,116.75 v1(217.54,112.14) 217.54,111.7 217.07,111.23 215.18,111.23 215.06,111.34 QN1.2 215.06,112.02 215.25,112.21 v2(215.25,112.65)
  IN1 w0.084: v2(141.42,86.79) 142.41,85.8 146.43,85.8 149.47,82.77 151.01,82.77 151.42,83.18 152.91,83.18 156.75,87.02 v2(159.46,87.02)
  IN2 w0.122: v2(215.25,112.65) 215.25,110.95 214.51,110.2 214.51,107.15 216.61,105.05 216.61,102.51 214.82,100.73 214.82,99.3 217.1,97.03 217.1,93.67 216.47,93.05 v2(216.47,91.75)
  IN3 w0.122: v2(159.46,87.02) 159.87,87.43 159.87,91.64 162.04,93.81 174.1,93.81 174.44,94.16 174.88,94.16 176.24,92.79 179.38,92.79 179.58,92.58 181.6,92.58 181.6,92.58 185.03,92.58 185.59,93.14 188.98,93.14 190.13,94.3 190.13,94.73 191.21,95.81 193.37,95.81 194.68,97.11 196.38,97.11 197.11,96.38 197.95,96.38 198.33,96.76 207.39,96.76 208.09,96.07 208.09,91.37 208.54,90.92 210.17,90.92 211.58,92.33 212.09,92.33 212.31,92.11 213.76,92.11 214,91.88 216.35,91.88 v2(216.47,91.75)
  BOTTOM w0.076: UC1.G2 138.46,86.33 139,86.33 139.16,86.17 140.27,86.17 140.46,86.37 141,86.37 v2(141.42,86.79)
FFS_INT2_Q: length 6
  TOP w0.102: v2(214.61,112.65) 214.61,112.32 214.41,112.13 QN1.3 213.5,111.72 RN1.2
  BOTTOM w0.102: v2(214.61,112.65) 214.65,112.61 JSATA1.19 214.65,111.1 214.45,110.9 213.58,110.9 213.07,110.39 v1(213.07,109.88)
FWP#: length 17
  TOP w0.102: v2(207.62,88.77) 208.12,88.27 UE2.B65 ; RE82.2 RE81.2 209.24,79.49 208.91,79.17 v1(208.36,79.17) v2(207.34,79.17)
  BOTTOM w0.102: v2(207.62,88.77) 207.18,88.34 207.18,84.66 207.65,84.19 208.52,84.19 208.79,83.93 208.79,79.72 208.24,79.17 v2(207.34,79.17)
GC6_EVENT#_Q: length 21.1
  TOP w0.089: 143.97,91.92 143.97,90.88 140.13,87.05 140.13,86.45 138.21,84.53 138.21,83.99 137.91,83.7 137.19,83.7 136.57,83.07 135.98,83.07 135.78,82.87 135.56,82.87 v2(135.16,82.47)
  TOP w0.102: 143.97,91.92 v1(143.97,92.93) 143.97,96.97 144.77,97.78 RPC15.4
  BOTTOM w0.089: v2(135.16,82.47) 135.53,82.1 UC1.R6
GFB: length 13
  TOP w0.152: PR532.2 96.41,96.96 95.33,96.96 93.49,95.11 91.35,95.11 90.27,96.19 v1(87.7,96.19) v2(87.19,96.7)
  BOTTOM w0.152: v2(87.19,96.7) 87.19,96.93 87.75,97.5 PU500.23
GPIO57: length 17.1
  TOP w0.076: 146.33,73.73 145.17,72.57 v2(144.97,72.57)
  TOP w0.102: RPC19.4 151.45,76.05 150.91,75.52 148.11,75.52 146.33,73.73
  BOTTOM w0.076: v2(144.97,72.57) 145.06,72.48 145.06,70.37 144.85,70.16 v1(144.43,70.16) 140.49,70.16 139.71,70.93 138.94,70.93 UC1.AP1
GPIO_PSID_SELECT: length 128
  TOP w0.102: UE1.A6 176.64,102.84 176.39,102.59 v1(175.83,102.59) 172.54,102.59 v2(172.26,102.88)
  TOP w0.254: PU1.6 68.66,119.83 v2(69.03,120.2)
  IN3 w0.122: v2(172.26,102.88) 172.26,104.86 171.24,105.87 171.24,108.07 169.78,109.53 163.26,109.53 161.67,111.12 161.67,112.66 161.37,112.97 161.37,114.95 161.96,115.55 161.96,116.29 159.41,118.84 152.57,118.84 151.93,118.2 147.6,118.2 147.31,118.49 145.44,118.49 142.11,115.16 128.5,115.16 126.9,113.55 118.32,113.55 115.82,116.05 108.4,116.05 105.57,118.88 83.5,118.88 82.09,120.29 69.12,120.29 v2(69.03,120.2)
GPU_GC6_FB_EN: length 14.3
  TOP w0.089: v2(135.68,84.63) 136.3,85.25 136.3,86.01 136.87,86.58 137.76,86.58 139.95,88.77 139.95,89.09 v1(140.53,89.67) 141.47,90.61 141.47,91.92
  TOP w0.102: RPC16.5 141.56,94.52 141.47,94.43 141.47,91.92
  BOTTOM w0.089: v2(135.68,84.63) 135.53,84.48 UC1.L6
GPU_SMBCLK: length 22.6
  TOP w0.102: v2(215.78,90.86) 215.51,90.59 RPE3.4 ; UE2.B49 201.63,89 v2(201.69,89.06)
  IN4 w0.084: v2(215.78,90.86) 216.03,90.6 217.05,90.6 217.36,90.29 217.36,88.69 216.89,88.22 215.48,88.22 214.98,87.71 211.05,87.71 210.82,87.49 208.51,87.49 208.02,87.97 208.02,89.05 207.71,89.37 202.47,89.37 202.17,89.06 v2(201.69,89.06)
GPU_SMBDAT: length 21.8
  TOP w0.102: v2(202.05,89.55) 202,89.5 UE2.B48 ; RPE3.3 215.64,90.09 v2(215.78,90.22)
  IN4 w0.084: v2(202.05,89.55) 207.78,89.55 208.21,89.13 208.21,88.05 208.58,87.67 210.74,87.67 210.97,87.9 214.9,87.9 215.4,88.4 216.81,88.4 217.17,88.76 217.17,90.21 216.97,90.41 215.97,90.41 v2(215.78,90.22)
GREEN_DOCK: length 29.3
  TOP w0.102: v2(156.78,126.86) v1(157.25,127.33) 157.33,127.41 RV77.1
  IN2 w0.122: v2(146.92,111.45) 147.17,111.45 148.72,112.99 148.72,115.75 150.08,117.11 150.08,117.19 151.89,119 151.89,125.96 152.73,126.81 153.38,126.81 154.43,127.86 156.57,127.86 156.88,127.54 156.88,126.96 v2(156.78,126.86)
  BOTTOM w0.102: v2(156.78,126.86) 157.25,127.33 JDOCK1.59 ; UV8.M7 147.89,112.06 147.27,111.45 v2(146.92,111.45)
H_CATERR#: length 17.6
  TOP w0.076: 97.72,84.55 v2(98.12,84.94)
  TOP w0.109: 97.72,84.55 97.56,84.38 94.06,84.38 91.27,81.59 v1(90.39,81.59) 87.97,81.59 v2(87.21,80.83)
  BOTTOM w0.076: v2(98.12,84.94) 98.25,84.81 98.27,84.81 98.54,84.54 99.7,84.54 99.95,84.29 100.31,84.29 100.48,84.46 100.48,84.64 100.72,84.87 101.24,84.87 UC1.K61
  BOTTOM w0.102: RC114.2 86.96,81.07 v2(87.21,80.83)
H_CPU_SVIDALRT#: length 8.1
  BOTTOM w0.076: 95.29,83.62 95.81,83.62 96.23,84.05 99.5,84.05 100,83.54 100.31,83.54 100.6,83.83 UC1.L62
  BOTTOM w0.102: 95.29,83.62 v1(95.1,83.62) RC207.1
H_CPUPWRGD: length 92.3
  TOP w0.102: v2(60.45,42.87) 60.54,42.79 v1(62.36,42.79) 64.09,42.79 RC103.1 ; CC83.1 RC123.1
  TOP w0.109: CC83.1 93.8,92.95 96.13,90.63 v2(96.46,90.63)
  IN1 w0.084: v2(96.46,90.63) 92.46,90.63 92.18,90.35 92.18,88.99 88.84,85.64 82.04,85.64 81.22,84.83 81.22,82.22 80.33,81.33 77.73,81.33 75,78.61 69.03,78.61 58.14,67.72 58.14,49.68 58.27,49.55 58.27,45.83 60.45,43.65 v2(60.45,42.87)
  BOTTOM w0.076: 97.45,90.69 101.56,90.69 101.76,90.49 101.76,90.13 101.83,90.06 101.83,89.47 101.81,89.45 UC1.C61
  BOTTOM w0.102: 97.45,90.69 96.52,90.69 v2(96.46,90.63)
H_PROCHOT#: length 289.7
  TOP w0.102: UE2.A46 199.84,89.25 199.73,89.14 199.39,89.14 198.8,88.55 198.8,88.15 v2(198.64,88) ; v2(83.15,100.32) 83.24,100.32 PC514.2 CC20.1
  IN1 w0.084: v2(79,80.15) 77.81,80.15 74.49,76.83 70.71,76.83 63.79,69.91 63.79,67.13 63.66,67 63.66,60.57 62.71,59.61 62.71,59.38 58.85,55.51 58.85,50.16 59.03,49.97 59.03,49.45 58.95,49.36 58.95,47.79 59.88,46.85 59.88,45.17 60.43,44.63 60.77,44.63 61.03,44.38 61.03,42.79 60.65,42.41 56.6,42.41 55.07,43.93 54.17,43.93 53.81,43.57 53.81,41.11 49.46,36.76 42.68,36.76 v2(41.34,35.42)
  BOTTOM w0.102: PR717.1 39.69,37.07 v2(41.34,35.42) ; v2(198.64,88) 198.64,87.9 200.04,86.5 200.04,83.11 200.28,82.87 200.28,80.43 200.04,80.19 200.04,79.38 200.24,79.18 200.24,78.13 200.76,77.61 200.76,67.6 198.83,65.68 198.09,65.68 197.3,64.88 197.3,62.27 193.82,58.79 189.9,58.79 187.96,56.85 171.73,56.85 166.2,51.32 159.8,51.32 155.14,46.66 83.37,46.66 78.32,51.71 78.32,75.72 RC116.2 RC121.1 78.98,80.14 v2(79,80.15) 81.03,82.19 81.03,85.04 82.92,86.93 82.92,95.3 81.96,96.27 81.96,99.83 PR534.1 82.45,100.32 v2(83.15,100.32)
H_PROCHOT#_R: length 23.7
  IN1 w0.084: v2(98.74,84.97) 98.74,84.84 97.52,83.62 96.25,83.62 95.87,83.24 93.12,83.24 91.73,81.85 85.93,81.85 81.48,77.39 v2(80.63,77.39)
  BOTTOM w0.076: v2(98.74,84.97) 99.07,84.97 99.33,84.71 100.06,84.71 UC1.K63
  BOTTOM w0.102: v2(80.63,77.39) 80.62,77.39 80.63,77.4 RC121.2
H_THERMTRIP#: length 215.4
  TOP w0.102: QE4.3 198,98.84 195.82,98.84 194.31,97.33 194.31,91.88 195.07,91.11 195.07,89.59 195.84,88.83 195.84,86.86 v1(197.39,85.31) 197.96,84.74 v2(198.92,84.74)
  BOTTOM w0.102: v2(198.92,84.74) 198.8,84.61 198.8,81.02 198.85,80.97 198.85,77.64 199.65,76.84 199.65,68.07 198.37,66.79 197.56,66.79 196.18,65.41 196.18,62.86 194.22,60.9 191.52,60.9 190.82,60.2 189.25,60.2 187.02,57.98 171.28,57.98 165.74,52.44 159.34,52.44 154.68,47.78 83.83,47.78 79.44,52.17 79.44,72.32 85.79,78.67 85.79,82.95 87.48,84.64 89.58,84.64 92.14,87.2 92.14,89.23 RC161.1 92.38,90.57 92.38,91.37 RC25.2
H_THERMTRIP#_R: length 8.9
  BOTTOM w0.076: UC1.D60 101.96,88.46 101.22,89.21 100.39,89.21 100.33,89.28 97.77,89.28 97.57,89.48
  BOTTOM w0.102: 97.57,89.48 97.45,89.59 v1(97.04,89.59) 94.27,89.59 RC161.2
H_VCCST_PWRGD: length 97.7
  TOP w0.102: v2(59.95,43.3) v1(60.89,43.3) 63.55,43.3 RC102.1
  TOP w0.109: v2(74.81,79.19) 75.23,79.62 76.94,79.62 77.3,79.98 UC8.4 77.3,81.32 77.66,81.69 RC202.1
  IN1 w0.084: v2(59.95,43.3) 59.95,43.86 57.43,46.38 57.43,48.5 57.93,49.01 57.93,67.83 69.3,79.19 v2(74.81,79.19) 75.29,79.19 77.64,81.54 80.24,81.54 81.01,82.31 81.01,88.2 86.5,93.7 95.91,93.7 v2(96.52,93.08)
  BOTTOM w0.076: 100.11,91.83 101.39,91.83 102.59,90.64 102.59,90.13 102.92,89.8 UC1.B59
  BOTTOM w0.102: CC24.1 95.67,93.93 v2(96.52,93.08) 97.98,93.08 99.23,91.83 100.11,91.83
H_VCCST_PWRGD_XDP: length 12.7
  TOP w0.102: RC102.2 RC103.2 64.89,44.14 65.01,44.01 65.01,43.37 65.13,43.26 65.29,43.26 65.42,43.39 65.42,44.73 65.29,44.86 63.31,44.86 63.15,44.7 63.15,44.19 63.01,44.05 62.85,44.05 62.77,44.14 v1(62.77,44.72) 62.77,45.09 63.1,45.42 65.61,45.42 65.75,45.56 JXDP1.39
H_VR_EN: length 237.1
  TOP w0.089: 100.06,91.66 100.06,89 v2(101.8,87.25)
  TOP w0.102: v2(100.07,92.45) 100.06,92.44 100.06,91.66 ; RE284.1 199.74,102.73 199.74,101.36 v2(199.05,100.68)
  TOP w0.254: PR536.1 90.39,104.4 90.63,104.64 v1(91.06,104.64) v2(91.54,104.16)
  IN2 w0.122: v2(95.56,97.7) 95.56,99.55 93.61,101.49 93.61,102.09 v2(91.54,104.16) ; v2(185.68,46.46) 186.78,46.46 189.62,49.3 196.56,49.3 196.93,49.66 196.93,55.46 197.95,56.49 198.21,56.49 200.15,58.42 200.15,58.79 200.76,59.41 200.76,65.76 200.46,66.05 200.46,69.92 198.81,71.57 198.19,71.57 197.6,72.16 197.6,74.81 199.07,76.28 199.07,79.66 196.13,82.61 196.13,88.38 196.73,88.98 196.73,95.8 197.94,97.02 197.94,98.58 199.05,99.69 v2(199.05,100.68)
  IN3 w0.122: v2(185.68,46.46) 185.3,46.84 142.99,46.84 140.8,49.03 105.65,49.03 93.45,61.23 93.45,73.26 v2(92.98,73.73) ; v2(89.65,76.75) 89.65,79.34 90.9,80.58 90.9,84.92 93.52,87.54 93.52,95.66 v2(95.56,97.7)
  BOTTOM w0.076: UC1.F60 102.14,86.91 101.8,87.24 v2(101.8,87.25)
  BOTTOM w0.102: v2(92.98,73.73) 92.67,73.73 v2(89.65,76.75) ; v2(100.07,92.45) 99.27,92.45 95.33,96.38 RC201.2 94.76,96.9 v2(95.56,97.7)
H_VR_READY: length 29.2
  TOP w0.254: v2(88.81,104.96) 88.71,104.85 PR539.2
  IN1 w0.084: v2(88.81,104.96) 92.03,104.96 94.87,102.12 94.87,98.1 v2(93.09,96.32)
  BOTTOM w0.076: 97.45,91.42 101.57,91.42 102.42,90.57 102.42,89.84 102.62,89.64 102.62,89.49 102.79,89.33 102.79,89.09 UC1.C59
  BOTTOM w0.102: v2(93.09,96.32) 93.16,96.38 RC201.1 93.84,95.53 RC199.2 93.8,94.61 v1(95.18,93.23) 96.99,91.42 97.45,91.42
HDD_DET#: length 118.5
  TOP w0.102: v2(140.95,81.4) 141.35,80.99 145.31,80.99 145.56,80.75 147.74,80.75 148.41,81.42 150.91,81.42 151.43,81.94 RPC18.8 ; v2(217.24,99.03) v1(217.24,98.52)
  IN3 w0.089: v2(140.95,81.4) 140.95,81.45 142.32,82.82 145.4,82.82 146.46,83.88
  IN3 w0.122: 146.46,83.88 147.95,85.38 155.24,85.38 158.88,89.01 158.88,92.88 161.63,95.64 172.17,95.64 173.06,96.53 174.05,96.53 174.9,97.38 176.64,97.38 177.91,96.12 183.14,96.12 183.14,96.12 184.17,96.12 184.36,95.92 189.18,95.92 190.56,97.3 191.71,97.3 192.47,98.06 195.56,101.15 203.21,101.15 203.54,101.49 204.91,101.49 205.35,101.04 205.35,100.5 205.95,99.9 208.26,99.9 208.94,99.21 209.77,99.21 211.01,97.98 216.18,97.98 v2(217.24,99.03)
  BOTTOM w0.089: UC1.U1 139,80.8 139.2,80.99 140.54,80.99 v2(140.95,81.4)
  BOTTOM w0.102: v2(217.24,99.03) 216.83,99.44 216.83,101.5 218.25,102.92 218.25,109.66 217.65,110.26 217.65,111.72 JSATA1.13
HDD_DEVSLP: length 104.7
  IN3 w0.122: v2(217.24,99.62) 217.04,99.42 215.3,99.42 214.74,98.86 211.37,98.86 210.14,100.1 209.31,100.1 207.83,101.58 206.73,101.58 206.57,101.74 203.25,101.74 202.94,102.04 198.79,102.04 198.15,101.4 195.46,101.4 192.37,98.31 191.22,98.31 189.77,96.86 186.38,96.86 186.13,96.61 178.11,96.61 176.85,97.88 174.69,97.88 173.84,97.03 172.85,97.03 171.96,96.14 161.43,96.14 158.38,93.09 158.38,89.22 155.03,85.87 144.64,85.87 v2(143.73,84.97)
  BOTTOM w0.089: UC1.L2 138.51,84.14 139.66,84.14 140.05,84.53 142.4,84.53 142.49,84.45 143.21,84.45 v2(143.73,84.97)
  BOTTOM w0.102: v2(217.24,99.62) 217.24,100.57 218.62,101.95 218.62,106.57 v1(219.14,107.09) 219.14,108.64 218.77,109.01 RN5.2 218.77,110.8 218.65,110.92 218.65,111.72 JSATA1.11
HDD_FALL_INT: length 121.2
  TOP w0.102: RPC18.5 151.44,83.44 150.83,84.05 148.99,84.05 146.38,86.66 144.7,86.66 144.16,86.12 144.16,84.83 143.87,84.53 139.99,84.53 139.38,83.92 138.65,83.92 137.92,83.19 137.69,83.19 v2(137.17,82.67) ; UN1.11 v1(218.98,116.36) 218.28,116.36 v2(218.13,116.51)
  IN4 w0.084: v2(218.13,116.51) 218.13,114.86 217.43,114.16 217.43,112.9 216.21,111.69 214.25,111.69 211.12,108.55 206.69,108.55 205.51,107.37 200.98,107.37 199.89,106.28 196.27,106.28 194.74,107.81 192.53,107.81 191.96,108.39 188.15,108.39 187.33,109.21 177.62,109.21 174.53,106.12 173.43,106.12 170.89,103.57 170.89,102.3 156.59,88 155.34,88 151.8,84.47 147.55,84.47 146.9,83.81 139.96,83.81 139.26,83.11 137.35,83.11 137.17,82.93 v2(137.17,82.67)
  BOTTOM w0.076: UC1.N4 136.87,82.97 v2(137.17,82.67)
HDMI_CEC: length 11.3
  BOTTOM w0.102: JHDMI1.13 91.35,131.46 86.1,131.46 85.79,131.16 85.79,129.53 86.68,128.64 RV8.1 v1(87.84,127.89)
HDMI_CLK_AUX: length 46.5
  TOP w0.102: UV7.48 123.93,119.91 123.78,119.75 120.95,119.75 v2(120.74,119.55)
  IN3 w0.122: v2(92.12,128.77) 92.94,129.59 94.87,129.59 95.19,129.91 95.19,131.21 94.92,131.47 93.56,131.47 JHDMI1.15
  IN4 w0.084: v2(92.12,128.77) 92.12,128.59 94.53,126.18 106.56,126.18 110.3,122.44 116.64,122.44 118.98,120.1 120.72,120.1 120.93,119.89 120.93,119.74 v2(120.74,119.55)
  BOTTOM w0.102: v2(120.74,119.55) 120.08,119.55 v1(119.73,119.9) ; v2(92.12,128.77) 92.12,128.62 91.68,128.18 RV7.1
HDMI_DAT_AUX#: length 42
  TOP w0.102: v2(92.81,128.77) v1(92.81,129.39) ; UV7.47 124.33,119.79 124.07,119.53 121.3,119.53 v2(120.74,118.96)
  IN4 w0.084: v2(92.81,128.77) 92.81,128.19 94.62,126.39 106.65,126.39 110.39,122.65 116.73,122.65 119.07,120.31 120.81,120.31 121.14,119.98 121.14,119.36 v2(120.74,118.96)
  BOTTOM w0.102: RV9.1 92.81,128.07 v2(92.81,128.77) 92.81,129 93.46,129.64 JHDMI1.16
HDMI_HPD: length 38.8
  TOP w0.102: JHDMI1.19 95.3,132.07 96.42,130.95 96.42,128.36 96.8,127.98 96.8,126.81 v1(97.41,126.21) v2(98.16,125.45) ; UV7.17 121.53,113.99 120.88,114.65 v2(120.88,117.47)
  IN4 w0.084: v2(98.16,125.45) 98.68,125.97 106.48,125.97 110.22,122.23 116.12,122.23 v2(120.88,117.47)
HDMI_LANE_N0: length 46
  TOP w0.102: LV12.1 95.8,125.1 95.49,124.79 95.4,124.79 95.3,124.69 v4(95.3,124.29) 95.3,122.92 v2(95.67,122.55) ; v2(121.43,112.58) 121.93,113.08 UV7.18
  IN4 w0.091: v2(121.43,112.58) 121.85,112.99 121.85,113.23 115.54,119.54 109.64,119.54 108.17,121 101.33,121 101.07,121.26 101.07,122.8 100.88,123 100.46,123 100.37,122.9 100.37,121.09 100.14,120.86 99.65,120.86 99.42,121.09 99.42,122.9 99.33,123 98.91,123 98.82,122.9 98.82,121.47 98.59,121.24 98.11,121.24 97.88,121.47 97.88,122.9 97.79,123 97.37,123 97.28,122.9 97.28,122.2 97.05,121.97 96.56,121.97 96.33,122.2 96.33,122.9 96.24,123 95.62,123 95.48,122.85 95.48,122.74 v2(95.67,122.55)
HDMI_LANE_N1: length 46
  TOP w0.102: v2(88.43,122.55) 88.14,122.84 v4(88.14,124.26) 88.14,124.68 88.57,125.1 LV10.1 ; v2(122.85,112.57) 122.85,112.58 123.13,112.87 UV7.21
  IN4 w0.091: v2(88.43,122.55) 88.02,122.96 88.02,123.19 88.11,123.27 90.43,123.27 90.95,123.79 101.17,123.79 103.19,121.77 108.49,121.77 109.95,120.32 115.86,120.32 122.53,113.64 122.77,113.64 123.26,113.16 123.26,112.98 v2(122.85,112.57)
HDMI_LANE_N2: length 51.5
  TOP w0.102: v2(84.81,122.55) 84.44,122.92 84.44,123.57 84.63,123.76 84.63,123.94 84.64,123.96 84.64,124.49 84.63,124.5 84.63,124.79 84.95,125.1 LV6.1 ; v2(124.24,112.58) 124.43,112.76 124.43,112.89 124.33,112.99 UV7.24
  IN4 w0.091: v2(84.81,122.55) 84.4,122.96 84.4,123.07 84.85,123.52 86.69,123.52 87.73,124.56 101.49,124.56 103.51,122.54 108.81,122.54 110.25,121.11 116.15,121.11 122.79,114.47 123.26,114.47 124.63,113.1 124.63,112.97 v2(124.24,112.58)
HDMI_LANE_N3: length 51.3
  TOP w0.102: LV3.1 92.05,125.1 91.54,124.6 91.54,124.31 92.68,123.17 92.7,123.17 93.08,122.8 93.08,122.78 94.82,121.03 94.82,120.19 v2(95.19,119.83) ; v2(120.27,112.32) 120.59,112.65 120.59,112.75 120.73,112.89 UV7.15
  IN4 w0.091: v2(120.27,112.32) 120.66,112.72 120.66,112.93 120.3,113.29 120.17,113.29 119.61,112.73 119.29,112.73 119.04,112.98 119.04,113.3 119.6,113.86 119.6,113.99 119.41,114.18 119.28,114.18 118.76,113.67 118.44,113.67 118.19,113.91 118.19,114.24 118.71,114.75 118.71,114.88 118.52,115.07 118.39,115.07 117.85,114.54 117.58,114.54 117.28,114.83 117.28,115.1 117.82,115.64 117.82,115.77 117.62,115.97 117.5,115.97 116.96,115.43 116.68,115.43 116.39,115.72 116.39,116 116.93,116.53 116.93,116.66 116.73,116.86 116.6,116.86 116.07,116.32 115.79,116.32 115.5,116.61 115.5,116.89 116.04,117.43 116.04,117.55 115.12,118.47 113.78,118.47 113.69,118.38 113.69,117.86 113.49,117.67 113.08,117.67 112.88,117.86 112.88,118.38 112.79,118.47 108.99,118.47 107.5,119.96 96.07,119.96 95.84,120.19 95.84,121.24 95.71,121.36 95.07,121.36 94.94,121.24 94.94,120.07 v2(95.19,119.83)
HDMI_LANE_P0: length 46
  TOP w0.102: v2(122.02,112.58) 121.95,112.65 121.95,112.7 122.33,113.09 UV7.19 ; v2(95.09,122.55) 95.09,124.01 95.07,124.02 95.07,124.55 95.09,124.56 95.09,124.97 94.95,125.1 LV12.4
  IN4 w0.091: v2(122.02,112.58) 122.02,113.31 115.61,119.71 109.71,119.71 108.25,121.17 101.4,121.17 101.24,121.33 101.24,122.87 100.95,123.17 100.39,123.17 100.19,122.98 100.19,121.16 100.07,121.03 99.72,121.03 99.59,121.16 99.59,122.98 99.4,123.17 98.84,123.17 98.65,122.98 98.65,121.54 98.52,121.42 98.18,121.42 98.05,121.54 98.05,122.98 97.86,123.17 97.3,123.17 97.11,122.98 97.11,122.27 96.98,122.15 96.63,122.15 96.51,122.27 96.51,122.98 96.31,123.17 95.54,123.17 95.3,122.93 95.3,122.77 v2(95.09,122.55)
HDMI_LANE_P1: length 46
  TOP w0.102: UV7.22 123.53,112.98 123.33,112.78 123.33,112.66 v2(123.43,112.57) ; LV10.4 87.72,125.1 87.92,124.89 87.92,124.54 87.91,124.53 87.91,123.99 87.92,123.98 87.92,122.63 v2(87.85,122.55)
  IN4 w0.091: v2(87.85,122.55) 87.85,123.26 88.03,123.44 90.36,123.44 90.88,123.96 101.25,123.96 103.26,121.94 108.57,121.94 110.02,120.49 115.93,120.49 122.6,113.81 122.84,113.81 123.43,113.23 v2(123.43,112.57)
HDMI_LANE_P2: length 51.6
  TOP w0.102: v2(124.83,112.58) 124.64,112.76 124.64,112.89 124.73,112.99 UV7.25 ; LV6.4 84.1,125.1 84.41,124.79 v4(84.41,124.22) 84.41,123.85 84.23,123.66 v2(84.23,122.55)
  IN4 w0.091: v2(84.23,122.55) 84.23,123.14 84.78,123.7 86.62,123.7 87.66,124.74 101.57,124.74 103.58,122.72 108.89,122.72 110.32,121.29 116.22,121.29 122.86,114.65 123.33,114.65 124.81,113.17 124.81,112.6 v2(124.83,112.58)
HDMI_LANE_P3: length 51.3
  TOP w0.102: v2(94.6,119.83) 94.6,120.94 93.33,122.22 v4(92.73,122.82) 91.33,124.22 91.33,124.97 91.2,125.1 LV3.4 ; UV7.16 121.13,112.99 120.8,112.66 120.8,112.37 v2(120.85,112.32)
  IN4 w0.091: v2(120.85,112.32) 120.83,112.34 120.83,113 120.37,113.46 120.1,113.46 119.54,112.9 119.36,112.9 119.21,113.05 119.21,113.23 119.77,113.79 119.77,114.06 119.48,114.36 119.21,114.36 118.69,113.84 118.51,113.84 118.37,113.98 118.37,114.16 118.88,114.68 118.88,114.95 118.59,115.25 118.32,115.25 117.78,114.71 117.65,114.71 117.45,114.9 117.45,115.03 117.99,115.57 117.99,115.84 117.7,116.14 117.42,116.14 116.88,115.6 116.76,115.6 116.56,115.79 116.56,115.92 117.1,116.46 117.1,116.73 116.8,117.03 116.53,117.03 115.99,116.49 115.86,116.49 115.67,116.69 115.67,116.82 116.21,117.35 116.21,117.63 115.19,118.64 113.71,118.64 113.51,118.45 113.51,117.93 113.42,117.84 113.15,117.84 113.06,117.93 113.06,118.45 112.86,118.64 109.06,118.64 107.57,120.13 96.14,120.13 96.01,120.26 96.01,121.31 95.79,121.54 95,121.54 94.77,121.31 94.77,119.99 v2(94.6,119.83)
HOST_ALERT1_R_N: length 28
  TOP w0.102: v2(156.43,77.09) 156.43,76.9 157.19,76.14 157.19,75.85 v1(157.45,75.59) 158,75.03 RC179.2
  IN1 w0.084: v2(156.43,77.09) 155.36,77.09 155.23,77.22 154.31,77.22 153.93,77.6 153.18,77.6 151.16,75.58 148.03,75.58 147.12,74.67 144.03,74.67 143.47,75.23 140.28,75.23 139.29,76.22 136.99,76.22 136.76,76.45 136.76,76.91 136.41,77.26 136.18,77.26 v2(135.71,77.74)
  BOTTOM w0.089: UC1.AD6 135.53,77.56 v2(135.71,77.74)
HOST_DEBUG_TX: length 27.9
  TOP w0.102: v2(202.27,90.84) 201.86,91.25 201.51,91.25 201.26,91.5 UE2.B44 ; v2(192.34,91.05) 191.86,90.57 191.86,88.29 192.53,87.62 192.53,85.46 191.81,84.74 191.81,84.46 191.57,84.22 v1(188.7,84.22) 188.11,84.22 187.71,83.81 187.71,82.72 RE73.2 187.25,82.16 JDEG1.8
  IN1 w0.084: v2(202.27,90.84) 201.28,91.83 196.74,91.83 195.67,90.75 192.46,90.75 192.41,90.81 192.41,90.99 v2(192.34,91.05)
HSYNC_DOCK: length 34.7
  IN2 w0.122: v2(146.92,112.72) 146.18,113.45 146.18,113.99 146.68,114.49 147.08,114.49 147.77,115.18 147.77,117.65 146.25,119.17 146.25,120.59 146.69,121.02 146.69,124.68 150.06,128.06 150.48,128.06 152.96,130.54 155.67,130.54 158.47,127.74 158.47,127.24 v2(158.04,126.81)
  BOTTOM w0.102: UV8.M9 147.79,113.36 147.14,112.72 v2(146.92,112.72) ; JDOCK1.65 158.75,127.52 v2(158.04,126.81)
HW_GPS_DISABLE2#: length 5.6
  TOP w0.102: UE1.A35 188.6,98.84 189.19,98.25 190.48,98.25 DZ6.1 190.87,97.86 RE12.2 190.46,96.89 v1(189.91,96.33)
HW_GPS_DISABLE2#_R: length 80.4
  TOP w0.102: v2(192.36,91.68) 192.31,91.68 v1(190.32,93.67) 190.32,95.25 190.99,95.91 191.92,95.91 193.11,97.11 193.11,97.78 192.99,97.91 DZ6.2
  IN3 w0.122: v2(226.06,88.36) 224.75,88.36 222.32,90.8 216.61,90.8 215.98,91.43 214.81,91.43 214.62,91.24 210.84,91.24 209.89,90.29 208.34,90.29 207.77,90.86 203.9,90.86 203.14,91.62 201.23,91.62 200.97,91.89 192.56,91.89 v2(192.36,91.68)
  BOTTOM w0.102: v2(226.06,88.36) 226.06,87.99 226.62,87.43 226.62,79.52 227.55,78.6 227.55,76.34 221.29,70.08 216.27,70.08 213.93,67.75 211.67,67.75 210.45,66.52 JNGFF2.18
I2C1_SCL_VMM: length 24.8
  TOP w0.102: v2(159.19,103) 159,103.19 159,104.3 159.54,104.84 159.54,106.67 161.61,108.74 161.61,113.45 161.93,113.77 162.6,113.77 v2(162.8,113.57)
  BOTTOM w0.102: UV8.A2 156.02,108.51 156.25,108.51 157.65,107.11 157.65,106.36 158.99,105.02 158.99,103.2 v2(159.19,103) ; RPV2.2 162.58,116.87 162.43,116.72 162.28,116.72 162.08,116.53 162.08,115.96 162.13,115.91 162.13,113.99 162.35,113.77 162.6,113.77 v2(162.8,113.57)
I2C1_SDA_VMM: length 24.1
  TOP w0.102: v2(162.8,114.15) 162.63,113.97 161.84,113.97 161.41,113.54 161.41,108.83 159.34,106.75 159.34,104.93 158.8,104.39 158.8,103.19 v2(158.61,103)
  BOTTOM w0.102: UV8.A1 155.87,108.31 156.17,108.31 157.44,107.03 157.44,106.28 158.79,104.93 158.79,103.18 v2(158.61,103) ; v2(162.8,114.15) 162.63,113.97 162.43,113.97 162.33,114.07 162.33,115.99 162.28,116.04 162.28,116.44 162.36,116.52 162.47,116.52 162.61,116.37 RPV2.1
I2C_EN: length 2
  TOP w0.102: UI7.24 223.4,84.98 RI38.2
I2S_BCLK: length 2.6
  TOP w0.102: RA31.2 204.62,66.27 204.82,66.27 205.48,66.93 UA1.16
I2S_DO: length 2.2
  TOP w0.102: RA32.2 205.04,66.17 205.76,66.88 205.76,67.15 205.88,67.28 UA1.17
I2S_MCLK: length 3.1
  TOP w0.102: UA1.15 205.08,66.85 204.73,66.5 203.97,66.5 RA30.2
I_ADP: length 221.1
  TOP w0.102: UE2.A12 211.68,93.75 v2(211.78,93.65)
  IN2 w0.122: v2(211.78,93.65) 210.91,92.79 210.91,86.83 210.99,86.75 210.99,85.92 210.67,85.6 210.67,80.99 210.13,80.45 210.13,78.37 208.51,76.75 203.66,76.75 203.28,76.37 203.28,74.05 203.41,73.92 203.41,65.43 204.93,63.91 204.93,62.3 204.22,61.59 204.22,58.48 203.76,58.02 203.76,54.94 197.38,48.55 189.93,48.55 186.41,45.03 159.49,45.03 155.61,48.91 140.05,48.91 135.92,44.78 80.11,44.78 71.66,36.33 56.4,36.33 55.67,37.07 54.06,37.07 53.34,36.35 48.26,36.35 47.42,37.18 46.99,37.61 44.53,37.61 v2(43.93,38.21)
  BOTTOM w0.254: v2(43.93,38.21) v1(43.39,37.67) 42.42,37.67 PR716.1
I_BATT: length 211.1
  TOP w0.102: PR718.1 39.83,36.16 v2(39.83,34.15) ; v2(198.66,77.21) 198.69,77.21 v1(198,77.91) 197.17,77.91 196.59,78.49 196.59,81.06 198.26,82.73 200.46,82.73 RE64.2
  IN2 w0.122: v2(39.83,34.15) 41.21,34.15 44.3,37.24 46.83,37.24 48.36,35.71 71.79,35.71 76.08,40 192.52,40 195.54,43.02 v2(195.54,44.61) ; v2(198.66,77.21) 198.12,77.21 195.88,74.96 195.88,70.77 v2(195.71,70.6)
  IN4 w0.084: v2(195.54,44.61) 196.07,45.14 196.07,50.46 194.22,52.32 194.22,54.98 193.74,55.46 193.74,57.47 195.07,58.8 195.07,65.07 195.05,65.1 195.05,69.91 195.07,69.93 195.07,70.41 195.27,70.6 v2(195.71,70.6)
I_SYS: length 228.7
  TOP w0.102: v2(205.67,85.21) 205.9,85.43 206.02,85.43 206.11,85.53 206.11,85.98 205.87,86.23 UE2.A57 ; PR720.1 38.82,36.29 v1(38.82,35.4) v2(38.82,34.15)
  IN2 w0.122: v2(213.79,78.97) 212.71,77.89 211.15,77.89 208.85,75.59 208.43,75.59 207.6,74.76 207.6,74.75 207.2,74.35 205.55,74.35 205.11,73.9 205.11,65.19 205.96,64.34 205.96,63.11 206.73,62.33 206.73,58.17 206.18,57.61 206.18,56.3 200.74,50.86 200.74,50.04 196.15,45.46 196.15,43.1 192.67,39.62 76.06,39.62 71.77,35.33 48.08,35.33 46.55,36.86 44.45,36.86 41.24,33.65 39.33,33.65 v2(38.82,34.15)
  IN4 w0.084: v2(213.79,78.97) 213.79,78.91 213.36,78.48 206.14,78.48 205.86,78.76 205.86,79.28 206.5,79.93 206.5,84.38 v2(205.67,85.21)
ILIM_SEL: length 3.5
  TOP w0.102: v1(63.21,116.34) 62.51,117.03 RI13.1 62.07,117.38 61.15,118.3 UI3.4
ILMT_1.05V:
  vias: v1(190.12,65.37)
IMON: length 5.4
  TOP w0.102: PR501.2 93.42,98.47 v1(93.82,98.07)
  TOP w0.254: v2(92.14,99.35) 91.8,99.35 PC500.2 91.71,98.47 PR501.2
  BOTTOM w0.203: v2(92.14,99.35) 91.99,99.35 91.43,99.9 PU500.13
INT_SPK_L+: length 78.1
  TOP w0.102: v2(218.18,8.18) v1(218.18,7.32)
  IN4 w1.016: 219.64,8.19 221.68,8.19 222.68,9.2 222.68,15.01 219.78,17.92 219.78,37.96 210.17,47.57 210.17,52.42 210.45,52.71 210.45,53.64 212.61,55.79 212.61,57.17 210.89,58.89 210.89,60.73 210.21,61.41 210.21,65.59 208.85,66.95 208.85,68.11 209.27,68.53 209.27,73.51 208.18,74.6
  vias: v2(207.05,75.53) v2(207.05,74.94) v2(218.76,8.18)
INT_SPK_L-: length 75.7
  IN4 w1.016: 206.97,73.83 207.43,73.37 207.43,68.79 207.1,68.46 207.1,66.51 208.94,64.67 208.94,57.7 209.15,57.49 209.15,55.46 208.66,54.98 208.66,47.28 218.51,37.44 218.51,17.34 221.36,14.48 221.36,10.4 220.97,10.01 219.79,10.01
  BOTTOM w0.102: v1(219.64,13.35) 219.64,11.37 218.73,10.47 v2(218.73,9.86)
  vias: v2(206.47,75.46) v2(206.47,74.88) v2(218.15,9.86)
INT_SPK_R+: length 69.8
  TOP w0.102: v2(218.23,13.59) v1(218.23,14.7)
  IN4 w1.016: 204.52,73.84 203.76,73.08 203.76,66.24 205.5,64.5 205.5,62.77 205.83,62.44 205.83,57.22 206.12,56.93 206.12,40.81 208.16,38.78 212.84,38.78 215.92,35.71 215.92,14.52 216.82,13.62
  vias: v2(205.3,75.46) v2(205.3,74.88) v2(218.81,13.59)
INT_SPK_R-: length 71.4
  IN4 w1.016: 205.6,73.12 205.6,67.88 205.22,67.5 205.22,66.58 206.85,64.95 206.85,63.27 207.1,63.02 207.1,57.75 207.39,57.45 207.39,41.33 208.68,40.05 213.37,40.05 217.24,36.18 217.24,16.81 219.92,14.13 219.92,12.3
  BOTTOM w0.102: v2(218.18,12.14) 218.18,12.58 v1(217.34,13.41)
  vias: v2(205.88,75.46) v2(205.88,74.88) v2(218.76,12.14)
INT_SPKR_L+:
  vias: v3(227.02,7.48)
INT_SPKR_L-:
  vias: v3(227.8,9.83)
INT_SPKR_R+: length 10
  TOP w0.102: v1(220.49,14.98) 220.71,14.75 220.71,13.25
  IN4 w1.016: 231.54,8.56 231.03,8.56 226.09,13.5 225.35,13.5
  vias: v2(223.88,13.5) v2(224.48,13.49) v2(232.5,8.73) v2(232.5,8.14)
INT_SPKR_R-: length 11.6
  TOP w0.102: v2(224.46,11.04) 225.52,11.04 v1(225.78,10.77)
  IN4 w1.016: 225.39,11.03 226.15,11.03 230.2,6.98 233.48,6.98 233.78,7.28
  vias: v2(223.88,11.04) v2(233.81,8.75) v2(233.81,8.17)
INTRUDER#: length 37.1
  TOP w0.102: RC9.2 160.42,61.85 159.3,60.73 156.88,60.73 155.7,59.56 v1(153.22,59.56) 152.55,58.89 142.62,58.89 141.24,60.27 141.24,63.68 138.51,66.41 137.56,66.41 v2(137.01,65.87)
  BOTTOM w0.076: UC1.AU6 135.77,69.29 135.77,68.82 135.73,68.78 135.73,67.43 136.01,67.15 136.01,66.78 136.93,65.87 v2(137.01,65.87)
IO_LDOSEL: length 3
  TOP w0.102: UR1.18 v1(18.14,19.04) 17.79,19.04 17.6,18.85 RR6.2 RR8.1
IRQ_SERIRQ: length 97
  TOP w0.102: v2(137.19,81.18) 137.71,80.66 138.83,80.66 138.99,80.83 139.71,80.83 139.74,80.8 v1(140.53,80.8) 145.19,80.8 145.47,80.52 147.83,80.52 148.5,81.19 151.4,81.19 151.73,80.87 RPC17.5 ; v2(203.57,98.34) 203.57,98.05 203.87,97.75 UE2.A28 ; UE1.B21 179.94,97.38 180.08,97.51 v2(180.08,97.78)
  IN1 w0.084: v2(180.08,97.78) 179.63,98.22 179.63,98.74 180.79,99.9 184.79,99.9 185.12,99.56 190.27,99.56 190.55,99.28 202.81,99.28 203.57,98.52 v2(203.57,98.34)
  IN3 w0.122: v2(169.61,98.19) 170.78,99.36 175.03,99.36 175.68,100.01 176.88,100.01 178.04,98.84 179.38,98.84 179.61,98.62 179.61,98.07 179.9,97.78 v2(180.08,97.78)
  IN4 w0.084: v2(137.19,81.18) 137.6,81.59 138.09,81.59 138.55,81.13 139.7,81.13 140.02,80.82 145.92,80.82 147.09,81.98 147.29,81.98 149.14,83.83 152.06,83.83 155.41,87.18 156.66,87.18 167.67,98.19 v2(169.61,98.19)
  BOTTOM w0.076: UC1.T4 136.87,81.51 v2(137.19,81.18)
JTAG_CLK: length 37
  TOP w0.102: JDEG1.4 185.25,80.97 184.69,81.54 184.69,82.35 184.28,82.76 184.28,83.61 183.84,84.06 183.84,84.32 183.66,84.49 RPE7.3 182.9,84.49 182.76,84.64 182.76,86.34 183.81,87.39 ; 183.81,87.39 184.75,88.33 184.75,90.9 184.6,91.05 184.37,91.05 v2(184.19,90.86) ; 183.81,87.39 v1(183.81,87.39) ; UE2.B56 203.62,88.26 203.67,88.32 v2(203.68,88.32)
  IN1 w0.084: v2(203.68,88.32) 203.68,87.96 203.06,87.35 200.96,87.35 200.51,87.79 199.58,87.79 199.13,87.35 195.68,87.35 194.44,88.59 186.1,88.59 184.65,90.05 184.65,90.89 184.49,91.05 184.37,91.05 v2(184.19,90.86)
JTAG_RST#: length 16.1
  TOP w0.102: RE63.2 RE65.1 CE30.1 203.29,80.01 JTAG1.1 203.14,80.65 202.87,80.92 202.87,82.29 202.46,82.7 202.46,82.74 v2(202.29,82.92) 202.29,82.92 201.63,83.58 v1(201.63,83.75) ; v2(201.68,90) UE2.B47
  BOTTOM w0.102: v2(201.68,90) 201.28,89.61 201.28,88.31 202.71,86.89 202.71,84.52 201.97,83.79 201.97,83.24 v2(202.29,82.92)
JTAG_TDI: length 24.9
  TOP w0.102: UE2.A51 202.87,86.26 202.8,86.19 202.8,85.75 v2(202.3,85.26) ; JDEG1.2 184.25,80.99 183.77,81.48 v1(183.77,81.83) 183.77,82.23 v2(183.63,82.38) 183.29,82.71 183.29,83.45 RPE7.1
  IN3 w0.122: v2(183.63,82.38) 183.67,82.33 194.16,82.33 195.38,83.54 199.48,83.54 201.2,85.26 v2(202.3,85.26)
JTAG_TDO: length 38.7
  TOP w0.102: v2(184.19,91.45) 184.35,91.28 184.69,91.28 184.98,90.99 184.98,87.72 v1(183.4,86.15) 182.98,85.73 182.98,85.08 183.07,84.99 RPE7.4 183.71,84.99 184.06,84.64 184.06,84.15 184.51,83.71 184.51,82.88 184.91,82.47 184.91,81.72 185.75,80.88 JDEG1.5 ; v2(202.83,88.95) 203.24,88.55 203.24,87.98 203.12,87.85 UE2.B55
  IN1 w0.084: v2(202.83,88.95) 202.95,88.95 203.24,88.66 203.24,87.82 202.97,87.56 201.04,87.56 200.6,88 199.37,88 198.92,87.56 195.77,87.56 194.53,88.8 186.19,88.8 184.86,90.13 184.86,90.98 184.58,91.26 184.37,91.26 v2(184.19,91.45)
JTAG_TMS: length 27.6
  TOP w0.102: RPE7.2 183.58,83.99 183.89,83.68 183.89,83.11 v2(183.73,82.96) 184.38,82.31 184.38,81.19 184.75,80.81 JDEG1.3 ; v1(204.12,85.51) 203.99,85.51 v2(203.69,85.81) 203.87,85.98 UE2.A53
  IN3 w0.122: v2(203.69,85.81) 203.24,86.26 202.13,86.26 201.46,85.59 201.18,85.59 199.4,83.82 195.3,83.82 194.06,82.58 184.34,82.58 183.96,82.96 v2(183.73,82.96)
KB_DET#: length 84.8
  TOP w0.102: v2(142.67,69.02) 143.05,68.63 143.84,68.63 144.32,68.15 144.32,67.77 148.95,63.14 153.55,63.14 154.24,63.82 154.75,63.82 v2(154.82,63.76) 155.18,64.13 155.18,64.77 156.94,66.53 158.76,66.53 v1(160.39,68.15) RPC1.5 ; v2(198.38,53.14) 197.3,53.14 197.02,53.42 197.02,54.71 JKBTP1.1
  IN3 w0.122: v2(198.38,53.14) 192.88,53.14 192.05,52.31 189.55,52.31 188.92,52.95 173.8,52.95 171.22,55.53 161.74,55.53 160.38,56.89 158.33,56.89 156.97,58.24 156.97,61.6 v2(154.82,63.76)
  BOTTOM w0.076: v2(142.67,69.02) 141.88,69.8 140.35,69.8 139.56,70.6 138.68,70.6 138.49,70.4 138.49,70.21 138.29,70.01 137.77,70.01 UC1.AT3
LAN_ACTLED_YEL#: length 53.2
  TOP w0.102: QL1.6 209.93,124.47 209.93,125.28 210.19,125.53 v1(212.28,125.53) 218.85,125.53 v2(222.5,121.88)
  IN4 w0.084: v2(256.38,122.63) 255.29,122.63 254.38,121.73 250.51,121.73 249.87,122.36 246.74,122.36 246.52,122.13 241.51,122.13 240.78,121.41 222.98,121.41 v2(222.5,121.88)
  BOTTOM w0.102: v2(256.38,122.63) 256.38,123.59 256.61,123.82 RL14.1
LAN_ACTLED_YEL_R#: length 43.8
  IN2 w0.122: v2(259.48,123.82) 264.91,129.25 268.46,129.25 270.89,131.68 281.69,131.68 283.82,129.55 283.82,124.65 285.94,122.54 288.23,122.54 289.73,124.03 289.73,126.43 JLOM1.10
  BOTTOM w0.102: v2(259.48,123.82) RL14.2
LAN_DISABLE#_R: length 31.3
  TOP w0.102: v2(185.64,105.49) 185.94,105.79 UE1.B53 ; v2(205.74,108.32) RL5.2 RL7.2 206.63,107.92 206.31,108.23 206.31,109.48 RL9.1 206.95,111.05 206.95,111.05 UL1.3
  IN1 w0.084: v2(205.74,108.32) 205.4,107.98 197.12,107.98 195.69,109.4 188.96,109.4 v2(188.58,109.02)
  BOTTOM w0.102: v2(185.64,105.49) 185.64,106.33 186.87,107.56 186.87,108.44 187.33,108.89 188.45,108.89 v2(188.58,109.02) ; v2(205.74,108.32) v1(205.74,107.74)
LAN_SMBCLK: length 95.7
  TOP w0.102: v2(209.76,119.45) 209.35,119.04 UL1.28
  IN4 w0.084: v2(158.42,96.61) 158.66,96.37 158.66,96.03 158.98,95.71 159.85,95.71 160.84,96.71 160.84,100.7 162.06,101.91 163.52,101.91 165.22,103.62 165.22,106.01 177.25,118.03 181.88,118.03 182.7,117.21 187.4,117.21 190.4,120.22 206.68,120.22 208.1,118.79 208.97,118.79 209.22,119.04 209.22,119.35 209.32,119.45 v2(209.76,119.45)
  BOTTOM w0.102: RC30.1 154.46,72.53 154.38,72.53 154.26,72.53 154.07,72.73 154.07,84.57 158.61,89.11 158.61,96.42 v2(158.42,96.61)
LAN_SMBDATA: length 94.7
  TOP w0.102: UL1.31 208.15,119.12 v2(208.47,119.45)
  IN4 w0.084: v2(159.01,96.61) 158.85,96.45 158.85,96.11 159.06,95.9 159.77,95.9 160.66,96.79 160.66,100.78 161.98,102.1 163.44,102.1 165.04,103.69 165.04,106.08 177.17,118.21 181.96,118.21 182.77,117.4 187.32,117.4 190.33,120.4 206.76,120.4 208.18,118.98 208.89,118.98 209.03,119.12 209.03,119.35 208.93,119.45 v2(208.47,119.45)
  BOTTOM w0.102: RC32.1 154.46,72.74 154.35,72.74 154.27,72.81 154.27,84.48 158.82,89.03 158.82,96.42 v2(159.01,96.61)
LAN_TEST_EN: length 2.8
  TOP w0.102: UL1.30 208.55,118.75 v1(209.18,119.38) 209.36,119.56 209.36,119.65 210.04,120.32 RL12.1
LAN_TX0+: length 13.6
  TOP w0.089: v2(216.63,113.77) 216.26,113.77 215.81,113.33 214.33,113.33 214.28,113.27 214.14,113.27 213.61,112.74 212.29,112.74 211.99,113.04 UL1.13
  BOTTOM w0.089: v2(216.63,113.77) 217.22,113.77 218.51,115.06 218.51,115.82 218.89,116.2 218.89,117.72 220.04,118.87 220.04,119.23 RL21.1
LAN_TX0+L: length 1.9
  BOTTOM w0.089: RL21.2 219.97,121.44 219.97,121.71 219.72,121.96 UL4.2
LAN_TX0-: length 13.5
  TOP w0.089: UL1.14 212.04,113.44 212.42,113.06 213.48,113.06 214.01,113.59 214.15,113.59 214.2,113.64 v4(214.86,113.64) 215.68,113.64 216.13,114.09 216.36,114.09 v2(216.63,114.35)
  BOTTOM w0.089: RL22.1 219.34,119.6 219.73,119.22 219.73,119 218.57,117.85 218.57,116.33 218.19,115.95 218.19,115.19 217.09,114.09 216.89,114.09 v2(216.63,114.35)
LAN_TX0-L: length 2
  BOTTOM w0.089: UL4.3 219.22,122.01 219.65,121.58 219.65,121.34 219.31,121 RL22.2
LAN_TX1+: length 10.8
  TOP w0.089: v2(216.64,115.1) 216,115.1 215.55,114.65 v4(213.98,114.65) 212.66,114.65 212.62,114.68 211.89,114.68 211.85,114.64 UL1.17
  BOTTOM w0.089: RL23.1 217.81,119.48 217.81,118.5 217.39,118.09 217.39,115.59 217.02,115.22 216.76,115.22 v2(216.64,115.1)
LAN_TX1+L: length 1.7
  BOTTOM w0.089: UL4.6 217.72,122.06 217.63,121.97 217.63,121.39 RL23.2
LAN_TX1-: length 10.6
  TOP w0.089: UL1.18 211.91,115.04 211.95,115 212.75,115 212.79,114.96 215.42,114.96 215.87,115.41 216.37,115.41 v2(216.64,115.68)
  BOTTOM w0.089: RL24.1 217.49,118.91 217.49,118.63 217.08,118.22 217.08,115.72 216.89,115.54 216.79,115.54 v2(216.64,115.68)
LAN_TX1-L: length 1.8
  BOTTOM w0.089: UL4.7 217.22,122.07 217.31,121.97 217.31,121.61 RL24.2
LAN_TX2+: length 2.3
  TOP w0.089: UL1.20 212.05,115.84 212.09,115.88 212.79,115.88 212.98,116.07 213.05,116.07 RL25.1
LAN_TX2+L: length 8.3
  TOP w0.089: v2(216.14,121.72) 216.07,121.65 216.07,121.56 216.91,120.71 216.91,118.43 215.94,117.46 215.94,116.61 215.36,116.04 215.08,116.04 RL25.2
  BOTTOM w0.089: v2(216.14,121.72) 216.22,121.81 UL4.9
LAN_TX2-: length 2.4
  TOP w0.089: UL1.21 211.97,116.24 212.01,116.2 212.66,116.2 RL26.1
LAN_TX2-L: length 8.3
  TOP w0.089: RL26.2 214.8,116.46 214.91,116.35 215.23,116.35 215.62,116.75 215.62,117.59 v4(215.89,117.86) 216.59,118.56 216.59,120.58 215.75,121.42 215.75,121.52 v2(215.55,121.72)
  BOTTOM w0.089: UL4.10 215.72,121.89 v2(215.55,121.72)
LAN_TX3+: length 3.2
  TOP w0.089: RL27.1 213.07,118.48 212.73,118.48 212.59,118.34 212.59,117.61 212.07,117.08 211.83,117.08 211.79,117.04 UL1.23
LAN_TX3+L: length 5.6
  TOP w0.089: RL27.2 215.1,118.45 215.35,118.45 215.79,118.9 v4(215.79,119.74) 215.79,119.96 215.33,120.42 215.33,120.7 214.77,121.26 214.77,121.53 v2(214.97,121.72)
  BOTTOM w0.089: UL4.11 215.22,121.98 v2(214.97,121.72)
LAN_TX3-: length 3.3
  TOP w0.089: RL28.1 212.84,118.8 212.6,118.8 212.27,118.47 212.27,117.74 211.94,117.4 211.84,117.4 211.8,117.44 UL1.24
LAN_TX3-L: length 5.5
  TOP w0.089: v2(214.38,121.72) 214.45,121.65 214.45,121.13 215.01,120.57 215.01,120.29 215.48,119.83 215.48,119.03 215.22,118.77 214.86,118.77 214.8,118.83 RL28.2
  BOTTOM w0.089: UL4.12 214.72,122.06 v2(214.38,121.72)
LAN_WAKE#: length 146.4
  TOP w0.102: UE2.B27 205.12,95.69 204.79,95.37 204.6,95.37 v2(204.62,95.35) ; UL1.2 206.55,110.83 v2(206.39,110.67) ; RC153.1 157.12,71.79 v1(156.82,71.49) 156.56,71.22 156.02,71.22 154.49,72.76 154.42,72.76 153.31,73.86 149.15,73.86 146.46,71.17 146.46,70.64 145.95,70.13 139.33,70.13 137.85,71.62 136.61,71.62 v2(136.34,71.89)
  IN1 w0.084: v2(206.39,110.67) 202.89,110.67 v2(202.21,109.99)
  IN2 w0.122: v2(204.35,82.1) 204.35,82.92 203.86,83.4 203.86,84.47 204.16,84.76 204.16,86.54 205.2,87.59 205.2,89.47 204.62,90.05 v2(204.62,95.35)
  IN3 w0.089: 146.46,72.66 145.61,71.81 140.11,71.81 139.66,71.36 136.86,71.36 v2(136.34,71.89)
  IN3 w0.122: v2(204.35,82.1) 204.05,81.8 202.19,81.8 201.21,82.78 198.77,82.78 197.2,81.21 169.24,81.21 167.36,79.34 165.12,79.34 164.22,78.44 160.01,78.44 159.37,77.8 158.34,77.8 156.67,79.48 155.05,79.48 153.82,78.25 149.87,78.25 149.1,77.49 149.1,75.3 146.46,72.66
  BOTTOM w0.089: UC1.AN5 136.04,72.19 v2(136.34,71.89)
  BOTTOM w0.102: v2(202.21,109.99) 203,109.2 203,103.51 204.69,101.82 206.52,101.82 207.58,100.76 207.58,98.73 207.31,98.45 207.31,96.93 208,96.23 208,95.01 207.79,94.8 205.17,94.8 v2(204.62,95.35)
LANCLK_REQ#: length 97.1
  TOP w0.089: v2(143.88,79.63) 144.12,79.87 145.8,79.87 145.84,79.84 146.46,79.84
  TOP w0.102: 146.46,79.84 148.3,79.84 148.46,80 RPC9.6 ; v2(196.6,100.19) 197.23,100.83 197.23,103.11 v1(197.36,103.24) 197.79,103.67 199.32,103.67 200.07,104.42 200.9,104.42 203.53,107.05 203.53,109.43 RL4.1 204.47,110.37 204.47,112.55 204.96,113.04 UL1.48
  IN3 w0.089: 146.46,82.73 143.88,80.15 v2(143.88,79.63)
  IN3 w0.122: 146.46,82.73 148.29,84.56 155.47,84.56 159.62,88.7 159.62,91.75 162.52,94.64 172.58,94.64 173.35,95.42 174.32,95.42 176.25,93.49 180.14,93.49 180.55,93.08 181.17,93.08 181.17,93.08 184.83,93.08 185.46,93.71 188.79,93.71 189.64,94.56 189.64,94.97 190.98,96.3 193.16,96.3 196.6,99.74 v2(196.6,100.19)
  BOTTOM w0.076: v2(143.88,79.63) 144.32,79.19 144.32,77.34 144,77.02 138.85,77.02 UC1.AD1
LCD_CBL_DET#: length 103.9
  TOP w0.089: v2(142.42,84.97) 142.21,85.19 142.21,87.47 145.88,91.14 145.88,91.92
  TOP w0.102: v2(86.95,115.1) v1(86.95,115.81) ; RPC4.8 145.88,91.92
  IN2 w0.122: v2(86.95,115.1) 88.64,116.8 95.68,116.8 96.86,117.97 99.21,117.97 100.39,116.8 103.6,116.8 104.78,117.97 107,117.97 108.6,116.38 116.28,116.38 117.83,114.83 130.61,114.83 133.67,111.77 133.67,106.1 133.07,105.5 133.07,105.21 132.21,104.35 132.21,101.81 132.29,101.73 132.77,101.73 134.65,99.86 134.65,98.56 138.46,94.74 140.71,94.74 140.94,94.51 140.94,93.3 142.18,92.07 142.18,85.21 v2(142.42,84.97)
  BOTTOM w0.076: v2(142.42,84.97) 141.81,85.58 138.7,85.58 138.52,85.41 138.52,85.24 138.29,85 137.77,85 UC1.J3
  BOTTOM w0.102: v2(86.95,115.1) 86.97,115.12 JEDP1.40
LCD_TST: length 116.1
  TOP w0.102: UE1.A36 188.67,99.34 v2(189.33,98.68) 189.92,99.26 RE20.2
  IN3 w0.122: v2(189.33,98.68) 189.33,98.98 188.74,99.57 184.56,99.57 184.19,99.94 181.71,99.94 181.53,99.76 178.53,99.76 177.51,100.79 171.11,100.79 169.12,102.78 169.12,103.28 168.22,104.18 166.4,104.18 165.25,105.34 159.14,105.34 158.18,104.38 148.97,104.38 145.75,107.61 145.75,113.61 145.16,114.2 143.52,114.2 143.31,114.41 128.81,114.41 127.21,112.81 125.86,112.81 124.39,111.33 119.48,111.33 116.52,114.3 113.79,114.3 112.79,115.3 101.58,115.3 100.59,116.3 98.04,116.3 98,116.26 96.5,116.26 v2(95.33,115.09)
  BOTTOM w0.102: v2(95.33,115.09) v1(94.95,114.71) 94.85,114.61 94.08,114.61 93.51,115.19 92.73,115.19 92.47,115.45 JEDP1.29
LCD_VCC_TEST_EN: length 133.2
  TOP w0.102: v1(189.08,101.68) 189.08,101.57 v2(188.72,101.21) 188.59,101.34 UE1.A40 ; v2(74.36,119.79) 73.92,119.79 DV3.2
  IN3 w0.122: v2(74.36,119.79) 80.89,119.79 83.68,117.01 89.96,117.01 91.44,118.49 98.7,118.49 100.39,116.8 100.86,116.8 101.85,115.8 115.72,115.8 118.21,113.3 127,113.3 128.61,114.91 143.51,114.91 143.72,114.7 145.36,114.7 146.24,113.82 146.24,107.81 148.79,105.27 158.36,105.27 159.77,106.67 164.62,106.67 165.78,105.51 167.94,105.51 169.86,103.59 169.86,103.09 170.79,102.16 174.13,102.16 174.72,101.58 179.25,101.58 179.96,102.29 182.78,102.29 183.96,101.11 185.08,101.11 185.33,101.36 187.41,101.36 187.56,101.21 v2(188.72,101.21)
LED_10_GRN#: length 40.6
  TOP w0.102: v2(221.1,121.86) 221.1,121.94 220.8,122.24 220.09,122.24 QL2.6
  IN4 w0.084: v2(257.28,122.86) 256.63,122.21 255.17,122.21 254.46,121.5 250.43,121.5 249.78,122.15 246.83,122.15 246.6,121.92 241.82,121.92 241.09,121.2 221.51,121.2 221.1,121.6 v2(221.1,121.86)
  BOTTOM w0.102: v1(256.81,123.08) 257.03,122.86 v2(257.28,122.86) RL19.1
LED_10_GRN_R#: length 56
  TOP w0.102: v1(261.5,123.98) 260.38,122.86 v2(259.49,122.86)
  IN2 w0.122: v2(259.49,122.86) 265.63,129 268.57,129 270.99,131.43 281.59,131.43 283.58,129.44 283.58,124.54 285.83,122.29 297.33,122.29 299.08,124.03 299.08,126.43 JLOM1.11
  BOTTOM w0.102: v2(259.49,122.86) RL19.2
LED_100_ORG#: length 52
  TOP w0.102: QL1.3 208.94,122.81 v2(209.06,122.93)
  IN4 w0.084: v2(209.06,122.93) 209.63,122.36 211.01,122.36 212.14,121.22 215.7,121.22 215.94,120.99 241.18,120.99 241.9,121.71 246.69,121.71 246.92,121.94 249.7,121.94 250.35,121.29 254.55,121.29 255.26,122 257.19,122 v2(257.28,121.91)
  BOTTOM w0.102: RL20.1 v2(257.28,121.91) 257.03,121.91 v1(256.76,121.64)
LED_100_ORG_R#: length 56.3
  IN2 w0.122: JLOM1.13 301.37,126.43 301.37,124.03 299.32,121.99 285.78,121.99 283.33,124.44 283.33,129.34 281.49,131.18 271.1,131.18 268.67,128.76 266.33,128.76 v2(259.49,121.91)
  BOTTOM w0.102: v2(259.49,121.91) RL20.2
LED_SATA_DIAG_OUT#: length 39.7
  TOP w0.102: v2(171.73,102.59) 172.35,101.97 174.25,101.97 175.38,100.84 UE1.A10 ; v2(190.88,107.56) 190.69,107.75 190.69,110.48 191.2,110.99 194.21,110.99 194.52,111.3 194.52,113.61 195.33,114.42 v1(195.33,114.6) DZ4.1
  IN4 w0.084: v2(190.88,107.56) 190.19,106.86 187.45,106.86 186.95,106.35 177.1,106.35 175.4,104.65 172.86,104.65 171.73,103.52 v2(171.73,102.59)
LG_5V: length 4.6
  IN1 w1.016: 48.33,21.9 48.33,17.91 48.3,17.88
  BOTTOM w0.102: v2(48.05,23.69) v1(47.44,23.69)
  vias: v2(47.09,18.05) v2(47.09,17.44) v2(48.02,23.07)
LID_CL#: length 109.5
  TOP w0.102: v1(184.74,117.34) RE26.1 185.66,116.06 186.12,116.51 186.76,116.51 186.95,116.32 UZ10.2 186.95,115.12 v2(186.76,114.93) ; JIO1.18 220.7,67.7 222.92,67.7 223.64,68.42 v2(223.64,68.47)
  IN3 w0.122: v2(186.76,114.93) 186.76,114.53 187.07,114.21 191.79,114.21 194.07,116.49 203.62,116.49 204.5,117.37 212.43,117.37 212.87,116.93 214.65,116.93 216.97,119.25 221.26,119.25 221.45,119.06 222.96,119.06 223.55,119.65 225.73,119.65 228.11,117.27 228.11,115.68 226.87,114.44 226.87,91.52 228.73,89.66 228.73,80.56 228.97,80.32 228.97,68.81 v2(228.83,68.67)
  BOTTOM w0.102: v2(228.83,68.67) 225.38,68.67 225.21,68.51 223.7,68.51 223.64,68.44 v2(223.64,68.47)
LID_CL_SIO#: length 15.2
  TOP w0.102: CE8.1 184.06,112.61 v2(184.06,113.03) 184.06,113.69 v1(183.74,114.01) 183.74,115.1 RE25.2 RE26.2 ; v2(185.06,105.53) 185.11,105.53 185.44,105.86 UE1.B54
  BOTTOM w0.102: v2(184.06,113.03) 184.87,112.22 186.08,112.22 186.58,111.73 186.58,107.59 185.06,106.07 v2(185.06,105.53)
LOM_ACTLED_YEL#: length 6.3
  TOP w0.102: UL1.26 210.15,118.78 210.39,119.03 210.61,119.03 v2(211.03,119.45)
  BOTTOM w0.102: UL4.15 213.22,122.21 212.18,121.17 211.33,121.17 211.03,120.87 v1(211.03,120.01) v2(211.03,119.45)
LOM_SPD10LED_GRN#: length 18.4
  TOP w0.102: UL1.25 210.55,118.7 210.64,118.8 210.96,118.8 v2(211.61,119.45) 212.27,120.11 UL2.2
  IN4 w0.084: v2(211.61,119.45) 212.01,119.05 217.61,119.05 218.79,120.22 v2(221.94,120.22)
  BOTTOM w0.102: UL4.42 221.25,123.57 221.51,123.31 221.51,120.96 v1(221.74,120.74) 221.94,120.54 v2(221.94,120.22)
LOM_SPD100LED_ORG#: length 8.9
  TOP w0.102: UL1.27 209.75,118.85 210.35,119.45 v2(210.44,119.45) 210.87,119.88 211.52,119.88 211.62,119.98 UL2.1
  BOTTOM w0.102: UL4.16 212.72,122.04 212.09,121.4 211.2,121.4 210.44,120.64 v2(210.44,119.45) v1(210.44,118.71)
LP_CTL: length 6.9
  BOTTOM w0.102: UV8.B2 155.23,108.97 155.47,108.97 155.6,109.1 155.85,109.1 156.15,108.8 156.47,108.8 157.06,108.21 v1(158.1,108.21) 158.57,108.21 158.94,108.58 158.94,109.1 RV79.1 RV516.1
LPC_LAD0: length 103.6
  TOP w0.102: v2(202.5,98.28) 202.87,97.91 UE2.A30 ; UE1.A27 183.69,95.5 v2(183.39,95.2)
  IN1 w0.084: v2(202.5,98.28) 201.8,97.57 194.69,97.57 193.88,96.76 184.84,96.76 183.39,95.32 v2(183.39,95.2)
  IN4 w0.084: v2(134.41,63.63) 134.7,63.92 153.08,63.92 156.91,67.75 158.02,67.75 159.45,69.18 159.45,70.19 160.82,71.56 161.18,71.56 163.02,73.4 163.4,73.4 164.12,74.12 164.12,75.12 v2(164.25,75.25) 167.5,75.25 170.65,78.4 171.77,78.4 174.61,81.24 176.83,81.24 177.84,82.25 177.84,85.45 180.66,88.27 180.66,91.8 181.48,92.62 181.48,94.91 181.75,95.17 182.26,95.17 182.66,94.78 183.08,94.78 183.39,95.09 v2(183.39,95.2)
  BOTTOM w0.076: UC1.AU14 131.28,69.29 131.28,68.82 131.24,68.78 131.24,67.45 131.49,67.19 131.49,66.03 133.2,64.32 133.2,64.27 v1(133.75,63.73) 133.85,63.63 v2(134.41,63.63)
  BOTTOM w0.102: JLPDE1.3 161.05,76.91 161.08,76.94 162.02,76.94 162.55,76.41 163.1,76.41 v2(164.25,75.25)
LPC_LAD1: length 101.5
  TOP w0.102: v2(202.44,95.97) 202.44,96.01 202.62,96.19 UE2.B32 ; UE1.A26 183.19,95.74 182.79,95.34 v2(182.79,95.2) 182.79,94.87 v1(182.96,94.71)
  IN1 w0.084: v2(202.44,95.97) 201.47,96.94 198.14,96.94 197.62,96.42 196.16,96.42 195.64,96.94 194.52,96.94 193.74,96.15 188.16,96.15 187.97,95.97 184.45,95.97 183.79,95.31 183.79,94.97 183.6,94.78 183.22,94.78 v2(182.79,95.2)
  IN4 w0.084: v2(182.79,95.2) 182.52,95.47 180.72,95.47 180.38,95.13 180.38,94.28 180.08,93.98 180.08,90.78 177.53,88.24 177.53,86.78 176.44,85.68 176.44,82.35 175.9,81.81 174.37,81.81 171.55,78.99 168.94,78.99 167.95,78.01 167.11,78.01 165.25,76.15 163.9,76.15 v2(163.01,75.26) 163.01,74.93 163.12,74.82 163.12,74.2 162.93,74.01 161.57,74.01 160.84,73.27 159.28,73.27 157.83,71.82 157.83,71.21 156.77,70.16 156.53,70.16 155.94,69.57 155.94,67.59 152.86,64.51 135.03,64.51 134.88,64.66 134.1,64.66 133.33,65.44 v2(133.33,66)
  BOTTOM w0.076: UC1.AW12 131.99,67.99 131.99,66.28 132.26,66 v2(133.33,66)
  BOTTOM w0.102: JLPDE1.4 161.32,76.41 161.64,76.09 162.18,76.09 v2(163.01,75.26)
LPC_LAD2: length 100.4
  TOP w0.102: v2(201.92,98.28) 202.37,97.83 UE2.A31 ; UE1.B26 182.44,97.34 182.18,97.59 182.18,98.03 182.55,98.4 v2(182.67,98.4)
  IN1 w0.084: v2(182.67,98.4) 183.05,98.02 183.05,97.84 183.62,97.27 189.45,97.27 190.7,98.52 199.97,98.52 200.59,97.91 201.55,97.91 v2(201.92,98.28)
  IN4 w0.084: v2(182.67,98.4) 182.55,98.4 182.18,98.03 182.18,97.21 181.55,96.57 179.97,96.57 178.94,95.54 178.94,93.9 178.18,93.15 177.55,93.15 177.15,92.75 177.15,91.06 174.28,88.19 174.28,83.97 174.37,83.87 174.37,82.22 171.43,79.28 168.62,79.28 167.84,78.51 167.2,78.51 165.19,76.5 163.39,76.5 162.42,75.53 v2(162.42,75.26) 162.42,74.91 161.89,74.37 161.53,74.37 160.72,73.56 159.16,73.56 157.53,71.94 157.53,71.33 156.65,70.45 156.41,70.45 155.66,69.69 155.66,67.71 152.89,64.94 134.35,64.94 v2(134.23,65.06)
  BOTTOM w0.076: v2(134.23,65.06) v1(133.16,65.06) 132.97,65.06 131.82,66.21 131.82,67.51 UC1.AY12
  BOTTOM w0.102: JLPDE1.5 161.39,75.91 161.51,75.78 161.9,75.78 v2(162.42,75.26)
