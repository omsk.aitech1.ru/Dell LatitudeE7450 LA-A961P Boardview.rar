# Allegro board LAA961PR10-1007A.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_A_D28: length 72.3
  IN1 w0.084: v2(62.55,29.05) 62.95,29.45 62.95,31.02 63.42,31.5 63.42,31.97 63.51,32.06 63.78,32.06 63.88,32.16 63.88,32.45 63.78,32.55 63.51,32.55 63.42,32.63 63.42,32.95 63.51,33.04 63.87,33.04 63.97,33.14 63.97,33.43 63.87,33.53 63.51,33.53 63.42,33.61 63.42,33.93 63.51,34.02 64.34,34.02 64.44,34.12 64.44,36.19 67.49,39.24 67.49,40.03 75.93,48.47 76.35,48.47 81.36,53.47 81.36,54.76 86.77,60.17 90.31,60.17 95.4,65.27 96.26,65.27 100.51,69.51 103.55,69.51 104.3,70.26 104.3,72.46 v2(104.86,73.02)
  BOTTOM w0.089: UC1.AL55 105.19,73.35 v2(104.86,73.02)
  BOTTOM w0.102: JDIMM1.23 63.75,32.14 63.75,30.25 v2(62.55,29.05)
DDR_A_D29: length 73.2
  IN1 w0.084: v2(104.81,73.67) 104.81,74.1 104.69,74.22 103.57,74.22 103.44,74.1 103.44,70.24 102.89,69.68 100.24,69.68 96.13,65.58 95.27,65.58 90.18,60.48 86.64,60.48 81.05,54.89 81.05,53.6 76.22,48.78 75.8,48.78 67.12,40.1 67.12,39.42 66.95,39.25 66.73,39.25 66.54,39.45 66.46,39.45 66.23,39.22 66.23,39.1 66.43,38.91 66.43,38.62 64.12,36.32 64.12,35.44 64,35.31 62.87,35.31 62.74,35.18 62.74,34.95 62.87,34.82 64,34.82 64.12,34.69 64.12,34.46 64,34.33 63.24,34.33 63.11,34.2 63.11,31.63 62.98,31.5 62.68,31.5 62.55,31.37 v2(62.55,30.57)
  BOTTOM w0.076: v2(104.81,73.67) 105.14,74 UC1.AK55
  BOTTOM w0.102: JDIMM1.21 63.15,32.14 63.15,30.7 63.02,30.57 v2(62.55,30.57)
DDR_A_D30: length 70.1
  IN1 w0.084: v2(105.82,70.42) 105.82,70.22 104.2,68.6 103.13,68.6 102.54,68.01 101.93,68.01 99.63,65.71 99.63,65.51 97.37,63.25 96.2,63.25 90.89,57.94 88.64,57.94 78.3,47.6 78.3,47.48 78.36,47.42 78.36,47.3 78.13,47.07 78.01,47.07 77.95,47.13 77.83,47.13 77.61,46.91 77.61,46.79 77.67,46.73 77.67,46.61 77.44,46.38 77.32,46.38 77.26,46.44 77.14,46.44 77.07,46.37 76.68,46.37 75.64,45.33 75.64,45.33 75.64,44.58 71.87,40.82 71.76,40.82 71.51,41.06 71.37,41.06 71.17,40.86 71.17,40.71 71.41,40.47 71.41,40.35 66.63,35.57 66.63,33.32 66.43,33.12 66.43,31.69 65.43,30.69 65.43,28.31 65.55,28.18 65.83,28.18 65.96,28.31 65.96,30.45 66.08,30.57 v2(66.36,30.57)
  BOTTOM w0.089: UC1.AR54 106.14,70.75 v2(105.82,70.42)
  BOTTOM w0.102: JDIMM1.33 66.75,32.14 66.75,31.08 66.92,30.92 66.92,30.32 66.79,30.2 66.48,30.2 66.36,30.32 v2(66.36,30.57)
DDR_A_D31: length 71.9
  IN1 w0.084: v2(105.82,71.72) 106.1,71.72 106.21,71.62 106.21,71.09 106.31,70.99 106.7,70.99 106.81,70.89 106.81,69.98 106.7,69.88 106.46,69.88 106.19,70.14 106.08,70.14 105.85,69.92 105.85,69.8 106.37,69.28 106.37,69.13 106.02,68.79 105.87,68.79 105.33,69.33 105.26,69.33 104.36,68.43 103.21,68.43 102.62,67.84 102.11,67.84 101.32,67.05 101.32,66.93 101.42,66.83 101.42,66.71 101.19,66.48 101.07,66.48 100.97,66.58 100.85,66.58 100.62,66.35 100.62,66.23 100.72,66.13 100.72,66.01 100.49,65.79 100.38,65.79 100.28,65.89 100.16,65.89 99.8,65.53 99.8,65.15 97.52,62.87 96.26,62.87 90.92,57.53 88.68,57.53 83.43,52.29 83.43,51.93 82.96,51.46 82.84,51.46 82.82,51.48 82.7,51.48 82.48,51.25 82.48,51.13 82.49,51.11 82.49,51 82.27,50.77 82.15,50.77 82.13,50.79 82.01,50.79 81.78,50.56 81.78,50.44 81.8,50.42 81.8,50.3 81.57,50.07 81.45,50.07 81.44,50.09 81.32,50.09 81.09,49.86 81.09,49.75 81.11,49.73 81.11,49.61 80.88,49.38 80.76,49.38 80.74,49.4 80.62,49.4 80.4,49.17 80.4,49.05 80.41,49.03 80.41,48.91 80.19,48.69 80.07,48.69 80.05,48.71 79.93,48.71 79.7,48.48 79.7,48.36 79.72,48.34 79.72,48.22 79.49,47.99 79.37,47.99 79.35,48.01 79.24,48.01 79.01,47.78 79.01,47.67 79.03,47.65 79.03,47.53 66.95,35.45 66.95,33.2 66.75,33 66.75,29.14 66.67,29.05 v2(66.36,29.05)
  BOTTOM w0.089: UC1.AN54 106.14,72.05 v2(105.82,71.72)
  BOTTOM w0.102: JDIMM1.35 67.35,32.14 67.35,30.04 v2(66.36,29.05)
DDR_A_D32: length 53.8
  IN4 w0.084: v2(109.61,25.5) 108.49,25.5 108.39,25.6 108.39,31.11 106.65,32.85 106.65,33.82 100.42,40.05 100.42,40.8 96.25,44.97 96.25,60.07 99.16,62.98 99.16,63.96 101.23,66.03 v2(101.76,66.03)
  BOTTOM w0.076: v2(101.76,66.03) 102.46,66.03 103.26,66.83 103.26,67.52 UC1.AY58
  BOTTOM w0.102: v2(109.61,25.5) 109.05,24.94 JDIMM1.166
DDR_A_D33: length 54.8
  IN4 w0.084: v2(107.68,29.05) 107.79,28.93 107.96,28.93 108.07,29.05 108.07,30.98 106.34,32.72 106.34,33.69 99.84,40.18 99.84,40.3 100.08,40.55 100.08,40.69 99.88,40.89 99.74,40.89 99.49,40.65 99.37,40.65 99.15,40.88 99.15,41 99.39,41.24 99.39,41.38 99.19,41.59 99.04,41.59 98.8,41.34 98.68,41.34 98.45,41.57 98.45,41.69 98.7,41.93 98.7,42.08 98.49,42.28 98.35,42.28 98.11,42.04 97.99,42.04 97.76,42.26 97.76,42.38 98,42.63 98,42.77 95.93,44.84 95.93,60.2 98.99,63.25 98.99,64.03 101.43,66.48 v2(102.35,66.48)
  BOTTOM w0.076: v2(102.35,66.48) 102.38,66.44 102.53,66.44 103.09,67.01 103.09,67.99 UC1.AW58
  BOTTOM w0.102: v2(107.68,29.05) 108.75,30.12 108.75,32.14 JDIMM1.165
DDR_A_D34: length 54.6
  IN4 w0.084: v2(103.54,65.77) 103.54,64.72 100.05,61.22 100.05,60.55 98.55,59.04 98.55,45.92 102.72,41.75 102.72,41 109.15,34.57 109.15,33.6 111.41,31.34 111.41,30.15 111.51,30.05 112.12,30.05 112.22,29.94 112.22,29.66 112.12,29.56 111.51,29.56 111.41,29.45 111.41,28.2 111.54,28.07 111.8,28.07 111.93,28.2 111.93,28.95 112.03,29.05 v2(112.62,29.05)
  BOTTOM w0.076: UC1.AY56 104.73,67.46 104.71,67.44 104.71,66.45 104.03,65.77 v2(103.54,65.77)
  BOTTOM w0.102: v2(112.62,29.05) 111.75,29.92 JDIMM1.175
DDR_A_D35: length 55.3
  IN4 w0.084: v2(111.13,25.5) 112.12,25.5 112.31,25.69 112.31,27.25 112.15,27.42 111.2,27.42 111.1,27.52 111.1,31.21 108.84,33.47 108.84,34.44 102.41,40.87 102.41,41.62 98.24,45.79 98.24,59.17 99.74,60.68 99.74,61.16 102.68,64.09 v2(102.68,64.9)
  BOTTOM w0.076: v2(102.68,64.9) 103.4,64.9 104.87,66.38 104.87,67.37 105.02,67.51 105.02,67.76 104.73,68.05 UC1.AW56
  BOTTOM w0.102: v2(111.13,25.5) 111.45,25.18 JDIMM1.174
DDR_A_D36: length 55
  IN4 w0.084: v2(102.08,67.04) 101.58,67.04 98.72,64.19 98.72,63.79 98.41,63.47 98.41,63.36 98.47,63.29 98.47,63.17 98.24,62.95 98.12,62.95 98.06,63.01 97.94,63.01 97.71,62.78 97.71,62.66 97.78,62.6 97.78,62.48 97.55,62.25 97.43,62.25 97.37,62.32 97.25,62.32 95.62,60.69 95.62,44.71 95.96,44.37 95.96,44.2 95.75,43.98 95.75,43.84 96,43.58 96.15,43.58 96.39,43.82 96.51,43.82 96.74,43.59 96.74,43.48 96.48,43.22 96.48,43.1 96.71,42.87 96.83,42.87 97.08,43.13 97.2,43.13 97.43,42.9 97.43,42.78 97.17,42.53 97.17,42.41 106.02,33.56 106.02,33.19 105.9,33.06 105.56,33.06 105.43,32.94 105.43,32.67 105.56,32.54 106.07,32.54 106.47,32.14 106.47,31.84 106.6,31.71 106.9,31.71 107.03,31.59 107.03,31.35 106.9,31.22 106.78,31.22 106.65,31.09 106.65,30.86 106.78,30.74 107.05,30.74 107.18,30.61 107.18,30.32 107.3,30.19 107.55,30.19 107.68,30.32 v2(107.68,30.57)
  BOTTOM w0.076: v2(102.08,67.04) 102.4,67.36 102.4,67.77 103.15,68.53 103.15,68.71 UC1.AV58
  BOTTOM w0.102: JDIMM1.163 108.15,32.14 108.15,30.97 108.42,30.7 108.42,30.31 108.32,30.21 107.79,30.21 107.68,30.31 v2(107.68,30.57)
DDR_A_D37: length 56.7
  IN4 w0.084: v2(109.61,27.02) 108.7,27.93 108.7,31.24 106.96,32.98 106.96,33.95 100.73,40.18 100.73,40.93 96.56,45.1 96.56,59.94 99.54,62.91 v2(99.54,63.68)
  BOTTOM w0.076: UC1.AU58 104.14,69.59 104.35,69.38 104.35,69.14 104.33,69.13 104.33,68.75 104.35,68.73 104.35,68.54 104.34,68.53 104.3,68.44 104.27,68.39 104.27,68.18 104.35,68.03 104.35,67.9 104.3,67.79 104.27,67.74 104.27,67.45 104.38,67.34 104.38,66.82 104.19,66.63 103.79,66.63 100.84,63.68 v2(99.54,63.68)
  BOTTOM w0.102: v2(109.61,27.02) 108.45,25.87 JDIMM1.164
DDR_A_D38: length 56.1
  IN4 w0.084: v2(103.94,66.24) 103.94,64.87 100.36,61.29 100.36,60.42 98.86,58.91 98.86,46.05 103.24,41.67 103.24,41.48 103.03,41.27 103.03,41.13 103.24,40.92 103.38,40.92 103.56,41.11 103.74,41.11 103.91,40.94 103.91,40.76 103.73,40.58 103.73,40.43 103.94,40.23 104.08,40.23 104.25,40.39 104.43,40.39 104.59,40.23 104.59,40.05 104.42,39.88 104.42,39.74 104.63,39.54 104.77,39.54 105.01,39.78 105.13,39.78 105.36,39.55 105.36,39.43 105.12,39.19 105.12,39.05 105.32,38.84 105.46,38.84 105.7,39.07 105.84,39.07 106.04,38.87 106.04,38.73 105.82,38.51 105.82,38.39 106.05,38.16 106.17,38.16 106.39,38.38 106.53,38.38 106.74,38.18 106.74,38.03 106.5,37.8 106.5,37.66 106.71,37.46 106.85,37.46 107.09,37.7 107.21,37.7 107.44,37.47 107.44,37.35 107.2,37.11 107.2,36.97 107.4,36.76 107.54,36.76 107.79,37.01 107.91,37.01 108.13,36.78 108.13,36.66 107.89,36.42 107.89,36.27 108.09,36.07 108.24,36.07 108.47,36.3 108.61,36.3 108.82,36.09 108.82,35.95 108.59,35.72 108.59,35.57 108.8,35.37 108.94,35.37 109.11,35.54 109.25,35.54 109.47,35.33 109.47,35.18 109.27,34.99 109.27,34.89 109.47,34.7 109.47,33.73 111.76,31.43 111.76,30.66 111.95,30.47 112.52,30.47 v2(112.62,30.57)
  BOTTOM w0.076: UC1.AV56 104.62,68.59 104.49,68.46 104.46,68.4 104.44,68.35 104.44,68.22 104.45,68.2 104.49,68.12 104.51,68.06 104.51,67.83 104.49,67.81 104.44,67.7 104.44,67.51 104.54,67.41 104.54,66.52 104.26,66.24 v2(103.94,66.24)
  BOTTOM w0.102: v2(112.62,30.57) 112.35,30.84 112.35,32.14 JDIMM1.177
DDR_A_D39: length 57.5
  IN4 w0.084: v2(111.13,27.02) 111.13,26.74 111.03,26.64 110.15,26.64 110.05,26.74 110.05,27.38 110.15,27.48 110.68,27.48 110.78,27.58 110.78,31.08 108.53,33.34 108.53,34.31 102.1,40.74 102.1,41.49 97.92,45.66 97.92,59.3 99.43,60.81 99.43,61.09 102.25,63.91 v2(102.25,64.47)
  BOTTOM w0.076: v2(102.25,64.47) 103.2,64.47 105.04,66.31 105.04,67.3 105.19,67.45 105.19,68.24 104.91,68.52 104.91,68.81 104.92,68.82 104.92,69.06 104.62,69.35 UC1.AU56
  BOTTOM w0.102: JDIMM1.176 112.05,26.1 v2(111.13,27.02)
DDR_A_D40: length 63.2
  IN1 w0.084: v2(69.85,25.5) 68.65,26.7 68.65,27.17 69.54,28.06 69.54,28.29 69.15,28.68 69.15,33.51 69.89,34.24 69.89,35.78 89.51,55.4 91.4,55.4 96.83,60.84 98.09,60.84 99.09,61.84 99.65,61.84 v2(100.08,62.27)
  BOTTOM w0.076: UC1.AY54 105.68,67.51 105.68,67.24 105.54,67.09 105.54,66.11 102.2,62.77 102.2,62.78 v1(101.97,62.55) 101.7,62.27 v2(100.08,62.27)
  BOTTOM w0.102: JDIMM1.42 69.45,25.09 v2(69.85,25.5)
DDR_A_D41: length 64.2
  IN1 w0.084: v2(100.91,63.18) 100.66,63.43 100.56,63.43 99.15,62.01 98.82,62.01 97.96,61.15 96.7,61.15 91.38,55.83 89.5,55.83 69.57,35.91 69.57,34.37 69.42,34.22 68.97,34.22 68.84,34.09 68.84,30.17 68.71,30.04 68.69,30.04 68.57,29.91 68.57,29.68 68.69,29.55 68.71,29.55 68.84,29.42 68.84,28.53 68.71,28.4 68.52,28.4 68.39,28.53 68.39,28.92 68.27,29.05 v2(68.08,29.05)
  BOTTOM w0.076: v2(100.91,63.18) 102.38,63.18 105.37,66.17 105.37,67.16 105.52,67.31 105.52,67.76 105.81,68.05 UC1.AW54
  BOTTOM w0.102: JDIMM1.41 69.15,29.63 68.57,29.05 v2(68.08,29.05)
DDR_A_D42: length 63.7
  IN1 w0.084: v2(71.38,25.5) 72.09,26.21 72.09,26.86 72.17,26.95 72.36,26.95 72.46,27.05 72.46,27.34 72.36,27.44 72.17,27.44 72.09,27.52 72.09,27.84 72.17,27.93 72.85,27.93 72.95,28.03 72.95,28.32 72.85,28.42 72.17,28.42 72.09,28.5 72.09,35.17 89.39,52.47 91.67,52.47 97.42,58.23 98.3,58.23 99.93,59.86 99.93,60.33 102.57,62.97 v2(103.53,62.97)
  BOTTOM w0.076: v2(103.53,62.97) 104.2,62.97 104.5,63.26 104.73,63.26 107.01,65.54 107.01,67.01 107.03,67.03 107.03,67.51 UC1.AY52
  BOTTOM w0.102: v2(71.38,25.5) 71.85,25.02 JDIMM1.50
DDR_A_D43: length 65
  IN1 w0.084: v2(102.61,62.05) 102.03,62.05 100.26,60.28 100.26,59.75 98.29,57.78 97.42,57.78 91.79,52.16 89.52,52.16 80.82,43.46 80.82,43.34 80.88,43.29 80.88,43.17 80.65,42.94 80.53,42.94 80.48,43 80.36,43 80.13,42.77 80.13,42.65 80.18,42.6 80.18,42.48 79.95,42.25 79.84,42.25 79.78,42.3 79.66,42.3 79.44,42.08 79.44,41.96 79.49,41.9 79.49,41.78 79.26,41.56 79.14,41.56 79.09,41.61 78.97,41.61 78.74,41.38 78.74,41.26 78.8,41.21 78.8,41.09 78.57,40.86 78.45,40.86 78.4,40.92 78.28,40.92 78.05,40.69 78.05,40.57 78.1,40.52 78.1,40.4 77.87,40.17 77.76,40.17 77.7,40.22 77.58,40.22 77.35,39.99 77.35,39.88 77.41,39.82 77.41,39.7 77.18,39.48 77.06,39.48 77.01,39.53 76.89,39.53 76.66,39.3 76.66,39.18 76.72,39.13 76.72,39.01 76.49,38.78 76.37,38.78 76.31,38.84 76.2,38.84 75.97,38.61 75.97,38.49 76.02,38.44 76.02,38.32 75.79,38.09 75.68,38.09 75.62,38.14 75.5,38.14 75.27,37.91 75.27,37.8 75.33,37.74 75.33,37.62 75.1,37.4 74.98,37.4 74.93,37.45 74.81,37.45 74.58,37.22 74.58,37.1 74.64,37.05 74.64,36.93 74.41,36.7 74.29,36.7 74.23,36.76 74.12,36.76 73.89,36.53 73.89,36.41 73.94,36.36 73.94,36.24 73.71,36.01 73.6,36.01 73.54,36.06 73.42,36.06 72.4,35.04 72.4,28.86 72.53,28.73 73.22,28.73 73.35,28.86 v2(73.35,29.05)
  BOTTOM w0.076: v2(102.61,62.05) 103.75,62.05 107.18,65.48 107.18,66.94 107.2,66.96 107.2,67.26 107.45,67.51 107.45,67.7 107.41,67.8 107.4,67.81 107.38,67.86 107.38,68.07 UC1.AW52
  BOTTOM w0.102: v2(73.35,29.05) 72.57,29.83 72.57,30.7 72.15,31.12 72.15,32.14 JDIMM1.51
DDR_A_D44: length 64.5
  IN1 w0.084: v2(68.08,30.57) 68.4,30.57 68.53,30.7 68.53,31.12 68.4,31.25 68.1,31.25 67.97,31.38 67.97,31.61 68.1,31.74 68.4,31.74 68.53,31.87 68.53,32.1 68.4,32.23 68.18,32.23 68.05,32.36 68.05,32.59 68.18,32.72 68.41,32.72 68.53,32.83 68.53,34.33 68.17,34.69 68.17,34.87 68.36,35.06 68.54,35.06 68.91,34.68 69.09,34.68 69.26,34.85 69.26,35.03 68.81,35.48 68.81,35.59 89.43,56.21 91.32,56.21 96.57,61.46 97.83,61.46 98.67,62.3 99.19,62.3 99.52,62.63 99.52,62.75 99.52,62.85 99.75,63.08 99.89,63.08 99.97,63.08 100.12,63.23 100.12,63.24 100.12,63.49 100.31,63.68 100.75,64.13 101.16,64.13 101.37,63.92 v2(101.37,63.6)
  BOTTOM w0.076: v2(101.37,63.6) 102.57,63.6 105.21,66.24 105.21,67.23 105.35,67.38 105.35,68.24 105.92,68.81 UC1.AV54
  BOTTOM w0.102: JDIMM1.39 68.55,31.11 68.82,30.84 68.82,30.38 68.72,30.28 68.18,30.28 68.08,30.38 v2(68.08,30.57)
DDR_A_D45: length 65.9
  IN1 w0.084: v2(69.85,27.02) 69.85,28.42 69.47,28.81 69.47,32.26 70.2,33 70.2,35.65 89.59,55.05 91.48,55.05 96.87,60.43 98.13,60.43 99.32,61.63 100.06,61.63 104.18,65.74 v2(106.23,65.74)
  BOTTOM w0.076: UC1.AU54 106.57,69.59 106.78,69.38 106.78,68.54 106.77,68.53 106.73,68.44 106.7,68.39 106.7,68.18 106.78,68.03 106.78,67.9 106.73,67.79 106.7,67.74 106.7,67.23 106.68,67.21 106.68,66.2 v2(106.23,65.74)
  BOTTOM w0.102: JDIMM1.40 68.85,23.94 68.85,26.02 v2(69.85,27.02)
DDR_A_D46: length 65.3
  IN1 w0.084: v2(103.99,63.43) 102.72,63.43 99.42,60.13 99.42,59.8 98.17,58.54 97.3,58.54 91.54,52.78 89.26,52.78 71.77,35.3 71.77,30.79 71.69,30.71 71.66,30.71 71.55,30.61 71.55,30.32 71.66,30.22 71.69,30.22 71.77,30.14 71.77,29.81 71.69,29.73 71.36,29.73 71.26,29.63 71.26,29.34 71.36,29.24 71.69,29.24 71.77,29.15 71.77,28.83 71.69,28.75 71.36,28.75 71.26,28.65 71.26,28.36 71.36,28.26 71.69,28.26 71.77,28.17 71.77,27.12 71.67,27.02 v2(71.38,27.02)
  BOTTOM w0.076: UC1.AV52 107.05,68.59 106.92,68.46 106.89,68.4 106.87,68.35 106.87,68.22 106.88,68.2 106.92,68.12 106.92,68.12 106.94,68.06 106.94,67.86 106.92,67.81 106.87,67.7 106.87,67.1 106.85,67.08 106.85,65.61 104.66,63.43 v2(103.99,63.43)
  BOTTOM w0.102: JDIMM1.52 72.45,23.94 72.45,25.14 71.94,25.66 71.94,26.46 v2(71.38,27.02)
DDR_A_D47: length 66.3
  IN1 w0.084: v2(73.35,30.57) 73.35,30.32 73.22,30.19 72.84,30.19 72.71,30.32 72.71,30.93 72.84,31.05 73.25,31.05 73.35,31.15 73.35,31.44 73.25,31.54 72.8,31.54 72.71,31.63 72.71,31.95 72.8,32.03 73.25,32.03 73.35,32.14 73.35,32.42 73.25,32.52 72.8,32.52 72.71,32.61 72.71,32.93 72.8,33.01 73.03,33.01 73.12,33.1 73.12,33.42 73.03,33.5 72.8,33.5 72.71,33.59 72.71,33.91 72.8,33.99 73.25,33.99 73.35,34.1 73.35,34.38 73.25,34.48 72.8,34.48 72.71,34.57 72.71,34.86 72.81,34.97 73.25,34.97 73.35,35.07 73.35,35.2 82.14,43.99 82.14,44.11 82.1,44.15 82.1,44.29 82.3,44.5 82.44,44.5 82.49,44.46 82.61,44.46 82.83,44.68 82.83,44.8 82.79,44.84 82.79,44.99 82.99,45.19 83.14,45.19 83.18,45.15 83.3,45.15 83.53,45.38 83.53,45.49 83.48,45.54 83.48,45.68 83.69,45.88 83.83,45.88 83.87,45.84 83.99,45.84 84.22,46.07 84.22,46.19 84.18,46.23 84.18,46.38 84.38,46.58 84.52,46.58 84.57,46.54 84.69,46.54 84.91,46.76 84.91,46.88 84.87,46.93 84.87,47.07 85.07,47.27 85.22,47.27 85.26,47.23 85.38,47.23 85.61,47.46 85.61,47.58 85.56,47.62 85.56,47.76 85.77,47.97 85.91,47.97 85.95,47.92 86.07,47.92 86.3,48.15 86.3,48.27 86.26,48.31 86.26,48.46 86.46,48.66 86.6,48.66 86.65,48.62 86.77,48.62 86.99,48.84 86.99,48.96 86.95,49.01 86.95,49.15 87.15,49.35 87.3,49.35 87.34,49.31 87.46,49.31 87.69,49.54 87.69,49.66 87.64,49.7 87.64,49.84 87.85,50.05 87.99,50.05 88.03,50 88.15,50 88.38,50.23 88.38,50.35 88.34,50.39 88.34,50.54 88.54,50.74 88.68,50.74 88.73,50.7 88.85,50.7 89.07,50.92 89.07,51.04 89.03,51.09 89.03,51.23 89.23,51.43 89.38,51.43 89.42,51.39 89.54,51.39 90,51.85 91.92,51.85 97.36,57.28 98.23,57.28 101.52,60.57 101.66,60.57 102.15,61.06 v2(102.15,61.59)
  BOTTOM w0.076: v2(102.15,61.59) 103.53,61.59 107.34,65.4 107.34,66.87 107.36,66.89 107.36,67.19 107.62,67.44 107.62,67.74 107.6,67.79 107.54,67.9 107.54,69.2 UC1.AU52
  BOTTOM w0.102: v2(73.35,30.57) 72.75,31.17 72.75,32.14 JDIMM1.53
DDR_A_D48: length 72.4
  IN1 w0.084: v2(78.15,30.57) 78.15,30.3 78.25,30.2 78.68,30.2 78.78,30.3 78.78,31.09 78.68,31.19 78.17,31.19 78.07,31.29 78.07,31.58 78.17,31.68 78.68,31.68 78.78,31.78 78.78,32.07 78.68,32.17 78.17,32.17 78.07,32.27 78.07,32.56 78.17,32.66 78.7,32.66 78.78,32.74 78.78,33.06 78.7,33.15 78.59,33.15 78.49,33.25 78.49,33.54 78.59,33.64 78.7,33.64 78.78,33.72 78.78,34.04 78.7,34.13 78.59,34.13 78.49,34.23 78.49,34.52 78.59,34.62 78.7,34.62 78.78,34.7 78.78,34.95 90.59,46.76 92.57,46.76 97.63,51.82 98.71,51.82 101.48,54.59 101.48,54.7 101.34,54.85 101.34,54.97 101.57,55.19 101.68,55.19 101.83,55.05 101.95,55.05 102.17,55.28 102.17,55.4 102.03,55.54 102.03,55.66 102.26,55.89 102.38,55.89 102.52,55.74 102.64,55.74 102.87,55.97 102.87,56.09 102.72,56.23 102.72,56.35 102.95,56.58 103.07,56.58 103.21,56.44 103.33,56.44 103.56,56.67 103.56,56.78 103.42,56.93 103.42,57.05 103.65,57.27 103.76,57.27 103.91,57.13 104.03,57.13 104.25,57.36 104.25,57.48 104.11,57.62 104.11,57.74 104.34,57.97 104.46,57.97 104.6,57.82 104.72,57.82 104.95,58.05 104.95,58.17 104.8,58.31 104.8,58.43 105.03,58.66 105.15,58.66 105.29,58.52 105.47,58.52 111.41,64.46 111.41,69.18 111.91,69.67 115.07,69.67 115.42,70.02 115.42,72.19 114.29,73.32 v2(114.29,73.67)
  BOTTOM w0.076: UC1.AK40 114.62,74 v2(114.29,73.67)
  BOTTOM w0.102: v2(78.15,30.57) 77.55,31.17 JDIMM1.69
DDR_A_D49: length 72.1
  IN1 w0.084: v2(78.15,29.05) 78.15,28.77 78.05,28.67 77.85,28.67 77.75,28.77 77.75,32.75 78.18,33.18 78.18,34.79 90.46,47.07 92.44,47.07 97.51,52.15 98.08,52.15 98.98,53.06 99.1,53.06 99.25,52.91 99.36,52.91 99.59,53.14 99.59,53.26 99.45,53.4 99.45,53.52 99.68,53.75 99.8,53.75 99.94,53.6 100.06,53.6 100.29,53.83 100.29,53.95 100.14,54.1 100.14,54.21 100.37,54.44 100.49,54.44 100.63,54.3 100.75,54.3 100.98,54.53 100.98,54.65 100.84,54.79 100.84,54.91 104.76,58.83 105.55,58.83 111.24,64.53 111.24,69.25 111.84,69.85 115,69.85 115.25,70.1 115.25,71.98 114.48,72.74 114.09,72.74 113.99,72.85 113.99,73.36 113.88,73.46 113.48,73.46 113.38,73.56 v2(113.38,73.72)
  BOTTOM w0.076: v2(113.38,73.72) 113.65,74 UC1.AK42
  BOTTOM w0.102: JDIMM1.67 76.95,32.14 76.95,30.25 v2(78.15,29.05)
DDR_A_D50: length 69.4
  IN1 w0.084: v2(112.43,72.5) 112.03,72.5 111.93,72.4 111.93,72.11 111.83,72 111.24,72 110.84,71.6 110.18,71.6 110.04,71.47 109.35,71.47 109.18,71.29 109.18,70.07 108.46,69.36 108.46,65.42 106.71,63.66 106.71,63.6 98.39,55.27 97.3,54.19 96.55,54.19 92.39,50.03 91.71,50.03 91.59,49.9 91.59,49.23 91.48,49.12 91.18,49.12 91.09,49.21 91.09,49.8 90.99,49.9 90.71,49.9 90.6,49.8 90.6,49.21 90.52,49.12 89.64,49.12 76.12,35.6 76.12,35.13 76.04,35.05 75.55,35.05 75.43,34.92 75.43,34.68 75.55,34.56 76.04,34.56 76.12,34.47 76.12,34.22 75.9,34 75.06,34 74.88,33.82 74.88,33.27 75.01,33.14 75.39,33.14 75.52,33.02 75.52,32.68 75.43,32.6 74.97,32.6 74.88,32.52 74.88,32.19 74.97,32.11 75.43,32.11 75.52,32.03 75.52,31.7 75.43,31.62 75.21,31.62 75.11,31.52 75.11,31.23 75.21,31.13 75.43,31.13 75.52,31.05 75.52,30.68 75.41,30.57 v2(75.23,30.57)
  BOTTOM w0.089: v2(112.43,72.5) 112.63,72.7 UC1.AM43
  BOTTOM w0.102: JDIMM1.59 74.55,32.14 74.55,31.04 74.62,30.98 74.62,30.3 74.74,30.18 74.96,30.18 75.23,30.45 v2(75.23,30.57)
DDR_A_D51: length 68.7
  IN1 w0.084: v2(75.23,29.05) 75.23,28.77 75.12,28.67 74.67,28.67 74.57,28.77 74.57,29.08 74.65,29.17 74.77,29.17 74.87,29.27 74.87,29.55 74.77,29.66 74.65,29.66 74.57,29.74 74.57,30.06 74.65,30.15 74.73,30.15 74.83,30.25 74.83,30.53 74.73,30.64 74.65,30.64 74.57,30.72 74.57,31.04 74.65,31.13 74.7,31.13 74.8,31.23 74.8,31.51 74.7,31.62 74.65,31.62 74.57,31.7 74.57,34.5 90.41,50.34 92.22,50.34 96.38,54.5 97.17,54.5 97.95,55.27 108.29,65.62 108.29,69.43 109,70.14 109,71.47 109.17,71.64 109.97,71.64 110.11,71.78 110.77,71.78 111.07,72.07 111.07,72.34 111.16,72.43 v2(111.48,72.43)
  BOTTOM w0.089: v2(111.48,72.43) 111.68,72.43 UC1.AM45
  BOTTOM w0.102: v2(75.23,29.05) 74.82,28.64 74.46,28.64 74.35,28.76 74.35,29.51 73.98,29.87 73.98,30.82 73.95,30.85 73.95,32.14 JDIMM1.57
DDR_A_D52: length 69.6
  IN1 w0.084: v2(111.49,73.73) 110.9,73.14 110.9,72.17 110.68,71.95 110.03,71.95 109.89,71.81 108.81,71.81 108.23,71.24 108.23,69.79 107.2,68.76 107.2,64.97 97.5,55.27 97.04,54.81 96.25,54.81 92.09,50.65 90.18,50.65 74.26,34.73 74.26,25.97 73.78,25.5 v2(73.05,25.5)
  BOTTOM w0.089: UC1.AK45 111.75,74 v2(111.49,73.73)
  BOTTOM w0.102: JDIMM1.56 73.65,24.9 v2(73.05,25.5)
DDR_A_D53: length 71
  IN1 w0.084: v2(112.43,73.8) 112.12,74.1 111.1,74.1 111.04,74.05 110.42,74.05 110.1,73.73 110.1,72.38 109.71,71.98 108.73,71.98 108.06,71.31 108.06,69.9 106.93,68.77 106.93,65.14 96.91,55.13 96.12,55.13 91.96,50.97 89.95,50.97 73.94,34.96 73.94,27.91 v2(73.05,27.02)
  BOTTOM w0.076: v2(112.43,73.8) 112.72,73.8 UC1.AK43
  BOTTOM w0.102: v2(73.05,27.02) 74.25,25.82 JDIMM1.58
DDR_A_D54: length 70.9
  IN1 w0.084: v2(78.45,27.02) 78.17,27.02 78.11,27.08 78.11,27.8 77.97,27.93 77.57,27.93 77.44,28.06 77.44,32.88 77.8,33.24 77.8,34.85 90.33,47.38 92.31,47.38 97.39,52.46 97.95,52.46 100.76,55.27 100.76,55.27 104.53,59.05 105.51,59.05 111.07,64.6 111.07,69.32 111.77,70.02 114.92,70.02 115.07,70.17 115.07,70.99 114.99,71.07 114.75,71.07 114.67,71.15 114.67,71.48 114.75,71.56 114.99,71.56 115.07,71.64 115.07,71.86 114.57,72.37 v2(114.29,72.37)
  BOTTOM w0.076: UC1.AM40 114.62,72.7 v2(114.29,72.37)
  BOTTOM w0.102: JDIMM1.68 77.25,23.94 77.25,25.82 77.25,25.82 v2(78.45,27.02)
DDR_A_D55: length 70.5
  IN1 w0.084: v2(113.38,72.42) 113.38,72.31 113.02,71.95 113.02,71.87 112.85,71.7 112.6,71.7 112.4,71.49 112.21,71.49 111.99,71.28 111.99,70.49 110.89,69.39 110.89,64.67 105.44,59.22 104.26,59.22 97.83,52.78 97.27,52.78 92.18,47.7 90.2,47.7 77.48,34.98 77.48,33.37 76.88,32.76 76.88,26.63 76.96,26.55 77.95,26.55 78.05,26.44 78.05,26.16 77.95,26.06 76.96,26.06 76.88,25.97 76.88,25.62 77.01,25.5 v2(78.45,25.5)
  BOTTOM w0.089: v2(113.38,72.42) 113.65,72.7 UC1.AM42
  BOTTOM w0.102: JDIMM1.70 77.85,24.9 v2(78.45,25.5)
DDR_A_D56: length 66.6
  IN4 w0.084: v2(118.08,27.02) 118.04,27.02 117.49,26.47 117.26,26.47 117.17,26.56 117.17,27.09 117.27,27.19 117.55,27.19 117.66,27.3 117.66,27.59 117.55,27.69 117.13,27.69 117.03,27.79 117.03,28.08 117.13,28.18 118.33,28.18 118.43,28.28 118.43,28.57 118.33,28.67 117.86,28.67 117.76,28.77 117.76,29.06 117.86,29.16 118.14,29.16 118.24,29.26 118.24,31.65 102.38,47.51 102.38,51.62 103.17,52.41 103.17,52.53 102.8,52.9 102.8,53.02 103.02,53.25 103.14,53.25 103.52,52.87 103.64,52.87 103.97,53.2 103.97,59.97 106.57,62.57 106.57,62.96 107.51,63.9 107.51,65.53 108.14,66.16 108.14,66.54 107.74,66.94 107.74,69.45 109,70.71 109,71.28 109.53,71.81 109.81,71.81 110.12,72.12 110.12,72.85 110.24,72.97 v2(110.52,72.97)
  BOTTOM w0.089: v2(110.52,72.97) 110.8,72.7 UC1.AM46
  BOTTOM w0.102: JDIMM1.192 116.85,23.94 116.85,25.18 116.99,25.33 116.99,25.94 v2(118.08,27.02)
DDR_A_D57: length 66.3
  IN4 w0.084: v2(117.58,25.89) 117.77,25.7 118.43,25.7 118.58,25.85 118.58,27 118.69,27.11 119.37,27.11 119.47,27.21 119.47,27.5 119.37,27.6 118.87,27.6 118.77,27.7 118.77,28.02 118.87,28.12 119.43,28.12 119.53,28.22 119.53,28.51 119.43,28.61 118.82,28.61 118.75,28.68 118.75,29 118.85,29.1 119.45,29.1 119.53,29.18 119.53,29.51 119.45,29.59 118.64,29.59 118.55,29.68 118.55,31.78 103.13,47.21 103.13,51.92 104.28,53.07 104.28,59.63 106.94,62.3 106.94,63.09 107.68,63.83 107.68,65.46 108.31,66.09 108.31,66.62 107.99,66.93 107.99,69.46 109.18,70.64 109.18,71.2 109.61,71.63 110.36,71.63 110.9,72.17 110.9,73.25 v2(110.52,73.62)
  BOTTOM w0.089: UC1.AK46 110.9,74 v2(110.52,73.62)
  BOTTOM w0.102: v2(117.58,25.89) 117.58,25.14 117.45,25.01 JDIMM1.194
DDR_A_D58: length 63.8
  IN4 w0.084: v2(114.75,30.57) 114.98,30.57 115.11,30.7 115.11,31.07 114.98,31.19 114.79,31.19 114.55,30.95 114.4,30.95 114.2,31.16 114.2,31.3 114.59,31.69 114.59,31.83 114.38,32.04 114.23,32.04 113.85,31.65 113.7,31.65 113.5,31.86 113.5,32 113.88,32.39 113.88,32.53 113.67,32.74 113.53,32.74 113.14,32.36 113,32.36 112.79,32.56 112.79,32.71 113.49,33.41 113.49,33.59 113.32,33.76 113.14,33.76 112.82,33.43 112.64,33.43 112.47,33.6 112.47,33.78 112.76,34.07 112.76,34.25 112.6,34.42 112.42,34.42 111.75,33.75 111.6,33.75 111.4,33.96 111.4,34.1 112.13,34.83 112.13,34.95 111.9,35.17 111.78,35.17 111.34,34.73 111.2,34.73 110.99,34.94 110.99,35.08 111.44,35.52 111.44,35.64 100.39,46.69 100.39,57.54 101.89,59.04 101.89,60.5 106.64,65.24 106.64,71.11 107.52,72 107.82,72 108.26,72.44 v2(108.57,72.44)
  BOTTOM w0.089: UC1.AM49 108.83,72.7 v2(108.57,72.44)
  BOTTOM w0.102: v2(114.75,30.57) 114.75,30.31 114.65,30.21 114.25,30.21 114.15,30.31 114.15,32.14 JDIMM1.183
DDR_A_D59: length 63.5
  IN4 w0.084: v2(108.62,73.7) 107.94,74.38 104.96,74.38 104.42,73.84 104.42,65.1 100.96,61.64 100.96,59.43 99.45,57.92 99.45,46.3 110.06,35.69 110.06,33.97 113.21,30.82 113.21,29.58 113.21,29.58 113.21,27.54 112.9,27.23 v2(112.9,27.02)
  BOTTOM w0.089: UC1.AK49 108.92,74 v2(108.62,73.7)
  BOTTOM w0.102: JDIMM1.182 113.85,23.94 113.85,26.07 v2(112.9,27.02)
DDR_A_D60: length 65.1
  IN4 w0.084: v2(116.58,30.45) 116.58,32.43 101.75,47.25 101.75,53.58 101.86,53.68 102.57,53.68 102.67,53.78 102.67,54.07 102.57,54.17 101.86,54.17 101.75,54.27 101.75,54.56 101.86,54.66 103.26,54.66 103.34,54.74 103.34,55.06 103.26,55.15 101.86,55.15 101.75,55.25 101.75,55.54 101.86,55.64 103.26,55.64 103.34,55.72 103.34,56.04 103.26,56.13 101.86,56.13 101.75,56.23 101.75,56.52 101.86,56.62 103.26,56.62 103.34,56.7 103.34,57.02 103.26,57.11 102.55,57.11 102.47,57.19 102.47,57.51 102.55,57.6 103.26,57.6 103.34,57.68 103.34,60.54 107.16,64.36 107.16,69.37 108.05,70.26 108.05,71.33 108.38,71.66 108.86,71.66 v2(109.57,72.37)
  BOTTOM w0.089: v2(109.57,72.37) 109.9,72.7 UC1.AM48
  BOTTOM w0.102: v2(116.58,30.45) 115.86,30.45 115.76,30.55 115.76,30.85 115.86,30.95 116.45,30.95 116.55,31.06 116.55,32.14 JDIMM1.191
DDR_A_D61: length 65.3
  IN4 w0.084: v2(109.57,73.67) 109.59,73.67 109.94,73.32 109.94,72.19 109.73,71.98 109.45,71.98 108.97,71.49 108.45,71.49 108.22,71.26 108.22,70.19 107.33,69.3 107.33,63.97 103.65,60.29 103.65,54.32 102.07,52.73 102.07,47.38 116.89,32.56 116.89,32.27 116.99,32.17 117.28,32.17 117.38,32.07 117.38,31.78 117.28,31.68 116.99,31.68 116.89,31.58 116.89,31.29 116.99,31.19 117.75,31.19 117.83,31.1 117.83,30.78 117.75,30.7 117.06,30.7 116.98,30.61 116.98,30.29 117.06,30.21 117.75,30.21 117.83,30.12 117.83,29.8 117.75,29.72 117.08,29.72 116.98,29.62 116.98,29.26 117.08,29.16 117.34,29.16 117.44,29.06 117.44,28.65 117.34,28.55 116.68,28.55 116.58,28.65 v2(116.58,28.93)
  BOTTOM w0.089: UC1.AK48 109.9,74 v2(109.57,73.67)
  BOTTOM w0.102: v2(116.58,28.93) 116.58,28.74 116.68,28.64 117.05,28.64 117.15,28.74 117.15,32.14 JDIMM1.193
DDR_A_D62: length 62.2
  IN4 w0.084: v2(114.75,29.05) 114.75,28.79 114.62,28.66 113.96,28.66 113.84,28.79 113.84,31.08 110.68,34.23 110.68,35.95 100.08,46.56 100.08,57.67 101.58,59.17 101.58,60.19 101.32,60.45 101.32,61.31 105.49,65.49 105.49,68.41 106.21,69.13 106.21,73.36 106.31,73.46 107.02,73.46 107.12,73.36 107.12,72.47 107.22,72.37 v2(107.67,72.37)
  BOTTOM w0.089: UC1.AM51 107.99,72.7 v2(107.67,72.37)
  BOTTOM w0.102: v2(114.75,29.05) 114.75,28.78 114.66,28.69 113.64,28.69 113.55,28.78 113.55,32.14 JDIMM1.181
DDR_A_D63: length 62.1
  IN4 w0.084: v2(112.9,25.5) 112.9,25.54 114.06,26.7 114.06,27.34 113.52,27.88 113.52,30.95 110.37,34.1 110.37,35.82 99.76,46.43 99.76,57.79 101.27,59.3 101.27,60.06 101.14,60.19 101.14,61.58 104.91,65.35 104.91,68.91 105.39,69.4 105.39,73.86 105.74,74.21 107.13,74.21 v2(107.67,73.67)
  BOTTOM w0.089: UC1.AK51 107.99,74 v2(107.67,73.67)
  BOTTOM w0.102: v2(112.9,25.5) 113.25,25.15 JDIMM1.180
DDR_A_DQS0: length 65.1
  IN4 w0.091: v2(99.45,28.47) 99.23,28.68 98.98,28.68 98.76,28.9 98.76,30.49 97.55,31.7 96.92,31.7 95.27,33.35 95.27,34.13 89.32,40.08 89.32,42.72 89.23,42.81 89.08,42.81 88.88,43 88.88,43.46 89.08,43.65 89.23,43.65 89.32,43.74 89.32,44.06 89.23,44.15 89.08,44.15 88.88,44.34 88.88,44.8 89.08,44.99 89.23,44.99 89.32,45.09 89.32,45.4 89.23,45.49 89.08,45.49 88.88,45.68 88.88,46.14 89.08,46.34 89.23,46.34 89.32,46.43 89.32,63.36 94.55,68.59 94.55,70.99 96.39,72.83 96.39,73.17 96.24,73.32 v2(95.92,73.32)
  BOTTOM w0.076: v2(95.92,73.32) 96.21,73.32 96.3,73.23 96.62,73.23 97.16,73.78 98.53,73.78 99.15,74.39 99.6,74.39 99.73,74.53 100.29,74.53 100.34,74.55 100.45,74.6 100.58,74.6 100.6,74.59 100.68,74.55 100.74,74.53 100.94,74.53 101.1,74.6 101.23,74.6 101.33,74.55 101.33,74.38 101.27,74.31 UC1.AJ62
  BOTTOM w0.102: JDIMM1.137 100.35,32.14 100.35,30.98 100.16,30.79 100.16,28.96 99.95,28.76 99.74,28.76 v2(99.45,28.47)
DDR_A_DQS1: length 74.1
  IN1 w0.091: v2(59.01,27.53) 59.13,27.4 59.62,27.4 59.9,27.68 59.9,36.13 64.19,40.43 64.19,41.56 67.43,44.8 68.57,44.8 78.75,54.98 78.75,55.99 82.58,59.83 82.58,60.67 84.77,62.85 89.29,62.85 94.92,68.48 96.57,68.48 97.6,69.51 97.6,69.86 98.3,70.56 98.3,70.65 v2(98.09,70.86)
  BOTTOM w0.076: v2(98.09,70.86) 98.09,71.74 98.33,71.98 99.18,71.98 99.46,72.26 99.98,72.26 99.98,72.26 100.25,72.26 100.41,72.34 100.62,72.34 100.77,72.26 101.24,72.26 101.4,72.1 101.59,72.1 UC1.AN61
  BOTTOM w0.102: JDIMM1.12 60.45,23.94 60.45,26.77 59.69,27.53 v2(59.01,27.53)
DDR_A_DQS2: length 61.2
  IN4 w0.091: v2(102.96,71.72) 102.96,71.77 102.64,72.09 102.2,72.09 100.69,70.59 100.69,69.07 93.5,61.87 93.5,42.11 96.73,38.88 97.7,38.88 102.3,34.28 102.3,33.65 101.97,33.31 101.97,33.12 104.28,30.81 104.28,27.25 104.47,27.06 104.92,27.06 105.04,27.18 v2(105.04,27.44)
  BOTTOM w0.089: v2(102.96,71.72) 103.28,72.05 UC1.AN58
  BOTTOM w0.102: v2(105.04,27.44) 105.23,27.24 105.77,27.24 106,27.02 106,25.64 105.77,25.42 105.44,25.42 105.3,25.28 105.3,25.11 105.45,24.96 JDIMM1.154
DDR_A_DQS3: length 70.8
  IN1 w0.091: v2(64.83,28.67) 64.49,29.01 64.4,29.01 64.17,29.24 64.17,30.52 65.66,32.01 65.66,35.69 68.71,38.74 68.71,39.49 71.81,42.59 72.08,42.59 72.27,42.4 72.37,42.4 72.69,42.72 72.69,42.83 72.51,43.01 72.51,43.28 72.9,43.68 73.17,43.68 73.2,43.65 73.33,43.65 73.63,43.95 73.63,44.07 73.6,44.1 73.6,44.38 73.99,44.77 74.27,44.77 74.45,44.59 74.56,44.59 74.87,44.9 74.87,45.01 74.69,45.2 74.69,45.47 76.39,47.17 76.78,47.17 88.39,58.78 90.64,58.78 95.89,64.03 97.07,64.03 98.72,65.68 101.42,68.38 102.09,68.38 102.66,68.95 103.93,68.95 105.24,70.27 105.24,71.91 105.17,71.99 104.97,71.99 104.86,71.89 v2(104.86,71.72)
  BOTTOM w0.089: v2(104.86,71.72) 105.19,72.05 UC1.AN55
  BOTTOM w0.102: JDIMM1.29 65.55,32.14 65.55,29.17 65.24,28.86 65.02,28.86 v2(64.83,28.67)
DDR_A_DQS4: length 55.3
  IN4 w0.091: v2(110.19,28.64) 110.01,28.82 109.49,28.82 109.29,29.01 109.29,30.6 109.47,30.77 109.47,31.31 107.56,33.22 107.56,34.19 101.33,40.42 101.33,41.17 97.16,45.35 97.16,59.69 99.5,62.04 99.5,62.61 101.03,64.13 101.03,64.27 100.71,64.59 100.38,64.59 v2(100.37,64.6)
  BOTTOM w0.076: v2(100.37,64.6) 100.58,64.6 100.82,64.36 101.29,64.36 103.59,66.66 103.59,67.2 103.84,67.45 103.84,67.74 103.81,67.79 103.76,67.9 103.76,68.03 103.77,68.05 103.81,68.13 103.84,68.18 103.84,68.39 103.76,68.55 103.76,68.68 103.81,68.78 103.89,68.86 103.98,68.86 104.05,68.79 UC1.AW57
  BOTTOM w0.102: JDIMM1.171 110.55,31.06 111.14,30.47 111.14,29.18 110.89,28.92 110.47,28.92 v2(110.19,28.64)
DDR_A_DQS5: length 64.7
  IN1 w0.091: v2(105.37,64.81) 104.83,65.34 104.11,65.34 99.98,61.2 99.74,61.2 97.85,59.31 96.98,59.31 92.04,54.38 89.77,54.38 70.79,35.4 70.79,32.51 70.68,32.4 70.44,32.4 70.21,32.17 70.21,31.64 70.44,31.41 70.58,31.41 70.7,31.28 70.7,30.91 70.58,30.78 70.29,30.78 70.06,30.55 70.06,29.06 70.22,28.9 70.58,28.9 70.67,28.82 v2(70.67,28.59)
  BOTTOM w0.076: v2(105.37,64.81) 105.13,64.81 105.09,64.84 105.09,65.19 105.87,65.97 105.87,66.9 106.01,67.04 106.01,67.17 106.27,67.42 106.27,67.74 106.24,67.79 106.19,67.9 106.19,68.03 106.2,68.05 106.24,68.13 106.27,68.18 106.27,68.57 106.31,68.61 UC1.AW53
  BOTTOM w0.102: v2(70.67,28.59) 70.83,28.76 71.12,28.76 71.4,29.04 71.4,30.26 70.79,30.87 70.79,31.04 70.95,31.21 JDIMM1.47
DDR_A_DQS6: length 70.3
  IN1 w0.091: v2(113.38,73.07) 113.15,73.07 112.98,72.9 112.98,72.15 112.7,71.87 112.31,71.87 112.01,71.57 111.31,71.57 111.1,71.36 111.1,70.16 110.72,69.78 110.2,69.78 109.71,69.29 109.71,66.17 107.06,63.52 107.06,62.86 97.62,53.42 96.87,53.42 91.74,48.29 89.9,48.29 76.89,35.28 76.89,33.9 76.28,33.3 76.28,27.89 76.03,27.63 75.17,27.63 75.02,27.49 75.02,26.94 75.09,26.87 75.31,26.87 75.43,26.99 v2(75.43,27.15)
  BOTTOM w0.076: v2(113.38,73.07) 113.65,73.35 UC1.AL42
  BOTTOM w0.102: v2(75.43,27.15) 75.64,26.94 75.83,26.94 76.46,26.32 76.46,25.73 76.05,25.32 76.05,23.94 JDIMM1.64
DDR_A_DQS7: length 63.8
  IN4 w0.091: v2(108.62,73.05) 108.96,72.71 108.96,72.27 108.74,72.05 108.13,72.05 107.8,71.72 107.49,71.72 106.81,71.04 106.81,64.72 102.49,60.4 102.49,58.79 100.99,57.29 100.99,46.93 114.25,33.67 114.25,33.01 115.81,31.45 115.81,28.1 115.64,27.94 114.95,27.94 114.75,27.74 114.75,27.13 114.95,26.93 116.48,26.93 116.58,26.83 v2(116.58,26.64)
  BOTTOM w0.089: v2(108.62,73.05) 108.92,73.35 UC1.AL49
  BOTTOM w0.102: JDIMM1.188 115.65,23.94 115.65,24.94 115.46,25.14 115.46,26.82 115.56,26.93 116.29,26.93 v2(116.58,26.64)
DDR_A_DQS#0: length 65.2
  IN4 w0.091: v2(99.45,29.23) 99.45,28.96 99.35,28.86 99.05,28.86 98.94,28.98 98.94,30.57 97.63,31.87 96.99,31.87 95.44,33.42 95.44,34.2 89.5,40.15 89.5,42.79 89.3,42.98 89.15,42.98 89.06,43.07 89.06,43.39 89.15,43.48 89.3,43.48 89.5,43.67 89.5,44.13 89.3,44.32 89.15,44.32 89.06,44.42 89.06,44.73 89.15,44.82 89.3,44.82 89.5,45.01 89.5,45.47 89.3,45.67 89.15,45.67 89.06,45.76 89.06,46.07 89.15,46.16 89.3,46.16 89.5,46.36 89.5,63.29 94.72,68.52 94.72,70.92 96.56,72.76 96.56,73.24 96.33,73.48 v2(96.33,73.74)
  BOTTOM w0.076: v2(96.33,73.74) 96.33,73.44 96.37,73.4 96.55,73.4 97.12,73.97 98.45,73.97 99.04,74.56 99.53,74.56 99.66,74.69 100.25,74.69 100.34,74.73 100.41,74.77 100.62,74.77 100.77,74.69 100.9,74.69 101.01,74.74 101.06,74.77 101.29,74.77 101.32,74.74 101.43,74.69 101.51,74.61 101.51,74.26 101.56,74.21 101.71,74.21 UC1.AJ61
  BOTTOM w0.102: v2(99.45,29.23) 99.71,28.97 99.86,28.97 99.94,29.05 99.94,30.79 99.75,30.98 99.75,32.14 JDIMM1.135
DDR_A_DQS#1: length 74.1
  IN1 w0.091: v2(59.01,26.76) 59.01,26.96 59.28,27.23 59.69,27.23 60.07,27.61 60.07,36.06 64.37,40.36 64.37,41.49 67.5,44.63 68.64,44.63 78.92,54.91 78.92,55.92 82.75,59.75 82.75,60.6 84.84,62.68 89.37,62.68 94.99,68.31 96.64,68.31 97.77,69.44 97.77,69.78 98.47,70.49 v2(98.47,71.3)
  BOTTOM w0.076: UC1.AN62 101.21,71.93 101.21,72.04 101.15,72.1 100.74,72.1 100.68,72.12 100.6,72.16 100.58,72.17 100.45,72.17 100.39,72.15 100.28,72.1 99.52,72.1 99.24,71.82 98.4,71.82 98.25,71.67 98.25,71.52 v2(98.47,71.3)
  BOTTOM w0.102: v2(59.01,26.76) 59.01,26.95 59.35,27.3 59.62,27.3 60.23,26.68 60.23,25.22 60.16,25.15 59.93,25.15 59.85,25.07 59.85,23.94 JDIMM1.10
DDR_A_DQS#2: length 61.3
  IN4 w0.091: v2(105.04,26.68) 104.83,26.89 104.4,26.89 104.11,27.18 104.11,30.74 101.79,33.05 101.79,33.38 102.13,33.72 102.13,34.2 97.63,38.7 96.65,38.7 93.32,42.03 93.32,61.95 100.52,69.14 100.52,70.66 102.13,72.27 102.85,72.27 v2(102.96,72.37)
  BOTTOM w0.089: v2(102.96,72.37) 103.28,72.7 UC1.AM58
  BOTTOM w0.102: JDIMM1.152 104.85,24.93 105.08,25.16 105.08,25.37 105.35,25.63 105.68,25.63 105.78,25.73 105.78,26.93 105.68,27.03 105.15,27.03 105.04,26.92 v2(105.04,26.68)
DDR_A_DQS#3: length 70.8
  IN1 w0.091: v2(104.86,72.37) 105.05,72.19 105.29,72.19 105.44,72.03 105.44,70.22 104,68.78 102.73,68.78 102.16,68.2 101.49,68.2 98.89,65.61 97.14,63.86 95.96,63.86 90.71,58.61 88.46,58.61 76.85,46.99 76.46,46.99 74.86,45.4 74.86,45.27 75.05,45.08 75.05,44.83 74.63,44.41 74.38,44.41 74.19,44.6 74.07,44.6 73.77,44.3 73.77,44.18 73.8,44.15 73.8,43.87 73.4,43.48 73.13,43.48 73.1,43.51 72.97,43.51 72.68,43.21 72.68,43.08 72.86,42.9 72.86,42.65 72.45,42.23 72.19,42.23 72.01,42.41 71.88,42.41 68.88,39.41 68.88,38.66 65.83,35.62 65.83,31.94 64.35,30.45 64.35,29.31 64.47,29.18 64.58,29.18 v2(64.83,29.43)
  BOTTOM w0.089: UC1.AM55 105.19,72.7 v2(104.86,72.37)
  BOTTOM w0.102: JDIMM1.27 64.95,32.14 64.95,30.99 65.03,30.91 65.22,30.91 65.33,30.8 65.33,29.26 65.15,29.07 64.95,29.07 64.83,29.19 v2(64.83,29.43)
DDR_A_DQS#4: length 55.4
  IN4 w0.091: v2(100.83,65.06) 100.83,64.78 101.2,64.41 101.2,64.06 99.68,62.54 99.68,61.97 97.33,59.62 97.33,45.42 101.5,41.24 101.5,40.49 107.73,34.27 107.73,33.3 109.64,31.38 109.64,30.7 109.47,30.52 109.47,29.09 109.56,28.99 109.97,28.99 110.19,29.21 v2(110.19,29.4)
  BOTTOM w0.076: UC1.AV57 104.05,69.11 103.98,69.03 103.82,69.03 103.73,68.94 103.67,68.88 103.6,68.71 103.6,68.51 103.62,68.45 103.67,68.35 103.67,68.22 103.6,68.06 103.6,67.86 103.62,67.81 103.67,67.7 103.67,67.51 103.43,67.27 103.43,66.77 103.42,66.76 101.21,64.55 100.9,64.55 100.71,64.75 100.71,64.94 v2(100.83,65.06)
  BOTTOM w0.102: JDIMM1.169 109.95,32.14 109.95,31.01 110.04,30.93 110.38,30.93 110.92,30.38 110.92,29.27 110.8,29.14 110.28,29.14 110.19,29.23 v2(110.19,29.4)
DDR_A_DQS#5: length 64.8
  IN1 w0.091: v2(104.91,64.35) 104.91,65.02 104.76,65.17 104.18,65.17 100.05,61.03 99.81,61.03 97.92,59.14 97.05,59.14 92.12,54.21 89.84,54.21 70.97,35.33 70.97,32.44 70.75,32.22 70.51,32.22 70.39,32.1 70.39,31.71 70.51,31.58 70.65,31.58 70.88,31.36 70.88,30.84 70.65,30.61 70.36,30.61 70.23,30.48 70.23,29.13 70.29,29.07 70.39,29.07 v2(70.67,29.35)
  BOTTOM w0.076: v2(104.91,64.35) 104.93,64.36 104.93,65.26 105.7,66.04 105.7,66.96 105.85,67.11 105.85,67.24 106.1,67.49 106.1,67.7 106.05,67.8 106.03,67.86 106.03,68.06 106.1,68.22 106.1,68.71 106.21,68.82 106.21,68.98 UC1.AV53
  BOTTOM w0.102: JDIMM1.45 70.35,31.17 70.57,30.95 70.57,30.79 71.19,30.17 71.19,29.13 71.03,28.97 70.8,28.97 70.67,29.1 v2(70.67,29.35)
DDR_A_DQS#6: length 70.4
  IN1 w0.091: v2(112.43,73.15) 112.8,72.77 112.8,72.22 112.63,72.05 112.24,72.05 111.94,71.75 111.23,71.75 110.92,71.44 110.92,70.23 110.65,69.96 110.13,69.96 109.54,69.36 109.54,66.24 106.89,63.59 106.89,62.93 97.55,53.59 96.79,53.59 91.67,48.47 89.83,48.47 76.72,35.36 76.72,33.97 76.11,33.37 76.11,27.96 75.96,27.8 75.1,27.8 74.85,27.56 74.85,26.87 75.02,26.7 75.12,26.7 v2(75.43,26.39)
  BOTTOM w0.076: UC1.AL43 112.72,73.15 v2(112.43,73.15)
  BOTTOM w0.102: JDIMM1.62 75.45,24.88 75.83,25.26 75.83,25.41 76.24,25.82 76.24,26.23 75.74,26.72 75.57,26.72 75.43,26.59 v2(75.43,26.39)
DDR_A_DQS#7: length 63.9
  IN4 w0.091: v2(109.57,73.02) 109.13,72.59 109.13,72.2 108.81,71.87 108.2,71.87 107.87,71.54 107.56,71.54 106.99,70.97 106.99,64.65 102.66,60.33 102.66,58.72 101.16,57.22 101.16,47.01 114.42,33.74 114.42,33.08 115.98,31.52 115.98,28.03 115.71,27.77 115.03,27.77 114.92,27.66 114.92,27.2 115.03,27.1 116.48,27.1 116.58,27.2 v2(116.58,27.4)
  BOTTOM w0.089: v2(109.57,73.02) 109.9,73.35 UC1.AL48
  BOTTOM w0.102: JDIMM1.186 115.05,24.93 115.24,25.12 115.24,26.91 115.47,27.14 116.32,27.14 v2(116.58,27.4)
DDR_A_MA0: length 61.1
  IN1 w0.089: v2(116.82,69.29) 116.36,68.83 116.36,67.87 116.45,67.78 116.45,63.79 116.13,63.48 116.13,62.8 114.38,61.05
  IN1 w0.132: v2(89.16,27.03) 88.67,27.52 88.67,28.95 88.11,29.51 88.11,32.66 88.74,33.29 88.74,34.05 93.65,38.97 96.99,38.97 102.07,44.04 103.09,44.04 114.38,55.34 114.38,61.05
  BOTTOM w0.076: UC1.AU36 116.97,69.29 v2(116.82,69.29)
  BOTTOM w0.17: v2(89.16,27.03) 88.65,26.52 JDIMM1.98
DDR_A_MA1: length 62.1
  IN1 w0.089: v2(117,66.6) 116.62,66.23 116.62,63.72 116.34,63.43 116.34,62.59 114.77,61.02
  IN1 w0.132: v2(88.58,30.57) 88.58,31.17 88.71,31.29 89.49,31.29 89.61,31.42 89.61,31.83 89.49,31.95 88.71,31.95 88.58,32.08 88.58,32.49 88.71,32.61 89.47,32.61 89.61,32.76 89.61,34.23 93.9,38.52 97.1,38.52 97.55,38.98 97.74,38.98 98.1,38.61 98.28,38.61 98.57,38.9 98.57,39.08 98.2,39.44 98.2,39.63 98.48,39.91 98.67,39.91 99.04,39.54 99.22,39.54 99.51,39.83 99.51,40.01 99.14,40.38 99.14,40.57 99.42,40.85 99.6,40.85 99.97,40.48 100.15,40.48 100.44,40.76 100.44,40.94 100.07,41.31 100.07,41.5 100.35,41.78 100.54,41.78 100.91,41.41 101.09,41.41 101.37,41.7 101.37,41.88 101.01,42.25 101.01,42.43 101.29,42.71 101.47,42.71 101.84,42.35 102.02,42.35 102.31,42.63 102.31,42.81 101.94,43.18 101.94,43.36 102.23,43.66 102.41,43.66 102.71,43.36 103.04,43.36 114.77,55.09 114.77,61.02
  BOTTOM w0.076: UC1.AY37 116.39,67.17 116.96,66.6 v2(117,66.6)
  BOTTOM w0.17: v2(88.58,30.57) 88.53,30.57 88.35,30.75 88.35,32.14 JDIMM1.97
DDR_A_MA2: length 64.6
  IN1 w0.089: v2(115.79,70.42) 115.83,70.38 115.83,67.65 115.91,67.56 115.91,64.01 115.49,63.59 115.49,62.98 112.55,60.04 112.55,58.36
  IN1 w0.132: v2(87.45,27.02) 87.8,27.38 87.8,27.55 87.7,27.66 87.11,27.66 86.67,28.09 86.67,33.88 93.1,40.3 96.44,40.3 105.72,49.58 106.91,49.58 108.64,51.31 108.64,51.5 108.58,51.56 108.58,51.74 108.86,52.02 109.04,52.02 109.11,51.96 109.29,51.96 109.57,52.25 109.57,52.43 109.51,52.49 109.51,52.67 109.8,52.96 109.98,52.96 110.04,52.89 110.22,52.89 110.51,53.18 110.51,53.36 110.45,53.43 110.45,53.61 110.73,53.89 110.91,53.89 110.98,53.83 111.16,53.83 111.44,54.12 111.44,54.3 111.38,54.36 111.38,54.54 111.67,54.83 111.85,54.83 111.91,54.77 112.09,54.77 112.55,55.22 112.55,58.36
  BOTTOM w0.076: UC1.AR38 116.12,70.75 v2(115.79,70.42)
  BOTTOM w0.17: JDIMM1.96 88.05,26.42 v2(87.45,27.02)
DDR_A_MA3: length 63
  IN1 w0.089: v2(116.74,71.22) 117.13,70.84 117.13,70.4 116.19,69.46 116.19,67.79 116.27,67.71 116.27,63.86 115.93,63.53 115.93,62.92 113.96,60.95 113.96,60.38
  IN1 w0.132: 113.96,60.38 113.96,55.55 102.85,44.43 101.83,44.43 96.81,39.41 93.47,39.41 88.29,34.24 88.29,33.47 87.66,32.84 87.66,29.41 88.17,28.91 88.17,28.68 87.93,28.45 87.75,28.45 v2(87.15,29.05)
  BOTTOM w0.076: UC1.AP36 116.92,71.4 v2(116.74,71.22)
  BOTTOM w0.17: JDIMM1.95 87.75,32.14 87.75,29.65 v2(87.15,29.05)
DDR_A_MA4: length 62.3
  IN1 w0.089: v2(115.25,69.29) 115.55,69.29 115.65,69.18 115.65,67.57 115.74,67.49 115.74,64.08 115.31,63.66 115.31,63.05 112.15,59.9 112.15,58.64
  IN1 w0.132: v2(87.45,25.5) 86.89,25.5 86.61,25.78 86.61,27.53 86.23,27.91 86.23,34.06 92.92,40.75 96.26,40.75 105.48,49.96 106.75,49.96 107.26,50.48 107.26,50.96 112.15,55.86 112.15,58.64
  BOTTOM w0.076: UC1.AU39 115.39,69.29 v2(115.25,69.29)
  BOTTOM w0.17: JDIMM1.92 86.85,24.9 v2(87.45,25.5)
DDR_A_MA5: length 63.1
  IN1 w0.089: 112.93,59.17 112.93,60.17 115.67,62.91 115.67,63.52 116.09,63.94 116.09,67.64 116.01,67.72 116.01,69.84 v2(116.74,70.57)
  IN1 w0.132: v2(87.15,30.57) 87.15,33.03 87.33,33.22 87.41,33.22 87.85,33.66 87.85,34.42 93.28,39.86 96.54,39.86 102.09,45.4 102.28,45.4 102.68,45 102.88,45 103.14,45.27 103.14,45.47 102.74,45.87 102.74,46.06 103.02,46.34 103.21,46.34 103.61,45.94 103.8,45.94 104.08,46.22 104.08,46.41 103.68,46.81 103.68,46.99 103.96,47.27 104.15,47.27 104.55,46.87 104.73,46.87 105.01,47.15 105.01,47.34 104.61,47.74 104.61,47.93 104.89,48.21 105.08,48.21 105.49,47.8 105.67,47.8 105.96,48.08 105.96,48.26 105.54,48.68 105.54,48.86 105.88,49.19 106.06,49.19 106.43,48.82 106.69,48.82 112.93,55.06 112.93,59.17
  BOTTOM w0.089: v2(116.74,70.57) 116.92,70.75 UC1.AR36
  BOTTOM w0.17: JDIMM1.91 86.55,32.14 86.55,31.17 v2(87.15,30.57)
DDR_A_MA6: length 62.8
  IN1 w0.089: 111.74,58.53 111.93,58.73 111.93,59.92 115.14,63.13 115.14,63.74 115.56,64.16 115.56,65.62 v2(115.21,65.97)
  IN1 w0.132: v2(85.65,25.5) 86.22,26.07 86.22,27.28 85.78,27.72 85.78,34.24 92.73,41.19 96.07,41.19 105.73,50.84 105.91,50.84 106.41,50.35 106.59,50.35 106.87,50.64 106.87,50.82 106.36,51.33 106.36,51.48 106.68,51.8 106.83,51.8 107.07,51.55 107.3,51.55 111.74,55.99 111.74,58.53
  BOTTOM w0.076: UC1.AV40 114.53,68.64 114.53,66.65 v2(115.21,65.97)
  BOTTOM w0.17: JDIMM1.90 86.25,23.94 86.25,24.9 v2(85.65,25.5)
DDR_A_MA7: length 63.2
  IN1 w0.089: 112.49,61.27 114.6,63.38 114.6,67.35 v2(115.23,67.99)
  IN1 w0.132: 112.49,61.27 112.19,61.27 110.33,59.42 110.33,56.22 107.69,53.58 106.83,53.58 101.15,47.91 99.73,47.91 99.45,47.62 99.45,47.44 99.97,46.92 99.97,46.73 99.69,46.45 99.5,46.45 98.68,47.27 98.49,47.27 93.74,42.52 92.18,42.52 83.94,34.29 83.94,28.93 85.65,27.23 v2(85.65,27.02)
  BOTTOM w0.076: v2(115.23,67.99) 115.25,67.99 115.55,68.29 UC1.AW39
  BOTTOM w0.17: v2(85.65,27.02) 85.05,26.42 JDIMM1.86
DDR_A_MA8: length 61.7
  IN1 w0.089: v2(115.24,67.29) 114.78,66.83 114.78,63.28 112.45,60.95 112.19,60.95 110.72,59.49 110.72,58.36
  IN1 w0.132: v2(85.27,29.05) 84.51,29.05 84.39,29.18 84.39,34.11 92.36,42.08 93.85,42.08 97.47,45.7 97.65,45.7 98.48,44.87 98.66,44.87 98.95,45.16 98.95,45.34 98.12,46.17 98.12,46.35 98.4,46.63 98.59,46.63 99.41,45.8 99.59,45.8 106.99,53.2 107.85,53.2 110.72,56.06 110.72,58.36
  BOTTOM w0.076: UC1.AY39 115.59,67.64 v2(115.24,67.29)
  BOTTOM w0.17: v2(85.27,29.05) 85.95,29.73 85.95,32.14 JDIMM1.89
DDR_A_MA9: length 63.8
  IN1 w0.089: 111.11,58.66 111.11,59.62 112.18,60.69 112.45,60.69 114.96,63.2 114.96,64.21 v2(115.18,64.43)
  IN1 w0.132: v2(85.27,30.57) 84.77,31.07 84.77,33.86 92.55,41.64 93.95,41.64 94.57,42.26 94.76,42.26 95.43,41.58 95.61,41.58 95.9,41.86 95.9,42.04 95.22,42.72 95.22,42.91 95.5,43.19 95.69,43.19 96.52,42.36 96.7,42.36 96.99,42.65 96.99,42.83 96.16,43.66 96.16,43.84 96.44,44.12 96.62,44.12 97.45,43.3 97.63,43.3 97.92,43.58 97.92,43.76 97.42,44.27 97.42,44.45 97.7,44.73 97.88,44.73 98.39,44.23 98.57,44.23 107.15,52.81 108.01,52.81 111.11,55.9 111.11,58.66
  BOTTOM w0.076: UC1.AU40 114.63,69.44 114.63,69.38 114.36,69.11 114.36,65.25 v2(115.18,64.43)
  BOTTOM w0.17: JDIMM1.85 84.75,32.14 84.75,31.1 v2(85.27,30.57)
DDR_A_MA10: length 62.9
  IN1 w0.089: v2(117.7,71.07) 117.32,70.69 117.32,69.7 117.96,69.06 117.96,62.6 117.92,62.56 117.92,61.86 117.08,61.01
  IN1 w0.132: v2(92.3,29.05) 91.93,29.05 91.8,29.18 91.8,31.93 91.93,32.05 92.78,32.05 92.91,32.18 92.91,34.44 93.52,35.05 93.7,35.05 94.25,34.5 94.43,34.5 94.72,34.79 94.72,34.97 94.17,35.52 94.17,35.7 94.45,35.98 94.63,35.98 95.13,35.49 95.41,35.49 96.27,36.34 99.11,36.34 116.95,54.19 116.95,60.89 117.08,61.01
  BOTTOM w0.076: UC1.AP35 118.02,71.4 v2(117.7,71.07)
  BOTTOM w0.17: JDIMM1.107 91.35,32.14 91.35,30 v2(92.3,29.05)
DDR_A_MA11: length 62.2
  IN1 w0.089: 111.75,61.62 111.91,61.78 112.48,61.78 114.25,63.55 114.25,65.56 114.05,65.75 114.05,67.52 113.66,67.91 v2(113.66,67.99)
  IN1 w0.132: v2(83.85,25.5) 84.33,25.97 84.33,27.9 82.9,29.33 82.9,32.73 82.46,33.16 82.46,34.07 91.81,43.41 93.54,43.41 97.38,47.25 97.38,47.25 98.89,48.76 99.98,48.76 105.57,54.36 107.37,54.36 109.56,56.54 109.56,59.43 111.75,61.62
  BOTTOM w0.076: v2(113.66,67.99) 113.67,67.99 113.97,68.29 UC1.AW41
  BOTTOM w0.17: JDIMM1.84 84.45,23.94 84.45,24.9 v2(83.85,25.5)
DDR_A_MA12: length 62.8
  IN1 w0.089: v2(113.67,69.29) 114.05,68.91 114.05,67.77 114.23,67.59 114.23,65.83 114.42,65.63 114.42,63.48 112.52,61.57 112.08,61.57 111.98,61.47
  IN1 w0.132: v2(83.37,30.57) 83.34,30.61 83.34,32.92 82.91,33.35 82.91,33.88 91.99,42.97 93.64,42.97 98.97,48.29 100.05,48.29 100.89,49.13 101.07,49.13 101.36,48.85 101.54,48.85 101.82,49.13 101.82,49.31 101.54,49.59 101.54,49.78 101.82,50.06 102.01,50.06 102.29,49.78 102.48,49.78 102.76,50.06 102.76,50.25 102.48,50.53 102.48,50.71 102.76,50.99 102.94,50.99 103.22,50.71 103.41,50.71 103.69,50.99 103.69,51.18 103.41,51.46 103.41,51.65 103.69,51.93 103.88,51.93 104.16,51.65 104.35,51.65 104.63,51.93 104.63,52.12 104.34,52.4 104.34,52.58 104.62,52.86 104.81,52.86 105.09,52.58 105.28,52.58 105.56,52.86 105.56,53.05 105.28,53.33 105.28,53.52 105.73,53.97 107.53,53.97 109.95,56.38 109.95,59.44 111.98,61.47
  BOTTOM w0.089: UC1.AU41 113.82,69.29 v2(113.67,69.29)
  BOTTOM w0.17: v2(83.37,30.57) 83.48,30.57 84.15,31.24 JDIMM1.83
DDR_A_MA13: length 64.3
  IN1 w0.089: v2(117.7,70.42) 118.1,70.02 118.22,70.02 119.72,68.52 119.72,61.3 119.27,60.86
  IN1 w0.132: v2(94.35,27.53) 94.77,27.95 94.77,30.45 98.35,34.02 101.18,34.02 109.11,41.95 109.3,41.95 109.81,41.44 110,41.44 110.28,41.72 110.28,41.9 109.76,42.42 109.76,42.6 110.04,42.89 110.23,42.89 110.75,42.37 110.93,42.37 117.77,49.21 117.77,51.72 119.27,53.23 119.27,60.86
  BOTTOM w0.076: UC1.AR35 118.02,70.75 v2(117.7,70.42)
  BOTTOM w0.17: v2(94.35,27.53) 94.95,28.12 94.95,32.14 JDIMM1.119
DDR_A_MA14: length 62.8
  IN1 w0.089: 111.22,61.68 113.39,63.85 113.39,64.48 113.66,64.75 113.93,64.75 114.06,64.89 114.06,65.48 113.67,65.87 v2(113.67,65.98)
  IN1 w0.132: 111.22,61.68 108.63,59.09 108.63,56.16 107.21,54.74 105.41,54.74 99.82,49.15 98.73,49.15 93.44,43.86 91.63,43.86 82.02,34.25 82.02,32.98 82.45,32.55 82.45,28.42 v2(83.85,27.02)
  BOTTOM w0.076: UC1.AV42 112.95,68.64 112.95,67.29 113.26,66.97 113.26,66.39 v2(113.67,65.98)
  BOTTOM w0.17: v2(83.85,27.02) 83.25,26.42 83.25,23.94 JDIMM1.80
DDR_A_MA15: length 63.2
  IN1 w0.132: v2(113.67,65.33) 113.18,64.85 113.18,63.95 110.43,61.2 108.24,59.01 108.24,56.32 107.05,55.13 105.25,55.13 99.66,49.54 98.57,49.54 93.34,44.3 91.44,44.3 81.57,34.44 81.57,32.8 82.01,32.36 82.01,27.58 v2(81.45,27.02)
  BOTTOM w0.076: UC1.AU42 113.05,69.44 113.05,69.38 112.79,69.11 112.79,67.15 113.1,66.83 113.1,65.91 v2(113.67,65.33)
  BOTTOM w0.17: JDIMM1.78 82.65,25.82 v2(81.45,27.02)
DDR_A_RAS#: length 63
  IN1 w0.089: v2(118.4,67.29) 119.14,66.54 119.14,61.81 118.11,60.78
  IN1 w0.132: 118.11,60.78 118.11,53.71 114.46,50.06 114.46,49.87 114.83,49.5 114.83,49.31 114.55,49.03 114.36,49.03 113.99,49.4 113.81,49.4 113.53,49.12 113.53,48.93 113.9,48.56 113.9,48.38 113.62,48.1 113.43,48.1 113.06,48.47 112.87,48.47 112.59,48.19 112.59,48 112.96,47.63 112.96,47.44 112.68,47.16 112.5,47.16 112.12,47.53 111.94,47.53 111.66,47.25 111.66,47.07 112.03,46.7 112.03,46.51 111.75,46.23 111.56,46.23 111.19,46.6 111,46.6 110.72,46.32 110.72,46.13 111.09,45.76 111.09,45.57 100.7,35.18 96.75,35.18 94.24,32.68 94.24,31.61 93.43,30.8 93.43,26.08 v2(92.85,25.5)
  BOTTOM w0.076: v2(118.4,67.29) 118.75,67.64 UC1.AY34
  BOTTOM w0.17: v2(92.85,25.5) 92.25,24.9 JDIMM1.110
