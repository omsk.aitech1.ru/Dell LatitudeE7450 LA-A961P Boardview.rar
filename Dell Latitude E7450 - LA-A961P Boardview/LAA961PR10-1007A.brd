# Allegro board LAA961PR10-1007A.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_A_WE#: length 63.5
  IN1 w0.089: 118.5,60.77 119.33,61.6 119.33,67.03 v2(118.38,67.99)
  IN1 w0.132: v2(94.35,29.05) 93.87,29.53 93.87,30.69 95.19,32.01 95.19,32.31 94.9,32.6 94.9,32.78 95.14,33.03 95.32,33.03 95.7,32.66 95.89,32.66 96.17,32.94 96.17,33.12 95.79,33.5 95.79,33.68 96.4,34.29 96.58,34.29 96.84,34.03 97.26,34.03 98.03,34.79 100.86,34.79 114.85,48.78 115.14,48.78 115.61,48.32 115.79,48.32 116.08,48.61 116.08,48.79 115,49.87 115,50.05 115.29,50.34 115.47,50.34 116.52,49.29 116.7,49.29 117,49.58 117,49.76 115.95,50.8 115.95,51 118.5,53.55 118.5,60.77
  BOTTOM w0.076: UC1.AW34 118.7,68.29 118.4,67.99 v2(118.38,67.99)
  BOTTOM w0.17: JDIMM1.113 93.15,31.11 93.86,30.41 93.86,29.54 v2(94.35,29.05)
DDR_B_BS0: length 101.7
  IN4 w0.089: 117.63,62.36 117.63,69.42 117.32,69.74 117.32,72.64 v2(117.7,73.02)
  IN4 w0.102: 116.73,61.46 117.63,62.36
  IN4 w0.132: 116.73,61.46 116.73,53.72 116.73,53.72 116.73,53.13 130.15,39.71 149.68,39.71 149.81,39.58 149.81,37.61 149.94,37.48 150.37,37.48 150.49,37.61 150.49,39.58 150.62,39.71 151.02,39.71 151.15,39.58 151.15,37.61 151.28,37.48 151.69,37.48 151.81,37.61 151.81,39.58 151.95,39.71 152.34,39.71 152.47,39.58 152.47,37.61 152.6,37.48 162.45,37.48 162.86,37.07 163.02,37.07 163.43,37.48 163.57,37.48 163.95,37.1 163.95,36.96 163.56,36.56 163.56,36.37 163.84,36.09 164.02,36.09 164.71,36.77 164.88,36.77 165.17,36.49 165.17,36.31 164.49,35.63 164.49,35.44 164.77,35.16 164.96,35.16 165.64,35.84 165.82,35.84 166.11,35.55 166.11,35.37 165.43,34.69 165.43,34.51 165.71,34.23 165.89,34.23 166.46,34.79 166.64,34.79 167.44,33.99 167.44,33.81 166.68,33.05 166.68,32.6 168.61,30.67 v2(168.61,30.57)
  BOTTOM w0.076: v2(117.7,73.02) 118.02,73.35 UC1.AL35
  BOTTOM w0.17: v2(168.61,30.57) 168.4,30.57 167.95,31.03 JDIMM2.109
DDR_B_BS1: length 101.7
  IN4 w0.089: v2(116.74,72.52) 117.13,72.14 117.13,69.66 117.39,69.4 117.39,62.49
  IN4 w0.132: v2(167.56,26.14) 167.56,23.66 167.43,23.54 166.25,23.54 166.12,23.66 166.12,24.2 166.25,24.32 166.63,24.32 166.76,24.45 166.76,24.93 166.63,25.06 166.26,25.06 166.13,25.19 166.13,25.71 166.26,25.84 166.67,25.84 166.79,25.96 166.79,26.34 166.67,26.47 166.26,26.47 166.13,26.6 166.13,27.04 166.26,27.17 167.01,27.17 167.13,27.3 167.13,27.8 167.01,27.93 166.46,27.93 166.33,28.06 166.33,28.5 166.46,28.63 167.01,28.63 167.13,28.76 167.13,29.26 167.26,29.39 168,29.39 168.13,29.52 168.13,30.6 166.29,32.44 166.29,33.1 162.29,37.1 149.55,37.1 149.42,37.22 149.42,39.2 149.3,39.32 129.88,39.32 116.28,52.93 116.28,61.37 117.39,62.49
  BOTTOM w0.076: v2(116.74,72.52) 116.92,72.7 UC1.AM36
  BOTTOM w0.17: v2(167.56,26.14) 167.65,26.05 JDIMM2.108
DDR_B_BS2: length 98.3
  IN4 w0.089: 106.97,60.43 108.46,61.92 108.46,65.18 109.58,66.3 109.58,69.07 109.39,69.26 v2(108.95,69.26)
  IN4 w0.132: 106.97,60.43 106.97,48.91 107.58,48.3 107.97,48.3 108.3,47.97 108.3,47.79 107.88,47.36 107.88,47.18 108.2,46.86 108.38,46.86 108.79,47.27 108.97,47.27 109.25,46.99 109.25,46.81 108.83,46.38 108.83,46.23 129.35,25.71 130.99,25.71 131.12,25.58 131.12,24.62 131.25,24.49 131.7,24.49 131.85,24.64 131.85,25.56 132.01,25.71 132.43,25.71 132.58,25.56 132.58,24.55 132.73,24.4 155.16,24.4 155.26,24.5 155.26,24.7 155.38,24.82 156.01,24.82 156.13,24.7 156.13,24.52 156.25,24.4 157.88,24.4 159.03,25.55 159.03,27.12 158.54,27.61 v2(158.54,27.77)
  BOTTOM w0.076: UC1.AU49 109.07,69.26 v2(108.95,69.26)
  BOTTOM w0.17: v2(158.54,27.77) 158.08,28.24 158.08,29.72 158.95,30.59 JDIMM2.79
DDR_B_CAS#: length 101.9
  IN4 w0.089: 118.95,62.09 118.95,64.75 119.02,64.82 119.02,72.06 v2(118.65,72.44)
  IN4 w0.132: v2(170.2,30.57) 170.2,30.72 168.6,32.32 168.6,34.7 168.55,34.74 168.55,34.93 169.08,35.46 169.08,35.65 168.8,35.93 168.61,35.93 168.08,35.4 167.9,35.4 167.62,35.68 167.62,35.87 168.15,36.39 168.15,36.58 167.87,36.86 167.68,36.86 167.15,36.33 166.96,36.33 166.68,36.61 166.68,36.8 167.21,37.33 167.21,37.52 166.93,37.8 166.74,37.8 166.22,37.27 166.03,37.27 165.75,37.55 165.75,37.73 166.28,38.26 166.28,38.45 165.88,38.84 165.7,38.84 165.41,38.55 165.26,38.55 164.94,38.88 164.94,39.02 165.23,39.31 165.23,39.5 164.93,39.79 164.43,39.79 164.29,39.66 164.29,38.74 164.19,38.64 163.74,38.64 163.63,38.74 163.63,39.66 163.5,39.79 163.11,39.79 162.98,39.66 162.98,38.74 162.88,38.64 162.42,38.64 162.32,38.74 162.32,39.66 162.19,39.79 161.79,39.79 161.66,39.66 161.66,38.74 161.56,38.64 161.1,38.64 161,38.74 161,39.66 160.87,39.79 160.47,39.79 160.34,39.66 160.34,39.36 160.21,39.23 159.81,39.23 159.68,39.36 159.68,39.66 159.54,39.79 159.15,39.79 159.02,39.66 159.02,39.36 158.88,39.23 158.49,39.23 158.36,39.36 158.36,39.66 158.22,39.79 157.83,39.79 157.7,39.66 157.7,39.36 157.56,39.23 156.92,39.23 155.29,40.87 131.03,40.87 130.26,41.64 130.26,41.82 130.7,42.27 130.7,42.45 130.42,42.73 130.24,42.73 129.79,42.29 129.61,42.29 118.18,53.72 118.18,61.31 118.95,62.09
  BOTTOM w0.076: v2(118.65,72.44) 118.91,72.7 UC1.AM33
  BOTTOM w0.17: v2(170.2,30.57) 169.75,31.02 JDIMM2.115
DDR_B_D0: length 86.5
  IN4 w0.084: v2(173.43,27.63) 174.14,28.34 174.14,32.05 173.63,32.56 173.63,35.21 166.14,42.7 157.94,42.7 156.86,43.78 136.88,43.78 134.84,45.82 130.19,45.82 121.08,54.93 121.08,59.8 121.08,59.81 121.08,61.85 v2(120.5,62.43)
  BOTTOM w0.076: v2(120.5,62.43) 119.73,63.19 119.73,66.68 119.91,66.86 119.91,67.51 UC1.AY31
  BOTTOM w0.102: JDIMM2.132 174.85,26.21 v2(173.43,27.63)
DDR_B_D1: length 87.6
  IN4 w0.084: v2(173.43,29.16) 173.43,29.17 173.82,29.56 173.82,31.16 173.74,31.25 173.25,31.25 173.13,31.37 173.13,31.66 173.21,31.74 173.52,31.74 173.65,31.86 173.65,32.09 173.5,32.25 173.26,32.25 173.13,32.38 173.13,35.27 166.01,42.39 157.81,42.39 156.73,43.46 135.23,43.46 135.15,43.55 135.15,45.07 134.84,45.38 130.19,45.38 120.77,54.8 120.77,60 120.89,60.11 120.89,61.71 120.82,61.78 v2(120.5,61.78)
  BOTTOM w0.076: v2(120.5,61.78) 120.08,61.78 119.56,62.29 119.56,66.74 119.75,66.93 119.75,67.71 119.84,67.88 120.04,68.08 UC1.AW31
  BOTTOM w0.102: v2(173.43,29.16) 174.29,29.16 174.55,29.42 JDIMM2.131
DDR_B_D2: length 87.4
  IN4 w0.084: v2(122.12,61.78) 122.54,61.36 122.54,59.81 123.11,59.23 123.11,55.94 131.25,47.81 135.67,47.81 137.66,45.81 157.64,45.81 158.76,44.69 167.18,44.69 175.64,36.23 175.64,34.3 176.14,33.8 176.14,31.21 176.81,30.54 176.81,27.04 v2(175.77,26)
  BOTTOM w0.076: UC1.AY29 121.39,66.63 121.28,66.51 121.28,62.62 v2(122.12,61.78)
  BOTTOM w0.102: JDIMM2.140 177.25,25.16 176.41,26 v2(175.77,26)
DDR_B_D3: length 88.2
  IN4 w0.084: v2(122.12,62.43) 122.12,62.42 122.79,61.75 122.79,59.87 123.42,59.24 123.42,56.07 131.38,48.12 135.8,48.12 137.79,46.13 157.77,46.13 158.89,45 167.46,45 175.95,36.51 175.95,34.43 176.45,33.93 176.45,31.34 177.43,30.36 177.43,30.06 177.51,29.98 178.01,29.98 178.14,29.85 178.14,29.61 178.01,29.49 177.51,29.49 177.43,29.4 177.43,28.9 177.56,28.77 178.47,28.77 178.59,28.9 v2(178.59,29.05)
  BOTTOM w0.076: v2(122.12,62.43) 121.45,63.1 121.45,66.42 121.56,66.53 121.56,67.39 121.69,67.51 121.69,67.76 121.39,68.05 UC1.AW29
  BOTTOM w0.102: JDIMM2.141 177.55,30.09 v2(178.59,29.05)
DDR_B_D4: length 88.2
  IN4 w0.084: v2(120.5,61.13) 120.46,61.09 120.46,60.94 120.13,60.61 120.13,60.3 120.46,59.97 120.46,54.67 130.06,45.06 132.71,45.06 132.79,44.98 132.79,44.33 132.92,44.2 133.16,44.2 133.28,44.33 133.28,44.98 133.37,45.06 133.72,45.06 133.84,44.94 133.84,43.28 133.97,43.15 134.26,43.15 134.35,43.23 134.35,44.94 134.47,45.06 134.71,45.06 134.84,44.94 134.84,43.23 134.92,43.15 156.6,43.15 157.68,42.07 165.88,42.07 172.82,35.14 172.82,31.24 173.38,30.68 v2(173.43,30.68)
  BOTTOM w0.076: 119.66,67.89 119.66,68.55 UC1.AV31 ; 119.66,67.89 119.66,67.89 119.66,67.89 ; 119.66,67.89 119.58,67.75 119.58,67 119.4,66.81 119.4,62.22 v2(120.5,61.13)
  BOTTOM w0.102: v2(173.43,30.68) 173.95,31.21 JDIMM2.129
DDR_B_D5: length 89.2
  IN4 w0.084: v2(173.43,26.11) 174.45,27.13 174.45,32.18 173.94,32.69 173.94,35.34 166.27,43.01 158.07,43.01 156.99,44.09 137.01,44.09 134.97,46.13 130.32,46.13 121.4,55.05 121.4,59.81 121.33,59.87 121.33,62.89 v2(120.5,63.73)
  BOTTOM w0.076: v2(120.5,63.73) 120.92,64.15 120.92,66.67 121.04,66.79 121.04,67.2 120.94,67.3 120.94,67.74 120.96,67.79 120.96,67.79 121.01,67.9 121.01,68.03 120.94,68.18 120.94,68.39 120.96,68.44 121,68.53 121.01,68.54 121.01,68.73 120.99,68.75 120.99,69.13 121.01,69.14 121.01,69.38 120.81,69.59 UC1.AU31
  BOTTOM w0.102: JDIMM2.130 174.25,25.29 v2(173.43,26.11)
DDR_B_D6: length 88.5
  IN4 w0.084: v2(175.77,27.53) 176.5,28.26 176.5,30.41 175.83,31.08 175.83,33.67 175.33,34.17 175.33,36.1 167.05,44.38 158.63,44.38 157.51,45.5 137.53,45.5 135.54,47.49 131.12,47.49 122.8,55.82 122.8,59.23 122.12,59.9 v2(122.12,60.48)
  BOTTOM w0.076: UC1.AV29 121.2,68.85 121.2,68.51 121.15,68.46 121.1,68.35 121.1,68.22 121.11,68.2 121.15,68.12 121.15,68.12 121.17,68.06 121.17,67.86 121.1,67.7 121.1,67.37 121.2,67.27 121.2,66.68 121.1,66.57 121.1,61.5 v2(122.12,60.48)
  BOTTOM w0.102: v2(175.77,27.53) 177.85,25.45 JDIMM2.142
DDR_B_D7: length 89.3
  IN4 w0.084: v2(178.59,30.57) 177.86,30.57 177.74,30.7 177.74,31.3 177.61,31.43 176.89,31.43 176.77,31.56 176.77,31.79 176.89,31.92 177.66,31.92 177.74,32 177.74,32.32 177.66,32.41 176.89,32.41 176.77,32.54 176.77,32.77 176.89,32.9 177.66,32.9 177.74,32.98 177.74,33.77 177.68,33.84 176.98,33.84 176.26,34.56 176.26,36.64 167.59,45.31 159.02,45.31 157.9,46.44 137.92,46.44 135.93,48.43 131.51,48.43 123.73,56.2 123.73,59.18 123.04,59.87 123.04,62.15 v2(122.12,63.08)
  BOTTOM w0.076: v2(122.12,63.08) 121.61,63.59 121.61,66.34 121.72,66.45 121.72,67.32 121.85,67.45 121.85,67.83 121.69,67.99 121.69,68.41 121.56,68.53 121.56,68.8 121.58,68.82 121.58,69.06 121.29,69.35 UC1.AU29
  BOTTOM w0.102: JDIMM2.143 178.15,30.97 177.91,30.73 177.91,30.35 178.06,30.21 178.23,30.21 v2(178.59,30.57)
DDR_B_D8: length 60.3
  IN1 w0.084: v2(135.09,29.05) 134.7,29.45 134.7,30.53 134.04,31.19 132.4,32.82 132.4,33.68 132.03,34.06 130.31,35.78 130.16,35.78 129.66,35.28 129.49,35.28 129.32,35.45 129.32,35.63 129.8,36.1 129.8,36.28 129.63,36.45 129.45,36.45 128.63,35.63 128.51,35.63 128.28,35.86 128.28,35.98 129.1,36.8 129.1,36.98 128.94,37.14 128.76,37.14 127.94,36.32 127.82,36.32 127.59,36.55 127.59,36.67 128.41,37.49 128.41,37.67 128.24,37.84 128.06,37.84 127.24,37.02 127.13,37.02 126.9,37.25 126.9,37.36 127.72,38.18 127.72,38.36 127.55,38.53 127.37,38.53 126.55,37.71 126.43,37.71 126.2,37.94 126.2,38.06 126.57,38.42 126.57,38.6 126.4,38.77 126.22,38.77 125.86,38.4 125.74,38.4 121.85,42.3 121.85,60.19 121.73,60.31 121.73,63.98 v2(122.12,64.38)
  BOTTOM w0.076: v2(122.12,64.38) 122.68,64.94 122.68,66.05 122.23,66.5 122.23,67.13 122.35,67.24 122.35,67.51 UC1.AY27
  BOTTOM w0.102: JDIMM2.5 134.35,29.79 v2(135.09,29.05)
DDR_B_D9: length 60.8
  IN1 w0.084: v2(135.25,22.41) 134.34,23.31 134.34,30.44 132.35,32.43 131.42,33.37 131.3,33.37 131.08,33.15 130.99,33.15 130.79,33.36 130.79,33.5 131.39,34.1 131.39,34.25 131.19,34.45 131.04,34.45 130.13,33.54 130.01,33.54 129.78,33.76 129.78,33.88 130.7,34.8 130.7,34.94 130.49,35.15 130.35,35.15 129.43,34.23 129.32,34.23 129.09,34.46 129.09,34.58 129.36,34.85 129.36,34.96 129.13,35.19 129.01,35.19 128.74,34.92 128.62,34.92 121.53,42.01 121.53,64.44 v2(122.12,65.03)
  BOTTOM w0.076: v2(122.12,65.03) 122.52,65.42 122.52,65.98 122.07,66.43 122.07,67.19 122.18,67.31 122.18,67.76 122.47,68.05 UC1.AW27
  BOTTOM w0.102: v2(135.25,22.41) 134.65,23.01 JDIMM2.6
DDR_B_D10: length 60
  IN1 w0.084: v2(136.62,30.57) 136.62,30.97 134.31,33.29 134.31,33.61 134.8,34.11 134.8,34.29 134.04,35.05 133.87,35.05 133.69,34.88 133.58,34.88 133.35,35.11 133.35,35.22 133.63,35.51 133.63,35.62 133.4,35.85 133.28,35.85 133,35.57 132.88,35.57 132.65,35.8 132.65,35.92 132.93,36.2 132.93,36.32 132.71,36.55 132.59,36.55 132.31,36.26 132.19,36.26 131.96,36.49 131.96,36.61 132.24,36.89 132.24,37.01 132.01,37.24 131.89,37.24 131.61,36.96 131.5,36.96 131.27,37.19 131.27,37.3 131.55,37.59 131.55,37.7 131.32,37.93 131.2,37.93 130.92,37.65 130.8,37.65 130.57,37.88 130.57,38 130.85,38.28 130.85,38.4 130.63,38.63 130.51,38.63 130.23,38.34 130.11,38.34 129.88,38.57 129.88,38.69 130.16,38.97 130.16,39.09 129.93,39.32 129.81,39.32 129.53,39.04 129.41,39.04 129.19,39.27 129.19,39.38 129.47,39.67 129.47,39.78 129.24,40.01 129.12,40.01 128.84,39.73 128.72,39.73 128.49,39.96 128.49,40.08 128.77,40.36 128.77,40.48 128.55,40.71 128.43,40.71 128.15,40.42 128.03,40.42 127.8,40.65 127.8,40.77 128.08,41.05 128.08,41.17 127.85,41.4 127.73,41.4 127.45,41.12 127.33,41.12 127.11,41.35 127.11,41.46 127.39,41.75 127.39,41.86 127.16,42.09 127.04,42.09 126.76,41.81 126.64,41.81 126.41,42.04 126.41,42.16 126.69,42.44 126.69,42.56 126.47,42.79 126.35,42.79 126.07,42.5 125.95,42.5 125.72,42.73 125.72,42.85 126,43.13 126,43.25 125.77,43.48 125.65,43.48 125.37,43.2 125.25,43.2 125.03,43.43 125.03,43.54 125.31,43.83 125.31,43.94 125.08,44.17 124.96,44.17 124.68,43.89 124.56,43.89 124.33,44.12 124.33,44.24 124.61,44.52 124.61,44.64 124.39,44.87 124.27,44.87 123.99,44.59 123.87,44.59 123.52,44.93 123.52,61.97 123.62,62.07 123.91,62.07 v2(124.21,61.78)
  BOTTOM w0.076: v2(124.21,61.78) 124.6,62.17 124.6,65.84 124.14,66.3 124.12,66.3 123.7,66.73 123.7,67.51 UC1.AY25
  BOTTOM w0.102: v2(136.62,30.57) 137.35,31.3 JDIMM2.15
DDR_B_D11: length 61.2
  IN1 w0.084: v2(124.21,61.13) 123.83,60.75 123.83,59.17 123.84,59.16 123.84,47.42 123.92,47.34 124.7,47.34 124.78,47.25 124.78,46.93 124.7,46.85 123.92,46.85 123.84,46.76 123.84,46.44 123.92,46.36 124.7,46.36 124.78,46.27 124.78,45.95 124.7,45.87 123.92,45.87 123.84,45.78 123.84,45.32 123.97,45.18 124.52,45.18 124.86,44.84 124.97,44.84 125.45,45.31 125.56,45.31 125.79,45.08 125.79,44.97 125.32,44.49 125.32,44.37 125.55,44.15 125.67,44.15 126.14,44.62 126.26,44.62 126.49,44.39 126.49,44.27 126.01,43.8 126.01,43.68 126.24,43.45 126.36,43.45 126.83,43.92 126.95,43.92 127.18,43.7 127.18,43.58 126.71,43.11 126.71,42.99 126.94,42.76 127.05,42.76 127.53,43.23 127.64,43.23 127.91,42.96 127.91,42.84 127.42,42.35 127.42,42.27 135.37,34.32 135.37,33.16 135.19,32.98 135.19,32.86 135.42,32.63 135.54,32.63 135.79,32.89 135.97,32.89 136.14,32.72 136.14,32.54 135.89,32.29 135.89,32.17 136.12,31.94 136.23,31.94 136.49,32.19 136.67,32.19 136.89,31.97 136.89,31.79 136.64,31.55 136.64,31.4 137.02,31.02 137.02,29.2 136.87,29.05 v2(136.62,29.05)
  BOTTOM w0.076: v2(124.21,61.13) 124.76,61.68 124.76,65.91 124.21,66.47 124.19,66.47 123.86,66.8 123.86,67.26 124.12,67.51 124.12,67.7 124.07,67.8 124.07,67.81 124.04,67.86 124.04,68.07 UC1.AW25
  BOTTOM w0.102: v2(136.62,29.05) 137.95,30.38 JDIMM2.17
DDR_B_D12: length 61.4
  IN1 w0.084: v2(122.12,65.68) 121.22,64.78 121.22,41.88 130.07,33.03 130.19,33.03 130.37,33.21 130.49,33.21 130.72,32.98 130.72,32.86 130.54,32.68 130.54,32.57 130.77,32.34 130.88,32.34 131.37,32.83 131.52,32.83 131.72,32.62 131.72,32.48 131.23,31.99 131.23,31.87 131.46,31.64 131.58,31.64 132.07,32.13 132.21,32.13 132.41,31.93 132.41,31.78 131.92,31.3 131.92,31.18 132.15,30.95 132.27,30.95 132.76,31.44 132.9,31.44 133.11,31.23 133.11,31.09 132.62,30.6 132.62,30.49 132.85,30.26 132.96,30.26 133.45,30.74 133.6,30.74 133.8,30.54 133.8,30.4 133.45,30.05 133.45,29.19 133.37,29.1 132.83,29.1 132.74,29.02 132.74,28.7 132.83,28.61 133.37,28.61 133.45,28.53 133.45,28.21 133.37,28.12 132.83,28.12 132.74,28.04 132.74,27.72 132.83,27.63 133.37,27.63 133.45,27.55 133.45,27.23 133.37,27.14 132.83,27.14 132.74,27.06 132.74,26.74 132.83,26.65 133.37,26.65 133.45,26.57 v2(133.45,26.1)
  BOTTOM w0.076: UC1.AV27 122.58,68.81 122.18,68.41 122.18,68 122.02,67.83 122.02,67.38 121.89,67.25 121.89,66.34 122.12,66.11 v2(122.12,65.68)
  BOTTOM w0.102: JDIMM2.4 134.05,25.5 v2(133.45,26.1)
DDR_B_D13: length 62.3
  IN1 w0.084: v2(138.85,20.88) 139.25,21.28 139.25,22.57 138.19,23.63 138.19,26.29 138.32,26.42 138.52,26.42 138.65,26.55 138.65,26.77 138.52,26.9 138.04,26.9 137.91,27.02 137.91,27.26 138.04,27.39 138.46,27.39 138.59,27.51 138.59,27.74 138.46,27.87 137.77,27.87 137.65,27.99 137.65,32.31 136.53,33.43 136.53,34.05 128.83,41.75 128.83,42.93 125.4,46.36 125.4,48.56 124.46,49.51 124.46,58.43 125.09,59.06 125.09,60.08 124.58,60.59 124.58,64.65 v2(124.21,65.03)
  BOTTOM w0.076: v2(124.21,65.03) 123.78,65.45 123.78,65.78 123.37,66.2 123.37,67.74 123.44,67.9 123.44,68.03 123.37,68.18 123.37,68.39 123.39,68.44 123.43,68.53 123.44,68.54 123.44,69.38 123.24,69.59 UC1.AU27
  BOTTOM w0.102: JDIMM2.16 137.65,22.08 v2(138.85,20.88)
DDR_B_D14: length 61.5
  IN1 w0.084: v2(135.09,30.57) 132.72,32.95 132.72,33.81 127.39,39.13 127.28,39.13 126.95,38.81 126.81,38.81 126.61,39.01 126.61,39.15 126.93,39.48 126.93,39.59 126.7,39.82 126.58,39.82 125.74,38.98 125.6,38.98 125.4,39.19 125.4,39.33 126.24,40.17 126.24,40.29 126.01,40.52 125.89,40.52 125.05,39.68 124.91,39.68 124.7,39.88 124.7,40.02 125.54,40.86 125.54,40.98 125.31,41.21 125.2,41.21 124.36,40.37 124.21,40.37 124.01,40.57 124.01,40.72 124.85,41.56 124.85,41.67 124.62,41.9 124.5,41.9 123.66,41.06 123.52,41.06 123.32,41.27 123.32,41.41 124.16,42.25 124.16,42.37 123.93,42.6 123.81,42.6 122.97,41.76 122.83,41.76 122.62,41.96 122.62,42.1 123.46,42.94 123.46,43.06 123.23,43.29 123.12,43.29 122.73,42.9 122.59,42.9 122.39,43.1 122.39,43.24 122.75,43.6 122.75,43.77 122.16,44.36 122.16,59.95 122.52,60.31 122.52,63.99 v2(124.21,65.68)
  BOTTOM w0.076: v2(124.21,65.68) 123.53,66.35 123.53,67.7 123.58,67.81 123.61,67.86 123.61,68.06 123.58,68.12 123.54,68.21 123.53,68.22 123.53,68.35 123.58,68.46 123.82,68.7 UC1.AV25
  BOTTOM w0.102: JDIMM2.7 134.95,30.72 v2(135.09,30.57)
DDR_B_D15: length 62.8
  IN1 w0.084: v2(138.85,22.41) 138.84,22.41 137.88,23.37 137.88,24.18 137.78,24.28 136.96,24.28 136.83,24.41 136.83,24.65 136.96,24.77 137.75,24.77 137.88,24.9 137.88,26.02 137.75,26.15 136.58,26.15 136.46,26.28 136.46,26.51 136.58,26.64 137.39,26.64 137.52,26.77 137.52,27 137.39,27.13 136.58,27.13 136.46,27.26 136.46,27.49 136.58,27.62 137.21,27.62 137.33,27.74 137.33,31.97 135.69,33.61 135.69,34.45 128.51,41.62 128.51,42.8 125.09,46.23 125.09,47.69 124.99,47.79 124.25,47.79 124.15,47.9 124.15,48.36 124.23,48.44 124.59,48.44 124.69,48.55 124.69,48.83 124.59,48.93 124.23,48.93 124.15,49.02 124.15,60.42 v2(124.21,60.48)
  BOTTOM w0.076: UC1.AU25 124.21,69.2 124.21,67.9 124.26,67.79 124.28,67.74 124.28,67.44 124.14,67.3 124.03,67.19 124.03,66.86 124.26,66.63 124.27,66.63 124.93,65.98 124.93,61.2 v2(124.21,60.48)
  BOTTOM w0.102: JDIMM2.18 138.25,23.01 v2(138.85,22.41)
DDR_B_D16: length 95.1
  IN4 w0.084: v2(121.08,72.37) 120.53,71.83 120.53,70.15 120.69,69.99 120.69,67.93 123.43,65.2 123.43,60.19 124.64,58.98 124.64,56.9 132.2,49.34 136.3,49.34 138.29,47.34 158.27,47.34 159.4,46.22 167.96,46.22 179.24,34.94 179.24,31.2 179.5,30.95 179.5,25.39 179.37,25.26 178.72,25.26 178.59,25.39 v2(178.59,26)
  BOTTOM w0.076: v2(121.08,72.37) 121.4,72.7 UC1.AM29
  BOTTOM w0.102: v2(178.59,26) 179.05,25.55 JDIMM2.146
DDR_B_D17: length 96.9
  IN4 w0.084: v2(121.08,73.67) 120.36,72.96 120.36,70.05 120.51,69.9 120.51,67.87 123.23,65.14 123.23,60.11 124.33,59.02 124.33,56.77 132.07,49.02 136.17,49.02 138.16,47.03 158.14,47.03 159.27,45.9 167.83,45.9 177.48,36.25 177.48,36.14 176.95,35.6 176.95,35.42 177.12,35.26 177.3,35.26 177.83,35.79 177.95,35.79 178.45,35.29 178.45,33.04 178.53,32.95 178.83,32.95 178.91,32.87 178.91,31.1 179.19,30.82 179.19,27.65 179.06,27.53 v2(178.59,27.53)
  BOTTOM w0.076: v2(121.08,73.67) 121.4,74 UC1.AK29
  BOTTOM w0.102: v2(178.59,27.53) 179.65,26.47 JDIMM2.148
DDR_B_D18: length 95.8
  IN4 w0.084: v2(122.02,73.02) 122.49,72.55 122.49,71.94 122.58,71.84 122.58,70.05 125.33,67.3 125.33,60.83 127.25,58.9 127.25,57.98 133.29,51.95 140.55,51.95 141.58,50.92 144.19,50.92 144.94,50.16 159.15,50.16 160.28,49.03 168.84,49.03 182.55,35.33 182.55,33.24 183.05,32.73 183.05,25.77 183.18,25.64 183.83,25.64 183.96,25.77 v2(183.96,26)
  BOTTOM w0.076: UC1.AL28 122.34,73.35 v2(122.02,73.02)
  BOTTOM w0.102: v2(183.96,26) 183.25,25.3 JDIMM2.160
DDR_B_D19: length 96.3
  IN4 w0.084: v2(122.85,73.66) 123.36,73.15 123.36,69.65 125.5,67.51 125.5,60.9 127.57,58.83 127.57,58.11 133.42,52.26 140.68,52.26 141.71,51.23 144.32,51.23 145.07,50.47 159.28,50.47 160.41,49.35 168.97,49.35 182.97,35.35 182.97,33.26 183.36,32.86 183.36,27.27 183.49,27.14 183.83,27.14 183.96,27.27 v2(183.96,27.53)
  BOTTOM w0.076: v2(122.85,73.66) 122.52,74 UC1.AK28
  BOTTOM w0.102: JDIMM2.158 182.65,26.22 v2(183.96,27.53)
DDR_B_D20: length 92.9
  IN4 w0.084: v2(121.08,70.42) 121.08,68.1 123.81,65.37 123.81,60.31 125.26,58.85 125.26,57.16 132.46,49.96 138.73,49.96 138.82,49.88 138.82,48.63 138.94,48.5 139.18,48.5 139.31,48.63 139.31,49.88 139.39,49.96 139.68,49.96 139.8,49.84 139.8,48.13 139.96,47.97 140.28,47.97 140.37,48.05 140.37,48.83 140.49,48.95 140.73,48.95 140.86,48.83 140.86,48.05 140.94,47.97 141.5,47.97 141.7,48.17 141.99,48.17 142.19,47.97 142.55,47.97 142.71,48.12 143.04,48.12 143.2,47.97 143.53,47.97 143.69,48.12 144.02,48.12 144.18,47.97 144.51,47.97 144.67,48.12 145,48.12 145.16,47.97 145.49,47.97 145.65,48.12 145.98,48.12 146.14,47.97 146.48,47.97 146.63,48.12 146.97,48.12 147.12,47.97 158.53,47.97 159.66,46.84 168.22,46.84 179.87,35.2 179.87,31.46 180.43,30.9 v2(180.43,30.57)
  BOTTOM w0.089: v2(121.08,70.42) 121.4,70.75 UC1.AR29
  BOTTOM w0.102: JDIMM2.149 179.95,30.34 180.08,30.22 180.3,30.22 180.43,30.34 v2(180.43,30.57)
DDR_B_D21: length 95
  IN4 w0.084: v2(180.43,29.05) 180.43,28.82 180.3,28.69 180,28.69 179.87,28.82 179.87,31.02 179.56,31.33 179.56,35.07 168.09,46.53 159.53,46.53 158.4,47.65 139.45,47.65 139.36,47.74 139.36,48.1 139.28,48.19 138.96,48.19 138.87,48.1 138.87,47.74 138.79,47.65 138.5,47.65 138.35,47.81 138.35,49.52 138.22,49.65 137.8,49.65 137.72,49.57 137.72,48.89 137.59,48.76 137.36,48.76 137.23,48.89 137.23,49.57 137.15,49.65 132.33,49.65 124.95,57.03 124.95,58.92 123.62,60.26 123.62,65.29 120.89,68.01 120.89,70.03 120.71,70.22 120.71,71.35 v2(121.08,71.72)
  BOTTOM w0.076: v2(121.08,71.72) 121.4,72.05 UC1.AN29
  BOTTOM w0.102: v2(180.43,29.05) 179.35,30.13 JDIMM2.147
DDR_B_D22: length 93.4
  IN4 w0.084: v2(122.02,70.42) 122.02,69.96 124.93,67.05 124.93,60.74 126.63,59.04 126.63,57.72 130.63,53.72 133.03,51.33 140.29,51.33 141.46,50.16 141.84,50.16 141.96,50.03 141.96,49.66 142.09,49.53 142.3,49.53 142.39,49.62 142.39,50.07 142.47,50.16 142.79,50.16 142.88,50.07 142.88,49.62 142.96,49.53 143.28,49.53 143.37,49.62 143.37,50.07 143.45,50.16 143.77,50.16 143.86,50.07 143.86,49.62 143.94,49.53 158.89,49.53 160.02,48.41 168.58,48.41 181.23,35.76 181.23,35.31 181.36,35.18 181.69,35.18 181.82,35.06 181.82,34.69 181.69,34.56 181.36,34.56 181.23,34.44 181.23,32.98 181.36,32.86 182.03,32.86 182.16,32.73 182.16,32.44 182.03,32.31 181.52,32.31 181.39,32.19 181.39,31.87 181.52,31.74 182.3,31.74 182.43,31.61 182.43,30.41 182.3,30.28 182.08,30.28 181.95,30.41 v2(181.95,30.57)
  BOTTOM w0.089: UC1.AR28 122.2,70.75 122.02,70.56 v2(122.02,70.42)
  BOTTOM w0.102: v2(181.95,30.57) 181.95,30.32 182.08,30.2 182.49,30.2 182.62,30.32 182.62,30.98 182.49,31.11 182.48,31.11 182.35,31.23 JDIMM2.157
DDR_B_D23: length 94.3
  IN4 w0.084: v2(122.02,71.07) 122.41,70.68 122.41,69.9 125.1,67.21 125.1,60.81 126.94,58.97 126.94,57.85 133.16,51.64 140.42,51.64 141.45,50.61 144.06,50.61 144.81,49.85 159.02,49.85 160.15,48.72 168.71,48.72 182.13,35.31 182.13,33.2 182.74,32.59 182.74,29.95 182.66,29.86 182.47,29.86 182.34,29.73 182.34,29.5 182.47,29.37 182.66,29.37 182.74,29.29 182.74,28.54 182.61,28.41 182.39,28.41 182.26,28.54 182.26,28.92 182.13,29.05 v2(181.95,29.05)
  BOTTOM w0.076: UC1.AP28 122.19,71.4 122.02,71.22 v2(122.02,71.07)
  BOTTOM w0.102: JDIMM2.159 182.95,31.16 183.19,30.92 183.19,28.82 183.07,28.69 182.08,28.69 181.95,28.82 v2(181.95,29.05)
DDR_B_D24: length 63.3
  IN1 w0.084: v2(122.97,71.72) 122.69,71.72 122.58,71.62 122.58,69.18 123.88,67.89 123.88,66.77 124.2,66.44 124.46,66.44 125.1,65.8 125.1,60.81 125.89,60.02 125.89,54.98 125.99,54.88 126.56,54.88 126.67,54.78 126.67,46.82 130.04,43.44 130.04,42.35 135.15,37.24 136.24,37.24 139.24,34.24 139.24,25.6 139.43,25.41 139.43,25.29 138.8,24.66 138.8,24.54 139.03,24.31 139.14,24.31 139.78,24.95 139.89,24.95 140.12,24.72 140.12,24.6 139.72,24.2 139.72,24.05 139.92,23.85 140.07,23.85 140.2,23.98 140.46,23.98 140.65,23.79 v2(140.65,22.41)
  BOTTOM w0.076: v2(122.97,71.72) 123.29,72.05 UC1.AN26
  BOTTOM w0.102: JDIMM2.24 140.05,23.01 v2(140.65,22.41)
DDR_B_D25: length 61.9
  IN1 w0.084: v2(122.97,70.42) 122.97,69.13 124.82,67.28 124.82,66.32 125.27,65.87 125.27,60.88 126.2,59.95 126.2,55.82 126.98,55.04 126.98,46.95 130.36,43.57 130.36,42.47 135.28,37.55 136.37,37.55 139.55,34.37 139.55,25.73 141.05,24.24 141.05,21.28 v2(140.65,20.88)
  BOTTOM w0.089: UC1.AR26 123.29,70.75 v2(122.97,70.42)
  BOTTOM w0.102: JDIMM2.22 139.45,22.08 v2(140.65,20.88)
DDR_B_D26: length 60.7
  IN1 w0.084: v2(123.92,70.42) 123.92,69.56 126.48,67 126.48,60.46 127.56,59.38 127.56,56.48 128.35,55.69 128.35,47.54 142.1,33.79 142.1,33 142,32.89 141.76,32.89 141.66,32.79 141.66,32.5 141.76,32.4 142,32.4 142.1,32.3 142.1,31.2 141.94,31.05 141.51,31.05 141.38,30.92 141.38,28.02 141.25,27.89 139.99,27.89 139.87,27.76 139.87,27.52 139.99,27.39 141.61,27.39 141.86,27.64 141.86,30.4 142.04,30.57 v2(142.31,30.57)
  BOTTOM w0.076: v2(123.92,70.42) 124.25,70.75 UC1.AR25
  BOTTOM w0.102: JDIMM2.33 142.75,31.02 v2(142.31,30.57)
DDR_B_D27: length 61.8
  IN1 w0.084: v2(142.31,29.05) 142.62,29.05 142.71,29.14 142.71,31.13 142.41,31.42 142.41,33.92 141.89,34.45 141.89,34.57 141.98,34.66 141.98,34.78 141.75,35 141.63,35 141.54,34.91 141.42,34.91 141.19,35.14 141.19,35.26 141.28,35.35 141.28,35.47 141.06,35.7 140.94,35.7 140.85,35.61 140.73,35.61 140.5,35.83 140.5,35.95 140.59,36.04 140.59,36.16 140.36,36.39 140.24,36.39 140.15,36.3 140.03,36.3 139.81,36.53 139.81,36.65 139.9,36.74 139.9,36.86 139.67,37.08 139.55,37.08 139.46,36.99 139.34,36.99 139.11,37.22 139.11,37.34 139.2,37.43 139.2,37.55 138.98,37.78 138.86,37.78 138.77,37.69 138.65,37.69 138.42,37.91 138.42,38.03 138.51,38.12 138.51,38.24 138.28,38.47 138.16,38.47 138.07,38.38 137.95,38.38 137.72,38.61 137.72,38.73 137.82,38.82 137.82,38.94 137.59,39.17 137.47,39.17 137.38,39.07 137.26,39.07 137.03,39.3 137.03,39.42 137.12,39.51 137.12,39.63 136.89,39.86 136.78,39.86 136.68,39.77 136.57,39.77 136.34,40 136.34,40.11 136.43,40.21 136.43,40.32 136.2,40.55 136.08,40.55 135.99,40.46 135.87,40.46 135.64,40.69 135.64,40.81 135.74,40.9 135.74,41.02 135.51,41.25 135.39,41.25 135.3,41.15 135.18,41.15 134.95,41.38 134.95,41.5 135.04,41.59 135.04,41.71 134.81,41.94 134.7,41.94 134.6,41.85 134.49,41.85 134.26,42.08 134.26,42.19 134.35,42.29 134.35,42.4 134.12,42.63 134,42.63 133.91,42.54 133.79,42.54 133.56,42.77 133.56,42.89 133.66,42.98 133.66,43.1 133.43,43.33 133.31,43.33 133.22,43.23 133.1,43.23 132.87,43.46 132.87,43.58 132.96,43.67 132.96,43.79 132.73,44.02 132.62,44.02 132.52,43.93 132.41,43.93 132.18,44.16 132.18,44.27 132.27,44.37 132.27,44.48 132.04,44.71 131.92,44.71 131.83,44.62 131.71,44.62 131.48,44.85 131.48,44.97 131.58,45.06 131.58,45.18 131.35,45.41 131.23,45.41 131.14,45.31 131.02,45.31 130.79,45.54 130.79,45.66 130.88,45.75 130.88,45.87 130.65,46.1 130.54,46.1 130.44,46.01 130.33,46.01 130.1,46.24 130.1,46.35 130.19,46.45 130.19,46.56 129.96,46.79 129.84,46.79 129.75,46.7 129.63,46.7 129.4,46.93 129.4,47.05 129.5,47.14 129.5,47.26 129.27,47.49 129.15,47.49 129.06,47.39 128.94,47.39 128.66,47.67 128.66,55.95 127.88,56.74 127.88,59.31 126.66,60.53 126.66,67.1 124.31,69.44 124.31,70.69 v2(123.92,71.07)
  BOTTOM w0.076: UC1.AP25 124.25,71.4 v2(123.92,71.07)
  BOTTOM w0.102: JDIMM2.35 143.35,30.09 v2(142.31,29.05)
DDR_B_D28: length 64
  IN1 w0.084: v2(138.47,30.57) 138.47,32.32 137.47,33.32 137.47,33.94 129.42,42 129.42,43.18 126,46.6 126,48.81 125.05,49.75 125.05,51.05 125.14,51.14 125.91,51.14 126,51.22 126,51.54 125.91,51.63 125.14,51.63 125.05,51.71 125.05,52.04 125.14,52.12 125.91,52.12 126,52.2 126,52.53 125.91,52.61 125.14,52.61 125.05,52.69 125.05,53.02 125.14,53.1 125.91,53.1 126,53.18 126,53.51 125.91,53.59 125.14,53.59 125.05,53.67 125.05,55.14 125.26,55.35 125.26,60.15 124.75,60.66 124.75,65.66 124.32,66.09 124.06,66.09 123.53,66.63 123.53,67.43 123.4,67.55 122.16,67.55 121.6,68.11 121.6,73.61 121.68,73.69 122.39,73.69 122.47,73.77 122.47,74.1 122.39,74.18 121.68,74.18 121.6,74.26 121.6,74.71 121.69,74.81 123.65,74.81 123.74,74.71 v2(123.74,74.36)
  BOTTOM w0.076: UC1.AK26 123.38,74 v2(123.74,74.36)
  BOTTOM w0.102: v2(138.47,30.57) 138.91,30.57 139.15,30.82 JDIMM2.21
DDR_B_D29: length 63.9
  IN1 w0.084: v2(138.47,29.05) 138.8,29.05 138.93,29.18 138.93,33.88 138.18,34.63 138.06,34.63 137.71,34.27 137.59,34.27 137.36,34.5 137.36,34.62 137.72,34.97 137.72,35.09 137.49,35.32 137.37,35.32 137.02,34.97 136.9,34.97 136.67,35.2 136.67,35.31 137.02,35.67 137.02,35.79 136.79,36.01 136.68,36.01 136.32,35.66 136.2,35.66 135.98,35.89 135.98,36.01 136.33,36.36 136.33,36.48 135.88,36.93 134.93,36.93 129.73,42.13 129.73,43.31 126.31,46.73 126.31,49.23 126.22,49.31 125.93,49.31 125.83,49.41 125.83,49.7 125.93,49.8 126.22,49.8 126.31,49.88 126.31,50.21 126.22,50.29 125.47,50.29 125.36,50.39 125.36,50.68 125.47,50.78 126.22,50.78 126.31,50.86 126.31,53.88 126.21,53.99 125.47,53.99 125.36,54.09 125.36,55.01 125.57,55.22 125.57,60.08 124.92,60.73 124.92,65.73 124.39,66.27 124.13,66.27 123.7,66.7 123.7,67.6 123.57,67.73 122.73,67.73 122.41,68.04 122.41,69.37 122.33,69.46 121.86,69.46 121.77,69.54 121.77,69.86 121.86,69.95 122.33,69.95 122.41,70.03 122.41,72.21 122.54,72.33 v2(122.93,72.33)
  BOTTOM w0.076: UC1.AM26 123.29,72.7 v2(122.93,72.33)
  BOTTOM w0.102: v2(138.47,29.05) 139.75,30.33 JDIMM2.23
DDR_B_D30: length 64
  IN1 w0.084: v2(123.87,73.67) 124.48,73.06 124.48,72.86 125.27,72.07 125.27,69.04 127.01,67.3 127.01,60.67 128.5,59.18 128.5,57 129.29,56.21 129.29,48.35 143.04,34.6 143.04,31.68 143.35,31.37 143.35,27.19 143.22,27.06 142.47,27.06 142.37,26.96 142.37,26.67 142.47,26.57 143.22,26.57 143.31,26.49 143.31,22.76 142.95,22.41 v2(142.45,22.41)
  BOTTOM w0.076: v2(123.87,73.67) 124.2,74 UC1.AK25
  BOTTOM w0.102: JDIMM2.34 143.05,23.01 v2(142.45,22.41)
DDR_B_D31: length 64.7
  IN1 w0.084: v2(142.45,20.88) 142.05,21.28 142.05,27.09 143.04,28.08 143.04,31.24 142.72,31.55 142.72,34.47 128.98,48.22 128.98,56.08 128.19,56.87 128.19,59.25 126.83,60.61 126.83,67.23 124.48,69.58 124.48,72.5 v2(123.96,73.02)
  BOTTOM w0.089: UC1.AL25 124.28,73.35 v2(123.96,73.02)
  BOTTOM w0.102: v2(142.45,20.88) 143.65,22.08 JDIMM2.36
DDR_B_D32: length 90.8
  IN4 w0.084: v2(185.83,25.62) 184.98,25.62 184.83,25.77 184.83,35.21 180,40.04 175.46,44.58 175.46,46.6 173.9,48.16 171.88,48.16 170.95,49.09 170.95,50.62 170.44,51.13 160.34,51.13 159.79,51.69 145.58,51.69 144.82,52.45 142.21,52.45 141.17,53.49 133.91,53.49 126.78,60.62 126.78,62.4 v2(126.11,63.08)
  BOTTOM w0.076: v2(126.11,63.08) 125.42,63.76 125.42,66.41 125.19,66.65 125.19,67.37 125.18,67.38 UC1.AY23
  BOTTOM w0.102: JDIMM2.166 185.05,24.84 v2(185.83,25.62)
DDR_B_D33: length 92.1
  IN4 w0.084: v2(183.96,29.05) 184.35,29.45 184.35,35.24 174.27,45.33 174.27,45.45 175.15,46.33 175.15,46.47 174.95,46.67 174.81,46.67 173.92,45.79 173.81,45.79 173.58,46.02 173.58,46.14 174.46,47.02 174.46,47.16 173.77,47.85 171.75,47.85 170.63,48.96 170.63,50.49 170.31,50.82 160.22,50.82 159.66,51.38 145.45,51.38 144.69,52.13 142.08,52.13 141.04,53.18 133.78,53.18 126.5,60.46 126.5,62.03 v2(126.11,62.43)
  BOTTOM w0.076: v2(126.11,62.43) 125.26,63.28 125.26,66.34 125.02,66.58 125.02,67.3 124.88,67.44 124.88,67.71 124.97,67.88 125.18,68.08 UC1.AW23
  BOTTOM w0.102: JDIMM2.165 184.75,31.04 184.51,30.8 184.51,29.6 v2(183.96,29.05)
DDR_B_D34: length 90.7
  IN4 w0.084: v2(127.71,61.78) 128.08,61.4 128.08,61.21 129.76,59.54 130.73,59.54 133.56,56.7 134.52,56.7 135.73,55.49 142.07,55.49 142.88,54.68 145.88,54.68 146.68,53.88 160.85,53.88 161.61,53.12 171.76,53.12 177.45,47.42 177.45,45.4 187.27,35.58 187.27,30.84 187.54,30.58 187.54,26.78 187.78,26.53 187.78,25.76 187.65,25.62 v2(187.1,25.62)
  BOTTOM w0.076: v2(127.71,61.78) 126.94,62.54 126.94,65.87 126.65,66.16 126.65,67.51 UC1.AY21
  BOTTOM w0.102: JDIMM2.174 187.45,25.27 v2(187.1,25.62)
DDR_B_D35: length 91.7
  IN4 w0.084: v2(188.64,29.05) 188.04,29.65 188.04,30.51 187.58,30.97 187.58,35.71 177.77,45.53 177.77,47.55 171.89,53.43 164.54,53.43 164.46,53.51 164.46,53.79 164.36,53.89 164.07,53.89 163.97,53.79 163.97,53.51 163.88,53.43 163.56,53.43 163.48,53.51 163.48,54.11 163.39,54.19 163.07,54.19 162.99,54.11 162.99,53.51 162.9,53.43 161.74,53.43 160.98,54.19 146.81,54.19 146.01,54.99 143.01,54.99 142.19,55.81 135.86,55.81 134.65,57.01 133.86,57.01 132.99,57.89 132.99,58.37 131.65,59.71 129.83,59.71 128.46,61.08 128.46,61.68 v2(127.71,62.43)
  BOTTOM w0.076: v2(127.71,62.43) 127.11,63.03 127.11,65.94 126.82,66.23 126.82,67.76 126.53,68.05 UC1.AW21
  BOTTOM w0.102: v2(188.64,29.05) 187.75,29.94 187.75,32.14 JDIMM2.175
DDR_B_D36: length 92.4
  IN4 w0.084: v2(126.11,61.13) 126.11,60.61 128.2,58.51 128.2,58.32 133.66,52.85 140.92,52.85 141.95,51.82 144.56,51.82 145.32,51.06 159.53,51.06 160.09,50.5 164.15,50.5 164.24,50.42 164.24,50.02 164.32,49.94 164.64,49.94 164.73,50.02 164.73,50.42 164.81,50.5 165.13,50.5 165.22,50.42 165.22,50.02 165.3,49.94 165.62,49.94 165.71,50.02 165.71,50.42 165.79,50.5 166.11,50.5 166.2,50.42 166.2,50.02 166.28,49.94 166.6,49.94 166.69,50.02 166.69,50.42 166.77,50.5 167.09,50.5 167.18,50.42 167.18,50.02 167.26,49.94 167.58,49.94 167.67,50.02 167.67,50.42 167.75,50.5 168.07,50.5 168.16,50.42 168.16,50.02 168.24,49.94 168.56,49.94 168.65,50.02 168.65,50.42 168.73,50.5 169.05,50.5 169.14,50.42 169.14,50.02 169.22,49.94 169.54,49.94 169.63,50.02 169.63,50.42 169.71,50.5 170.18,50.5 170.32,50.36 170.32,48.83 171.92,47.24 172.04,47.24 172.34,47.54 172.48,47.54 172.68,47.34 172.68,47.19 172.38,46.89 172.38,46.77 172.61,46.55 172.73,46.55 173.06,46.87 173.2,46.87 173.4,46.67 173.4,46.53 173.08,46.2 173.08,46.08 183.96,35.2 v2(183.96,30.57)
  BOTTOM w0.076: v2(126.11,61.13) 125.09,62.14 125.09,66.28 124.86,66.51 124.86,67.23 124.72,67.37 124.72,67.75 124.74,67.79 124.79,67.89 124.79,68.55 UC1.AV23
  BOTTOM w0.102: v2(183.96,30.57) 184.15,30.77 JDIMM2.163
DDR_B_D37: length 93.5
  IN4 w0.084: v2(185.83,27.14) 185.27,27.14 185.14,27.27 185.14,32.06 185.27,32.19 185.43,32.19 185.56,32.32 185.56,32.57 185.43,32.69 185.27,32.69 185.14,32.82 185.14,35.34 175.78,44.71 175.78,46.73 171.06,51.44 160.47,51.44 159.92,52 145.71,52 144.95,52.76 142.34,52.76 141.3,53.8 134.04,53.8 127.64,60.2 127.54,60.2 126.96,60.79 126.96,62.88 v2(126.11,63.73)
  BOTTOM w0.076: UC1.AU23 125.94,69.59 126.14,69.38 126.14,69.14 126.13,69.13 126.13,68.75 126.14,68.73 126.14,68.54 126.13,68.53 126.07,68.39 126.07,68.18 126.14,68.03 126.14,67.9 126.09,67.79 126.07,67.74 126.07,67.45 126.3,67.21 126.3,66.04 126.61,65.74 126.61,64.22 v2(126.11,63.73)
  BOTTOM w0.102: v2(185.83,27.14) 185.4,26.71 185.4,25.76 184.45,24.81 JDIMM2.164
DDR_B_D38: length 92
  IN4 w0.084: v2(127.71,61.13) 127.87,61.13 129.63,59.36 130.46,59.36 133.43,56.39 134.39,56.39 135.6,55.18 141.94,55.18 142.75,54.37 145.75,54.37 146.55,53.57 160.72,53.57 161.48,52.81 171.63,52.81 177.14,47.29 177.14,45.27 186.92,35.49 186.92,30.75 187.22,30.45 187.22,28.59 186.7,28.07 186.7,27.54 v2(187.1,27.14)
  BOTTOM w0.076: UC1.AV21 126.42,68.59 126.28,68.46 126.23,68.35 126.23,68.22 126.24,68.2 126.28,68.12 126.31,68.06 126.31,67.86 126.23,67.7 126.23,67.51 126.48,67.27 126.48,66.1 126.77,65.81 126.77,65.61 126.78,65.61 126.78,62.07 127.26,61.59 127.26,61.58 v2(127.71,61.13)
  BOTTOM w0.102: JDIMM2.176 188.05,25.19 187.54,25.7 187.54,26.71 v2(187.1,27.14)
DDR_B_D39: length 92.8
  IN4 w0.084: v2(127.71,63.08) 128.63,62.15 128.63,61.15 129.9,59.88 131.73,59.88 133.3,58.32 133.3,58.02 133.99,57.33 134.78,57.33 135.99,56.12 142.32,56.12 143.14,55.3 146.14,55.3 146.94,54.51 166.95,54.51 167.03,54.42 167.03,53.86 167.12,53.78 167.44,53.78 167.52,53.86 167.52,54.42 167.61,54.51 167.93,54.51 168.01,54.42 168.01,53.86 168.1,53.78 168.42,53.78 168.5,53.86 168.5,54.42 168.59,54.51 168.91,54.51 168.99,54.42 168.99,53.86 169.08,53.78 169.4,53.78 169.48,53.86 169.48,54.42 169.57,54.51 169.89,54.51 169.97,54.42 169.97,53.86 170.06,53.78 170.38,53.78 170.46,53.86 170.46,54.42 170.55,54.51 171.26,54.51 178.08,47.68 178.08,45.66 187.9,35.84 187.9,31.32 v2(188.64,30.57)
  BOTTOM w0.076: v2(127.71,63.08) 127.28,63.51 127.28,66 126.98,66.3 126.98,67.83 126.82,67.99 126.82,68.41 126.69,68.53 126.69,68.8 126.71,68.82 126.71,69.06 126.42,69.35 UC1.AU21
  BOTTOM w0.102: v2(188.64,30.57) 188.35,30.87 JDIMM2.177
DDR_B_D40: length 59
  IN1 w0.084: v2(127.71,64.38) 128.08,64 128.08,60.1 129.09,59.09 129.09,57.26 129.88,56.47 129.88,49.59 130.17,49.3 130.17,49.18 129.9,48.9 129.9,48.79 130.12,48.56 130.24,48.56 130.52,48.83 130.64,48.83 130.87,48.61 130.87,48.49 130.59,48.21 130.59,48.09 130.82,47.86 130.94,47.86 131.21,48.14 131.33,48.14 131.56,47.91 131.56,47.79 131.28,47.52 131.28,47.4 131.51,47.17 131.63,47.17 131.91,47.45 132.02,47.45 132.25,47.22 132.25,47.1 131.98,46.82 131.98,46.71 132.2,46.48 132.32,46.48 132.6,46.75 132.72,46.75 132.95,46.53 132.95,46.41 132.67,46.13 132.67,46.01 132.9,45.78 133.02,45.78 133.29,46.06 133.41,46.06 133.64,45.83 133.64,45.71 133.36,45.44 133.36,45.32 133.59,45.09 133.71,45.09 133.99,45.37 134.1,45.37 134.33,45.14 134.33,45.02 134.06,44.74 134.06,44.63 134.28,44.4 134.4,44.4 134.68,44.67 134.8,44.67 135.03,44.45 135.03,44.33 134.75,44.05 134.75,43.93 134.98,43.7 135.1,43.7 135.37,43.98 135.49,43.98 135.72,43.75 135.72,43.63 135.44,43.36 135.44,43.24 135.67,43.01 135.79,43.01 136.07,43.29 136.18,43.29 136.41,43.06 136.41,42.94 136.14,42.66 136.14,42.55 136.36,42.32 136.48,42.32 136.76,42.59 136.88,42.59 137.11,42.37 137.11,42.25 136.83,41.97 136.83,41.85 137.06,41.62 137.18,41.62 137.45,41.9 137.57,41.9 137.8,41.67 137.8,41.55 137.52,41.28 137.52,41.16 137.75,40.93 137.87,40.93 138.15,41.21 138.26,41.21 138.49,40.98 138.49,40.86 138.22,40.58 138.22,40.47 138.44,40.24 138.56,40.24 138.84,40.51 138.96,40.51 139.19,40.28 139.19,40.17 138.91,39.89 138.91,39.77 139.14,39.54 139.26,39.54 139.4,39.69 139.54,39.69 139.75,39.48 139.75,39.34 139.6,39.2 139.6,39.08 143.63,35.05 143.63,31.93 143.95,31.61 v2(143.95,30.57)
  BOTTOM w0.076: UC1.AY19 127.48,67.51 127.48,66.66 128.27,65.87 128.27,64.94 v2(127.71,64.38)
  BOTTOM w0.102: v2(143.95,30.57) 144.55,31.17 JDIMM2.39
DDR_B_D41: length 59.8
  IN1 w0.084: v2(143.95,29.05) 144.45,29.55 144.45,30.39 144.56,30.49 144.86,30.49 144.96,30.59 144.96,30.88 144.86,30.98 144.61,30.98 144.5,31.08 144.5,31.37 144.61,31.47 145.26,31.47 145.34,31.55 145.34,31.87 145.26,31.96 144.35,31.96 144.25,32.06 144.25,32.35 144.35,32.45 145.26,32.45 145.34,32.53 145.34,32.86 145.26,32.94 144.71,32.94 144.61,33.04 144.61,33.33 144.71,33.43 145.26,33.43 145.34,33.51 145.34,34.57 144.29,35.62 144.17,35.62 143.98,35.43 143.86,35.43 143.63,35.65 143.63,35.77 143.83,35.97 143.83,36.09 143.6,36.32 143.48,36.32 143.28,36.12 143.16,36.12 142.94,36.35 142.94,36.47 143.13,36.66 143.13,36.78 142.9,37.01 142.79,37.01 142.59,36.81 142.47,36.81 142.24,37.04 142.24,37.16 142.44,37.36 142.44,37.47 142.21,37.7 142.09,37.7 141.9,37.51 141.78,37.51 141.55,37.74 141.55,37.85 141.74,38.05 141.74,38.17 141.52,38.4 141.4,38.4 141.2,38.2 141.08,38.2 140.85,38.43 140.85,38.55 141.05,38.74 141.05,38.86 140.82,39.09 140.7,39.09 140.51,38.89 140.39,38.89 140.16,39.12 140.16,39.24 140.36,39.44 140.36,39.56 130.19,49.72 130.19,56.6 129.4,57.39 129.4,59.29 128.26,60.44 128.26,64.48 v2(127.71,65.03)
  BOTTOM w0.076: UC1.AW19 127.61,68.05 127.31,67.76 127.31,66.6 128.1,65.8 128.1,65.42 v2(127.71,65.03)
  BOTTOM w0.102: v2(143.95,29.05) 145.15,30.25 JDIMM2.41
DDR_B_D42: length 58.8
  IN1 w0.084: v2(149.27,30.57) 149.27,31.63 149.17,31.73 148.94,31.73 148.84,31.84 148.84,32.12 148.94,32.22 149.17,32.22 149.27,32.33 149.27,32.61 149.17,32.71 148.79,32.71 148.69,32.82 148.69,35.59 148.29,35.98 148.29,36.1 148.55,36.35 148.55,36.5 148.34,36.7 148.2,36.7 147.95,36.45 147.83,36.45 147.6,36.67 147.6,36.79 147.86,37.04 147.86,37.19 147.65,37.39 147.51,37.39 147.26,37.14 147.14,37.14 146.91,37.37 146.91,37.49 147.16,37.74 147.16,37.88 146.96,38.08 146.82,38.08 146.56,37.83 146.45,37.83 146.22,38.06 146.22,38.18 146.47,38.43 146.47,38.57 146.27,38.78 146.12,38.78 145.87,38.53 145.75,38.53 145.52,38.75 145.52,38.87 145.79,39.14 145.79,39.25 134.64,50.4 134.64,51.36 134.54,51.46 133.58,51.46 133.48,51.56 133.48,51.85 133.58,51.95 134.54,51.95 134.64,52.05 134.64,52.34 134.54,52.44 133.27,52.44 133.17,52.54 133.17,52.83 133.27,52.93 133.74,52.93 133.84,53.03 133.84,53.32 133.74,53.42 133.27,53.42 133.17,53.52 133.17,53.81 133.27,53.91 133.74,53.91 133.84,54.01 133.84,54.3 133.74,54.4 133.27,54.4 133.17,54.5 133.17,58.87 133.29,59 133.29,59.14 133.11,59.32 132.96,59.32 132.79,59.15 132.67,59.15 132.45,59.38 132.45,59.5 132.78,59.83 132.78,59.98 132.58,60.18 132.43,60.18 132.1,59.85 131.98,59.85 131.75,60.07 131.75,60.19 131.85,60.29 131.85,60.41 130.16,62.1 130.16,65.37 129.86,65.67 v2(129.58,65.67)
  BOTTOM w0.076: v2(129.58,65.67) 129.58,65.83 128.94,66.47 128.94,67.3 128.96,67.31 UC1.AY17
  BOTTOM w0.102: JDIMM2.53 148.75,31.1 v2(149.27,30.57)
DDR_B_D43: length 59.2
  IN1 w0.084: v2(129.63,61.13) 129.63,61.26 129.96,61.59 130.09,61.59 130.57,61.11 130.57,60.99 130.37,60.79 130.37,60.67 130.6,60.44 130.72,60.44 130.92,60.65 131.04,60.65 131.25,60.43 131.25,59.67 131.63,59.3 131.63,58.48 132.5,57.61 132.5,51.66 138.35,45.81 138.35,44.82 148.06,35.11 148.06,31.73 148.56,31.22 148.56,28.1 148.65,28.02 148.8,28.02 148.89,27.94 148.89,27.61 148.8,27.53 148.65,27.53 148.56,27.45 148.56,27.12 148.65,27.04 148.8,27.04 148.89,26.96 148.89,26.63 148.8,26.55 148.65,26.55 148.56,26.47 148.56,22.49 148.64,22.41 v2(149.05,22.41)
  BOTTOM w0.076: v2(129.63,61.13) 130,61.5 130,64.8 129.94,64.86 129.94,65.85 129.12,66.68 129.12,67.39 129.25,67.51 129.25,67.7 129.2,67.81 129.18,67.86 129.18,68.07 UC1.AW17
  BOTTOM w0.102: JDIMM2.52 148.45,23.01 v2(149.05,22.41)
DDR_B_D44: length 60.1
  IN1 w0.084: v2(127.71,65.68) 128.43,64.96 128.43,60.51 129.72,59.22 129.72,57.52 130.51,56.73 130.51,49.85 145.65,34.7 145.65,29.99 145.57,29.91 144.85,29.91 144.77,29.82 144.77,29.5 144.85,29.42 145.57,29.42 145.65,29.33 145.65,29.01 145.57,28.93 144.85,28.93 144.77,28.84 144.77,28.52 144.85,28.44 145.29,28.44 145.39,28.34 145.39,28.05 145.29,27.95 144.85,27.95 144.77,27.86 144.77,23.69 v2(146.05,22.41)
  BOTTOM w0.076: UC1.AV19 127.71,68.81 127.31,68.41 127.31,68 127.15,67.83 127.15,66.43 127.71,65.87 v2(127.71,65.68)
  BOTTOM w0.102: v2(146.05,22.41) 145.45,23.01 JDIMM2.42
DDR_B_D45: length 61.4
  IN1 w0.084: v2(146.05,20.88) 146.45,21.28 146.45,25.61 146.07,25.98 146.07,34.73 130.82,49.98 130.82,56.92 130.03,57.7 130.03,59.15 128.64,60.54 128.64,63.48 v2(129.59,64.43)
  BOTTOM w0.076: UC1.AU19 128.37,69.59 128.57,69.38 128.57,68.54 128.57,68.53 128.5,68.39 128.5,68.18 128.57,68.03 128.57,67.9 128.5,67.74 128.5,67.4 128.61,67.29 128.61,66.33 129.01,65.94 129.01,65.01 v2(129.59,64.43)
  BOTTOM w0.102: JDIMM2.40 144.85,22.08 v2(146.05,20.88)
DDR_B_D46: length 60.1
  IN1 w0.084: v2(149.27,29.05) 148.88,29.45 148.88,31.35 148.37,31.86 148.37,35.46 145.02,38.82 145.02,38.94 145.2,39.12 145.2,39.26 145,39.46 144.85,39.46 144.67,39.28 144.55,39.28 144.33,39.51 144.33,39.63 144.59,39.89 144.59,40.01 144.36,40.24 144.24,40.24 143.98,39.98 143.86,39.98 143.63,40.2 143.63,40.32 143.9,40.59 143.9,40.7 143.67,40.93 143.55,40.93 143.29,40.67 143.17,40.67 142.94,40.9 142.94,41.02 143.2,41.28 143.2,41.4 142.97,41.63 142.86,41.63 142.59,41.36 142.47,41.36 142.25,41.59 142.25,41.71 142.51,41.97 142.51,42.09 142.28,42.32 142.16,42.32 141.9,42.06 141.78,42.06 141.55,42.28 141.55,42.4 141.82,42.67 141.82,42.79 141.59,43.01 141.47,43.01 141.21,42.75 141.09,42.75 140.86,42.98 140.86,43.1 141.12,43.36 141.12,43.48 140.89,43.71 140.78,43.71 140.51,43.44 140.39,43.44 140.17,43.67 140.17,43.79 140.43,44.05 140.43,44.17 140.2,44.4 140.08,44.4 139.82,44.14 139.7,44.14 139.47,44.36 139.47,44.48 139.74,44.75 139.74,44.87 139.51,45.09 139.39,45.09 139.13,44.83 139.01,44.83 138.78,45.06 138.78,45.18 139.04,45.44 139.04,45.56 132.86,51.75 132.86,58.63 131.45,60.04 131.45,60.48 129.97,61.96 129.97,64.66 v2(129.57,65.06)
  BOTTOM w0.076: v2(129.57,65.06) 129.17,65.45 129.17,66 128.78,66.4 128.78,67.36 128.66,67.47 128.66,67.7 128.71,67.81 128.74,67.86 128.74,68.06 128.71,68.12 128.71,68.12 128.67,68.21 128.66,68.22 128.66,68.35 128.71,68.46 128.96,68.7 UC1.AV17
  BOTTOM w0.102: v2(149.27,29.05) 148.15,30.17 JDIMM2.51
DDR_B_D47: length 60.9
  IN1 w0.084: v2(129.91,60.64) 131.39,59.16 131.39,58.27 132.19,57.48 132.19,51.53 138.03,45.68 138.03,44.69 147.75,34.98 147.75,31.6 148.25,31.1 148.25,21.68 v2(149.05,20.88)
  BOTTOM w0.076: UC1.AU17 129.25,69.29 129.25,68.54 129.34,68.45 129.34,67.9 129.39,67.79 129.41,67.74 129.41,67.45 129.29,67.32 129.29,66.75 130.11,65.92 130.11,64.94 130.18,64.87 130.18,60.91 v2(129.91,60.64)
  BOTTOM w0.102: v2(149.05,20.88) 147.85,22.08 JDIMM2.50
DDR_B_D48: length 97.8
  IN4 w0.084: v2(126.67,70.42) 126.67,69.71 128.83,67.55 129.63,67.55 130.83,66.35 130.83,63.54 134.61,59.76 136.98,59.76 137.2,59.54 143.15,59.54 144.44,58.25 147.33,58.25 147.96,57.63 172.23,57.63 184.45,45.4 184.45,44.13 185.05,43.53 185.17,43.53 185.63,43.99 185.75,43.99 185.97,43.76 185.97,43.64 185.52,43.19 185.52,43.07 185.75,42.84 185.87,42.84 186.32,43.3 186.44,43.3 186.67,43.07 186.67,42.95 186.21,42.49 186.21,42.38 186.44,42.15 186.56,42.15 187.02,42.6 187.13,42.6 187.36,42.37 187.36,42.26 186.91,41.8 186.91,41.68 187.13,41.45 187.25,41.45 187.71,41.91 187.83,41.91 188.06,41.68 188.06,41.56 187.6,41.11 187.6,40.99 187.93,40.66 188.05,40.66 188.48,41.1 188.63,41.1 188.83,40.89 188.83,40.75 188.39,40.31 188.39,40.19 192.16,36.43 v2(192.16,30.57)
  BOTTOM w0.076: v2(126.67,70.42) 127,70.75 UC1.AR21
  BOTTOM w0.102: v2(192.16,30.57) 192.46,30.57 192.55,30.66 JDIMM2.191
DDR_B_D49: length 98.9
  IN4 w0.084: v2(190.63,30.27) 190.21,30.69 190.21,36.44 184.65,42 183.91,42 182.2,43.71 182.2,43.82 183.09,44.72 183.09,44.83 182.86,45.06 182.74,45.06 181.85,44.17 181.73,44.17 181.5,44.4 181.5,44.52 182.4,45.41 182.4,45.53 182.17,45.76 182.05,45.76 181.16,44.86 181.04,44.86 180.81,45.09 180.81,45.21 181.7,46.1 181.7,46.22 181.47,46.45 181.36,46.45 180.46,45.56 180.35,45.56 180.12,45.79 180.12,47.81 171.89,56.03 147.59,56.03 146.78,56.84 143.79,56.84 142.45,58.17 136.54,58.17 135.77,58.94 134.68,58.94 130.2,63.42 130.2,65.81 129.79,66.23 128.5,66.23 125.72,69.01 v2(125.72,70.42)
  BOTTOM w0.076: v2(125.72,70.42) 126.05,70.75 UC1.AR22
  BOTTOM w0.102: v2(190.63,30.27) 190.15,30.75 JDIMM2.183
DDR_B_D50: length 100.8
  IN4 w0.084: v2(194.05,25.5) 193.35,26.19 193.35,31.45 193.44,31.53 193.72,31.53 193.84,31.66 193.84,31.89 193.72,32.02 193.44,32.02 193.35,32.1 193.35,32.43 193.44,32.51 193.74,32.51 193.87,32.64 193.87,32.87 193.74,33 193.44,33 193.35,33.08 193.35,36.12 190.24,39.24 190.24,40.5 172.49,58.25 148.27,58.25 147.64,58.88 144.92,58.88 143.64,60.16 137.46,60.16 137.38,60.24 134.62,60.24 131.18,63.68 131.18,66.56 129.84,67.9 128.99,67.9 127.23,69.66 127.23,72.46 v2(126.67,73.02)
  BOTTOM w0.076: UC1.AL21 127,73.35 v2(126.67,73.02)
  BOTTOM w0.102: v2(194.05,25.5) 193.45,24.9 JDIMM2.194
DDR_B_D51: length 100.9
  IN4 w0.084: v2(188.63,26) 189.55,26.92 189.55,32.89 189.46,32.97 188.94,32.97 188.85,33.06 188.85,33.38 188.94,33.46 189.46,33.46 189.55,33.55 189.55,33.87 189.46,33.95 188.94,33.95 188.85,34.04 188.85,34.36 188.94,34.44 189.46,34.44 189.55,34.53 189.55,34.85 189.46,34.93 188.94,34.93 188.85,35.02 188.85,35.34 188.94,35.42 189.46,35.42 189.55,35.51 189.55,35.77 189.42,35.89 189.12,35.89 178.98,46.04 178.98,48.06 171.63,55.41 147.32,55.41 146.51,56.22 143.53,56.22 142.7,57.04 136.78,57.04 135.53,58.3 134.64,58.3 133.99,58.95 133.99,59.13 129.72,63.4 129.45,63.4 128.27,64.58 128.27,65.89 124.5,69.66 124.5,70.79 125.33,71.61 125.33,71.98 v2(125.72,72.37)
  BOTTOM w0.089: UC1.AM22 126.05,72.7 v2(125.72,72.37)
  BOTTOM w0.102: JDIMM2.180 189.25,25.38 v2(188.63,26)
DDR_B_D52: length 100.2
  IN4 w0.084: v2(125.72,71.72) 125.72,71.63 125.35,71.26 125.35,69.14 128.43,66.05 129.71,66.05 130.03,65.74 130.03,63.35 134.73,58.64 135.63,58.64 136.49,57.78 142.41,57.78 143.66,56.53 146.65,56.53 147.46,55.72 171.76,55.72 179.29,48.19 179.29,46.17 185.38,40.08 185.5,40.08 185.76,40.33 185.87,40.33 186.1,40.11 186.1,39.99 185.85,39.73 185.85,39.61 186.08,39.38 186.19,39.38 186.45,39.64 186.57,39.64 186.8,39.41 186.8,39.29 186.54,39.04 186.54,38.92 186.77,38.69 186.89,38.69 187.14,38.95 187.26,38.95 187.49,38.72 187.49,38.6 187.23,38.34 187.23,38.23 187.46,38 187.58,38 187.84,38.25 187.95,38.25 188.18,38.02 188.18,37.91 187.93,37.65 187.93,37.53 188.16,37.3 188.27,37.3 188.53,37.56 188.65,37.56 188.88,37.33 188.88,37.21 188.62,36.96 188.62,36.84 188.85,36.61 188.97,36.61 189.22,36.87 189.34,36.87 189.89,36.31 189.89,29.48 v2(190.63,28.74)
  BOTTOM w0.089: v2(125.72,71.72) 126.05,72.05 UC1.AN22
  BOTTOM w0.102: v2(190.63,28.74) 189.55,29.82 JDIMM2.181
DDR_B_D53: length 98.9
  IN4 w0.084: v2(126.67,71.07) 127.04,70.7 127.04,69.58 128.9,67.72 129.76,67.72 131.01,66.48 131.01,63.61 134.63,59.99 137.2,59.99 137.33,59.85 143.29,59.85 144.58,58.56 147.5,58.56 148.13,57.94 172.36,57.94 189.92,40.37 189.92,39.11 193.04,35.99 193.04,27.46 192.91,27.33 192.68,27.33 192.55,27.46 192.55,28.65 v2(192.16,29.05)
  BOTTOM w0.076: UC1.AP21 127,71.4 v2(126.67,71.07)
  BOTTOM w0.102: JDIMM2.193 193.15,30.04 v2(192.16,29.05)
DDR_B_D54: length 101.9
  IN4 w0.084: v2(194.05,27.02) 194.48,27.45 194.48,28.83 194.26,29.05 194.26,35.65 190.55,39.37 190.55,40.63 172.62,58.56 148.42,58.56 147.77,59.21 145.07,59.21 143.81,60.47 134.63,60.47 131.35,63.75 131.35,66.63 129.9,68.09 129.08,68.09 128.07,69.09 128.07,73.83 127.82,74.09 127.06,74.09 v2(126.65,73.67)
  BOTTOM w0.089: v2(126.65,73.67) 126.97,74 UC1.AK21
  BOTTOM w0.102: v2(194.05,27.02) 192.85,25.82 JDIMM2.192
