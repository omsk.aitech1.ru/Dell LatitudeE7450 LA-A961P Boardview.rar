# Allegro board LAA961PR10-1007A.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DOCK_DCIN_IS-: length 240.5
  TOP w0.254: PQ703.4 57.21,39.49 57.8,38.89 58.28,38.89 v2(58.4,38.78)
  IN4 w0.254: v2(177.54,135.12) 177.44,135.22 177.44,136.41 176.7,137.15 169.14,137.15 167.68,135.69 165.64,135.69 164.88,136.45 156.44,136.45 155.68,135.69 154.02,135.69 152.94,136.77 144.78,136.77 143.83,135.82 143.83,132.58 142.56,131.31 142.56,129.99 141.02,128.45 138.08,128.45 137.32,127.69 134.37,127.69 132.83,129.23 127.56,129.23 122.04,123.71 112.93,123.71 109.96,126.68 108.69,126.68 106.92,128.45 95.51,128.45 94.17,129.78 86.68,129.78 83.26,126.37 70.74,126.37 67.02,122.65 67.02,118.42 68.24,117.2 68.24,103.46 70.17,101.53 73.54,101.53 75.38,99.69 75.38,88.16 77.12,86.41 81,86.41 83.25,84.16 83.25,73.84 72.96,63.55 71.26,63.55 66.42,58.72 66.42,53.55 63.39,50.52 63.39,49.55 57.27,43.43 57.27,39.36 57.72,38.9 58.27,38.9 v2(58.4,38.78)
  BOTTOM w0.254: v2(177.54,135.12) 177.54,135.29 177.25,135.58 JDOCK1.136
DOCK_DET#: length 339.1
  TOP w0.102: UE1.B41 186.73,100.59 v2(186.37,100.23)
  TOP w0.254: PR853.1 11.51,27.96 v2(11.51,27.24) 11.51,26.98 12.41,26.08 12.41,24.06 12.78,23.69 13.38,23.69 13.54,23.85 PQ817.2
  IN1 w0.084: v2(163.2,48.01) 163.85,47.36 165.19,47.36 174.5,38.05 174.5,19.15 v2(173.59,18.24)
  IN2 w0.122: v2(163.2,48.01) 163.86,47.35 167.23,47.35 170.21,50.33 170.21,58.69 167.07,61.83 167.07,64.8 166.59,65.28 166.59,66.85 166.7,66.96 166.7,68.7 168.03,70.03 168.03,70.82 171.11,73.9 171.11,75.34 173.41,77.64 182.3,77.64 183.21,78.55 183.21,86.38 183.62,86.79 183.62,88.42 185.1,89.9 185.1,92.37 186.78,94.05 186.78,95.28 186.34,95.72 186.34,96.8 187.04,97.5 187.04,99.56 v2(186.37,100.23)
  IN2 w0.254: v2(173.59,18.24) 172.38,17.04 166.84,17.04 164.65,14.84 151.48,14.84 150.89,15.42 121.73,15.42 119.81,17.34 107.2,17.34 102.79,21.75 98.78,21.75 97.25,23.28 56.51,23.28 53.28,26.51 52.39,26.51 50.5,28.4 43.48,28.4 40.27,31.61 33.02,31.61 30.61,29.2 30.61,27.31 30.01,26.72 30.01,22.83 27.55,20.36 27.55,18.86 26.06,17.38 25.82,17.38 24.33,15.89 18.36,15.89 18.04,15.57 16.36,15.57 15.81,16.12 14.95,16.12 v2(13.13,17.94)
  IN4 w0.254: v2(11.51,27.24) 12.02,26.74 12.02,19.05 v2(13.13,17.94)
  BOTTOM w0.102: D19.2 178.37,124.97 R272.1 v1(184.62,118.73) 186.2,117.15 188.15,117.15 189.32,115.98 189.32,108.87 187.24,106.78 187.24,101.1 v2(186.37,100.23)
DOCK_DET_R#: length 15.1
  BOTTOM w0.102: JDOCK1.144 179.25,135.87 179.01,135.63 ; JDOCK1.142 178.75,135.89 179.01,135.63 ; 179.01,135.63 179.01,134.36 179.9,133.47 179.9,132.26 179.07,131.44 179.07,130.74 179.86,129.96 179.86,126.1 179.77,126.01 D19.1 v1(180.63,125.15)
DOCK_HP_DET: length 123
  TOP w0.102: UE1.A7 176.46,102.34 176.13,102.01 v2(175.5,102.01) ; v2(201.63,50.3) 203.3,50.3 207.37,54.37 207.37,56.86 209.04,58.52 v1(209.04,59.17) RA29.2 208.91,61.24 QA3.2
  IN2 w0.122: v2(175.5,102.01) 175.35,102.16 170.44,102.16 167.51,99.24 167.51,92.76 166.74,91.99 166.74,85.13 167.76,84.1 167.76,81.16 166.99,80.39 166.99,78.15 165.81,76.97 165.81,74.21 163.86,72.26 163.86,71.18 162.26,69.58 162.26,67.86 160.13,65.74 160.13,63.23 159.37,62.47 159.37,61.2 158.89,60.72 158.89,53.47 158.59,53.17 v2(158.57,53.17)
  IN3 w0.122: v2(158.57,53.17) 158.59,53.17 159.69,54.27 168.28,54.27 171.8,50.75 186.37,50.75 187.46,49.66 199.72,49.66 200.36,50.3 v2(201.63,50.3)
DOCK_LOM_ACTLED_YEL#: length 51.2
  IN4 w0.084: v2(208.85,124.81) 207.65,123.6 200.3,123.6 197.83,126.08 183.08,126.08 180.05,129.11 174.71,129.11 169.4,134.42 v2(168.34,134.42)
  BOTTOM w0.102: JDOCK1.100 168.25,136.4 168.25,134.51 v2(168.34,134.42) ; UL4.19 209.59,124.07 v1(209.32,124.34) v2(208.85,124.81)
DOCK_LOM_SPD10LED_GRN#: length 97.5
  IN3 w0.122: v2(142.05,130.86) 143.07,131.88 145.61,131.88 145.99,132.26 147.83,132.26 147.97,132.12 148.96,132.12 151.07,134.23 154.78,134.23 155.89,133.12 155.89,132.67 156.64,131.92 159.21,131.92 160.37,130.76 161.89,130.76 162.37,130.28 164.26,130.28 164.84,130.87 166.65,130.87 169.44,128.08 173.17,128.08 174.41,126.84 175.33,126.84 176.31,125.86 194.16,125.86 195.86,124.16 197.16,124.16 200.43,120.89 207.93,120.89 209.55,122.51 211.36,122.51 212.63,121.24 219.11,121.24 220.35,122.48 222.76,122.48 223.1,122.14 v2(223.1,121.84)
  BOTTOM w0.102: v2(142.05,130.86) 142.47,130.45 142.47,129.95 142.25,129.73 JDOCK1.3 ; v2(223.1,121.84) 223.1,122.96 v1(222.85,123.22) 221.49,124.57 UL4.40
DOCK_LOM_SPD100LED_ORG#: length 82.1
  TOP w0.102: v2(209.49,124.83) v1(209.49,125.43)
  IN4 w0.084: v2(209.49,124.83) 209.11,125.21 208.54,125.21 207.14,123.82 200.41,123.82 196.37,127.85 182.5,127.85 179.61,130.75 179.61,135.2 176.9,137.9 165.97,137.9 165.52,137.46 155.59,137.46 155.16,137.89 153.72,137.89 153.28,137.45 144.19,137.45 v2(142.25,135.51)
  BOTTOM w0.102: v2(142.25,135.51) JDOCK1.4 ; UL4.20 209.75,124.57 v2(209.49,124.83)
DOCK_LOM_TRD0+: length 65
  IN2 w0.102: v2(170.25,134.16) 171.32,133.09 172.8,133.09 173.99,131.89 173.99,130.72 176.96,127.75 177.75,127.75 181.03,124.48 195.18,124.48 198.93,120.73 201.34,120.73 202.03,120.05 211.2,120.05 214.08,122.93 218.48,122.93 219.26,123.71 v2(219.26,127.11)
  BOTTOM w0.089: UL4.36 219.22,127.07 v2(219.26,127.11) ; v2(170.25,134.16) 169.69,134.16 169.25,134.6 JDOCK1.104
DOCK_LOM_TRD0-: length 64.8
  IN2 w0.102: v2(170.25,134.74) 170.68,134.32 170.68,134.09 171.43,133.34 172.9,133.34 174.25,132 174.25,130.82 177.06,128.01 177.86,128.01 181.14,124.73 195.28,124.73 199.03,120.98 201.45,120.98 202.13,120.3 211.1,120.3 213.98,123.18 218.38,123.18 219.01,123.81 219.01,126.78 v2(218.68,127.11)
  BOTTOM w0.089: JDOCK1.106 169.75,135.8 169.57,135.62 169.57,134.73 169.83,134.48 169.98,134.48 v2(170.25,134.74) ; v2(218.68,127.11) 218.9,126.89 218.9,126.68 218.72,126.49 UL4.35
DOCK_LOM_TRD1+: length 58.7
  IN2 w0.102: v2(217.26,126.99) 217.26,126.36 215.1,124.2 213.84,124.2 210.76,121.11 202.47,121.11 201.79,121.8 199.67,121.8 195.89,125.58 181.47,125.58 178.2,128.84 177.38,128.84 175.06,131.16 175.06,132.33 173.23,134.16 v2(171.81,134.16)
  BOTTOM w0.089: UL4.32 217.22,126.94 v2(217.26,126.99) ; v2(171.81,134.16) 171.32,134.16 171.06,134.42 171.06,135.06 170.75,135.37 JDOCK1.110
DOCK_LOM_TRD1-: length 58.6
  IN2 w0.102: v2(216.68,126.99) 217.01,126.66 217.01,126.46 215,124.45 213.74,124.45 210.66,121.37 202.57,121.37 201.89,122.05 199.78,122.05 195.99,125.83 181.57,125.83 178.31,129.1 177.48,129.1 175.31,131.27 175.31,132.44 173.34,134.41 172.14,134.41 172.04,134.52 172.04,134.64 171.94,134.74 v2(171.81,134.74)
  BOTTOM w0.089: UL4.31 216.72,126.53 216.78,126.58 216.87,126.58 216.9,126.62 216.9,126.8 216.72,126.99 v2(216.68,126.99) ; v2(171.81,134.74) 171.81,134.73 171.56,134.48 171.45,134.48 171.38,134.55 171.38,135.2 171.07,135.5 171.07,135.76 171.12,135.81 171.2,135.81 171.25,135.86 JDOCK1.112
DOCK_LOM_TRD2+: length 52.6
  IN2 w0.102: v2(174.62,134.16) 175.01,134.16 175.17,134 175.17,133.73 176.13,132.78 176.13,131.6 177.82,129.91 178.64,129.91 181.91,126.65 196.33,126.65 200.11,122.86 204.49,122.86 205.09,122.27 210.29,122.27 214.76,126.74 v2(214.76,127.11)
  BOTTOM w0.089: JDOCK1.122 173.75,134.51 174.1,134.16 v2(174.62,134.16) ; v2(214.76,127.11) 214.72,127.07 UL4.27
DOCK_LOM_TRD2-: length 52.3
  IN2 w0.102: v2(174.62,134.74) 174.77,134.74 174.87,134.64 174.87,134.52 174.97,134.41 175.12,134.41 175.43,134.1 175.43,133.83 176.38,132.88 176.38,131.71 177.92,130.17 178.75,130.17 182.01,126.9 196.44,126.9 200.22,123.12 204.6,123.12 205.2,122.52 210.18,122.52 214.48,126.81 v2(214.18,127.11)
  BOTTOM w0.089: JDOCK1.124 174.25,135.74 174.19,135.68 174.13,135.68 174.07,135.62 174.07,134.64 174.23,134.48 174.36,134.48 v2(174.62,134.74) ; v2(214.18,127.11) 214.4,126.89 214.4,126.63 214.22,126.45 UL4.26
DOCK_LOM_TRD3+: length 48.3
  IN2 w0.102: v2(176.38,134.16) 176.84,134.16 177.19,133.81 177.19,132.05 178.04,131.19 178.87,131.19 182.34,127.73 189.38,127.73 189.66,128.01 196.48,128.01 200.56,123.93 210.43,123.93 212.76,126.26 v2(212.76,127.11)
  BOTTOM w0.089: v2(176.38,134.16) 175.84,134.16 175.25,134.75 JDOCK1.128 ; UL4.23 212.72,127.07 v2(212.76,127.11)
DOCK_LOM_TRD3-: length 48
  IN2 w0.102: v2(212.18,127.11) 212.51,126.78 212.51,126.37 210.32,124.18 200.66,124.18 196.59,128.26 189.55,128.26 189.27,127.98 182.44,127.98 178.98,131.45 178.15,131.45 177.45,132.15 177.45,133.92 176.95,134.41 176.75,134.41 176.65,134.52 176.65,134.64 176.55,134.74 v2(176.38,134.74)
  BOTTOM w0.089: v2(212.18,127.11) 212.4,126.89 212.4,126.67 212.22,126.48 UL4.22 ; v2(176.38,134.74) 176.11,134.48 175.97,134.48 175.57,134.88 175.57,135.62 175.63,135.68 175.68,135.68 175.75,135.75 JDOCK1.130
DOCK_MIC_DET: length 120
  TOP w0.102: v2(199.53,51.3) 200.36,52.12 203.84,52.12 206.46,54.75 206.46,57.23 206.87,57.65 206.87,60.9 206.54,61.24 QA3.5 205.38,61.24 RA26.2 ; v2(179.19,102.4) 178.84,102.05 178.29,102.05 178.25,102.09 UE1.B8 ; v1(159.29,56.43) v2(159.83,56.43)
  IN2 w0.122: v2(159.83,56.43) 160.12,56.72 160.12,59.42 161.43,60.73 161.43,61.15 162.97,62.69 162.97,66.05 164.2,67.29 164.2,68.08 166.79,70.67 166.79,71.34 169.87,74.41 169.87,75.86 175.34,81.33 176.18,81.33 176.47,81.63 176.47,83.89 182.79,90.2 182.79,92.22 184.12,93.55 184.12,94.35 183.81,94.67 183.81,96.14 183.1,96.86 183.1,98.78 182.96,98.91 182.96,99.56 180.12,102.4 v2(179.19,102.4)
  IN3 w0.122: v2(199.53,51.3) 194.58,51.3 194.06,50.78 187.75,50.78 186.78,51.74 172.21,51.74 168.76,55.2 161.07,55.2 v2(159.83,56.43)
DOCK_POR_RST#: length 67.1
  TOP w0.102: v2(208.03,98.64) 208.03,99.24 RE277.2 207.23,98.77 207.23,97.98 207.37,97.84 UE2.A21
  IN3 w0.122: v2(179.45,127.02) 193.36,127.02 195.94,124.44 200.78,124.44 v2(200.94,124.6)
  BOTTOM w0.102: v2(200.94,124.6) 200.6,124.26 v1(200.6,122.11) 200.6,118.68 202,117.28 202,112.01 203.23,110.78 203.23,103.61 204.79,102.05 206.7,102.05 207.95,100.8 207.95,98.72 v2(208.03,98.64) ; v2(179.45,127.02) 179.58,127.15 179.58,129.91 178.84,130.65 178.84,131.53 179.64,132.33 179.64,133.4 178.56,134.48 178.56,135.56 178.25,135.88 JDOCK1.140
DOCK_PSID: length 145.7
  TOP w0.102: v2(108.65,127.42) 102.57,127.42 100.59,125.44 v2(98.76,125.44)
  TOP w0.254: v2(64.37,114.35) 64.56,114.16 v1(65.83,114.16) 67.3,114.16 68.66,115.52 PU1.1
  IN3 w0.122: v2(98.76,125.44) 98.22,124.91 82.59,124.91 81.98,124.3 63.27,124.3 61.86,122.89 61.86,116.86 v2(64.37,114.35) ; v2(177.8,124.77) 176.81,124.77 176.32,124.28 171.22,124.28 169.18,126.32 164.75,126.32 161.57,129.5 157,129.5 154.97,131.54 153.26,131.54 153.26,131.54 152.02,131.54 149.47,128.98 142.6,128.98 140.48,126.86 125.41,126.86 123.87,125.32 121.91,125.32 120,123.42 118.94,123.42 118.67,123.69 112.71,123.69 108.98,127.42 v2(108.65,127.42)
  BOTTOM w0.102: JDOCK1.135 177.25,126.35 177.8,125.8 v2(177.8,124.77)
DOCK_PWR_BTN#: length 94.3
  TOP w0.102: RE42.2 211.99,78.12 CE44.1 212.22,78.35 v2(212.22,78.98)
  IN2 w0.122: v2(184.34,121.09) 182.82,121.09 181.85,120.12 181.85,117.39 182.5,116.74 182.5,107.62 183.21,106.92 189.27,106.92 191.25,104.93 191.25,99.72 190.72,99.19 190.72,96.8 191.47,96.06 191.47,93.92 190.76,93.21 189.88,93.21 187.43,90.75 187.43,89.54 186.01,88.12 186.01,86.65 188.03,84.64 188.03,81.91 189.74,80.19 v2(189.74,79.56)
  IN3 w0.122: v2(189.74,79.56) 189.98,79.8 199.23,79.8 200.27,80.84 203.43,80.84 206.8,77.46 209,77.46 210.46,78.92 212.16,78.92 v2(212.22,78.98)
  BOTTOM w0.102: JDOCK1.139 178.25,127.55 178.07,127.37 178.07,126.18 v1(181.73,122.51) 183.16,121.09 v2(184.34,121.09)
DOCK_PWR_SW#: length 13.2
  TOP w0.102: UE2.A63 208.87,86.34 209.35,85.86 209.73,85.86 210.01,85.58 210.64,85.58 211.06,85.99 211.47,85.99 211.8,85.65 211.8,85.33 211.51,85.04 211.51,83.4 RE62.2 211.04,82.1 v1(210.85,81.91) 210.85,81.25 211.88,80.22 211.88,79.4 211.51,79.04 RE42.1 CE45.1
DOCK_SMB_ALERT#: length 244.2
  TOP w0.102: UE1.A51 185.19,107.54 v2(185.74,108.09) 185.74,108.63 RE9.2
  IN2 w0.122: v2(182.31,119.46) 182.31,117.4 185.68,114.03 185.68,108.14 v2(185.74,108.09)
  IN3 w0.122: v2(185.74,108.09) 186.84,106.98 188.83,106.98 189.59,106.22 192.58,106.22 193.35,105.45 198.7,105.45 200.47,107.22 206.13,107.22 207,108.09 214.1,108.09 217.82,104.38 217.82,102.24 221.55,98.5 221.55,95.75 227.94,89.37 227.94,87.2 227.43,86.69 227.43,79.71 228.22,78.91 228.22,70.89 227.37,70.04 227.37,67.72 224.37,64.72 221.86,64.72 220.24,63.1 220.24,59.42 216.9,56.08 216.9,49.58 218.64,47.84 218.64,47.3 219.36,46.58 219.36,44.59 219.1,44.33 217.34,44.33 214.09,41.08 214.09,15.32 209.36,10.59 199.72,10.59 199.11,9.99 172.31,9.99 171.87,9.55 150.08,9.55 149.49,10.15 v2(147.64,10.15)
  BOTTOM w0.102: v2(182.31,119.46) 181.54,119.46 v1(180.12,120.88) 177.38,123.61 177.38,125.89 176.75,126.52 JDOCK1.133
  BOTTOM w0.254: PQ1.3 148.63,15.4 148.4,15.17 146.85,15.17 146.62,14.94 146.62,11.17 v2(147.64,10.15)
DOCK_SMB_CLK: length 84.6
  TOP w0.102: UE2.B4 209.73,89.5 v2(209.51,89.28) ; v2(216.55,89.79) 216.2,89.44 215.71,89.44 215.56,89.59 RPE3.2
  IN1 w0.084: v2(184.66,113.08) 184.86,112.88 184.86,112.69 185.11,112.44 185.86,112.44 185.94,112.51 195.75,112.51 196.59,111.67 200.32,111.67 200.45,111.8 213.33,111.8 218.04,107.09 218.04,100.93 217.66,100.55 217.66,93.71 217.12,93.17 217.12,89.71 217.02,89.61 216.73,89.61 v2(216.55,89.79)
  IN4 w0.084: v2(216.55,89.79) 216.28,89.52 214.44,89.52 213.62,88.7 212.49,88.7 212.48,88.7 210.5,88.7 209.92,89.28 v2(209.51,89.28)
  BOTTOM w0.102: v2(184.66,113.08) 184.81,113.24 184.81,115.03 176.56,123.29 176.56,125.57 175.4,126.73 175.4,127.65 175.25,127.8 JDOCK1.127
DOCK_SMB_DAT: length 82.9
  TOP w0.102: UE2.A3 211.46,89.25 211.56,89.14 211.9,89.14 212.41,88.64 v2(212.41,88.31) ; RPE3.1 215.56,89.09 215.71,89.24 216.52,89.24 v2(216.56,89.2)
  IN1 w0.084: v2(185.24,113.08) 185.04,112.88 185.04,112.76 185.18,112.62 185.79,112.62 185.86,112.7 195.82,112.7 196.67,111.85 200.24,111.85 200.38,111.99 213.41,111.99 218.23,107.17 218.23,100.85 217.85,100.47 217.85,93.63 217.31,93.09 217.31,89.63 217.1,89.42 216.79,89.42 v2(216.56,89.2)
  IN4 w0.084: v2(216.56,89.2) 216.42,89.34 214.52,89.34 213.7,88.51 212.63,88.51 212.41,88.29 v2(212.41,88.31)
  BOTTOM w0.102: v2(185.24,113.08) 185.02,113.31 185.02,115.12 176.76,123.37 176.76,125.65 175.6,126.81 175.6,127.65 175.75,127.8 JDOCK1.129
DOCK_USB3RN1: length 49
  TOP w0.102: UI4.22 129.73,132.58 129.67,132.64 129.67,133.33 129.61,133.39 129.61,133.47 v2(129.83,133.69)
  IN1 w0.091: v2(129.83,133.69) 129.6,133.47 129.6,132.71 129.86,132.45 132,132.45 133.14,131.31 133.14,128.18 134.52,126.8 137.79,126.8 138.08,127.09 142.53,127.09 144.98,129.54 150.58,129.54 152.12,131.07 163.42,131.07 163.51,131.16 163.51,131.28 163.22,131.56 v2(163.21,131.56)
  BOTTOM w0.102: JDOCK1.84 163.25,135.88 163.3,135.82 163.47,135.82 163.53,135.76 163.53,132.25 163.58,132.21 163.58,131.93 v2(163.21,131.56)
DOCK_USB3RP1: length 49.1
  TOP w0.102: UI4.23 129.33,132.67 129.45,132.79 129.45,133.24 129.39,133.3 129.39,133.54 v2(129.24,133.69)
  IN1 w0.091: v2(163.79,131.56) 163.68,131.45 163.68,131.09 163.49,130.9 152.19,130.9 150.66,129.37 145.05,129.37 142.6,126.92 138.15,126.92 137.86,126.63 134.45,126.63 132.97,128.11 132.97,131.24 131.92,132.28 129.79,132.28 129.43,132.64 129.43,133.51 v2(129.24,133.69)
  BOTTOM w0.102: v2(163.79,131.56) 163.79,132.3 163.75,132.34 JDOCK1.86
DOCK_USB3TN1: length 51.3
  TOP w0.102: v2(129.03,133.11) 128.79,132.88 128.79,132.67 128.93,132.53 UI4.24
  IN1 w0.091: v2(164.38,131.57) 164.79,131.16 164.79,130.87 163.69,129.76 156.3,129.76 155.8,130.26 152.68,130.26 150.99,128.58 145.81,128.58 143.68,126.45 139.61,126.45 139.19,126.03 134.32,126.03 132.37,127.98 132.37,130.99 131.68,131.68 129.51,131.68 128.66,132.53 128.66,132.74 v2(129.03,133.11)
  BOTTOM w0.102: v2(164.38,131.57) 164.74,131.94 164.74,133.02 164.89,133.17 164.89,135.66 164.75,135.8 JDOCK1.90
DOCK_USB3TP1: length 51.4
  TOP w0.102: UI4.25 128.53,132.57 128.58,132.61 128.58,132.97 v2(128.44,133.11)
  IN1 w0.091: v2(164.96,131.57) 164.96,130.8 163.76,129.59 156.22,129.59 155.73,130.09 152.75,130.09 151.07,128.41 145.88,128.41 143.75,126.27 139.68,126.27 139.27,125.86 134.24,125.86 132.19,127.9 132.19,130.92 131.6,131.51 129.44,131.51 128.49,132.46 128.49,133.06 v2(128.44,133.11)
  BOTTOM w0.102: v2(164.96,131.57) 164.96,132.93 165.11,133.08 165.11,135.66 165.25,135.8 JDOCK1.92
DOCK_USBP0+: length 37.8
  TOP w0.102: UI4.15 133.39,130.92 133.49,130.82 133.61,130.82 v2(133.79,131)
  IN1 w0.091: v2(133.79,131) 134,130.8 134.18,130.8 134.37,130.61 134.37,129.91 133.91,129.45 133.91,128.4 134.74,127.57 137.6,127.57 137.82,127.8 142.11,127.8 145.14,130.83 150.51,130.83 151.53,131.85 151.53,133.68 152.06,134.21 160,134.21 160.62,134.83 160.62,134.98 v2(160.21,135.39)
  BOTTOM w0.102: JDOCK1.72 160.25,135.97 160.46,135.76 160.46,135.64 v2(160.21,135.39)
DOCK_USBP0-: length 37.8
  TOP w0.102: v2(133.79,130.42) 133.61,130.6 133.47,130.6 133.39,130.52 UI4.14
  IN1 w0.091: v2(133.79,130.42) 134,130.62 134.11,130.62 134.2,130.54 134.2,129.98 133.74,129.53 133.74,128.33 134.67,127.4 137.67,127.4 137.9,127.63 142.18,127.63 145.21,130.66 150.58,130.66 151.7,131.78 151.7,133.61 152.13,134.04 160.08,134.04 160.79,134.75 v2(160.79,135.39)
  BOTTOM w0.102: JDOCK1.74 160.75,135.96 160.67,135.88 160.67,135.51 v2(160.79,135.39)
DOCK_USBP3+: length 46.6
  IN1 w0.091: v2(131.52,124.78) 132.23,124.07 134.11,124.07 134.23,123.94 155.15,123.94 155.4,124.19 159.38,124.19 159.8,123.77 159.8,123.66 v2(159.5,123.36)
  IN4 w0.091: v2(158.3,130.23) 158.52,130 158.52,129.7 160.17,128.06 160.17,126.32 159.79,125.95 159.79,123.65 v2(159.5,123.36)
  BOTTOM w0.102: v2(131.52,124.78) 131.68,124.62 131.68,124.51 131.52,124.36 130.42,124.36 130.29,124.49 UI5.3 ; JDOCK1.66 158.75,135.87 158.92,135.7 158.92,132.02 158.47,131.58 158.47,130.41 v2(158.3,130.23)
DOCK_USBP3-: length 46.6
  IN1 w0.091: v2(160.08,123.36) 159.97,123.47 159.97,123.84 159.45,124.36 155.33,124.36 155.08,124.11 134.31,124.11 134.18,124.24 132.3,124.24 132.1,124.44 v2(132.1,124.78)
  IN4 w0.091: v2(158.88,130.23) 158.7,130.05 158.7,129.77 160.34,128.13 160.34,126.25 159.97,125.88 159.97,123.48 v2(160.08,123.36)
  BOTTOM w0.102: v2(132.1,124.78) 131.89,124.57 131.89,124.43 131.61,124.15 130.44,124.15 130.29,123.99 UI5.4 ; v2(158.88,130.23) 158.69,130.42 158.69,131.49 159.13,131.93 159.13,135.73 159.25,135.85 JDOCK1.68
DOCKED: length 187.4
  TOP w0.102: v2(189.31,100.17) 188.9,100.57 188.47,100.57 188.24,100.34 UE1.A38 ; UI4.32 126.23,129.72 126.01,129.51 v1(126.01,127.74) 126.01,127.46 126.47,127 130.95,127 131.22,127.27 131.22,127.65 131.52,127.95 v2(131.52,128.16) 131.52,128.38 131.33,128.56 UI4.10
  IN2 w0.122: v2(145.54,103.31) 144.3,104.55 144.3,109.25 143.85,109.7 143.85,111.63 142.41,113.07 140.36,113.07 138.24,115.18 137.54,115.18 133.86,118.86 133.86,124.52 132.97,125.42 132.53,125.42 132.31,125.63 v2(132.31,125.89)
  IN3 w0.122: v2(214.07,119.45) 211.26,122.26 209.65,122.26 208.03,120.65 199.42,120.65 196.16,123.91 195.76,123.91 194.51,125.15 v2(188.88,125.15) 186.21,125.15 185.81,125.56 170.35,125.56 169.33,126.57 167.93,126.57 v2(167.6,126.9) 166.62,127.88 165.35,127.88 163.48,129.75 157.11,129.75 155.07,131.79 153.36,131.79 151.92,131.79 149.36,129.23 142.5,129.23 140.38,127.11 133.5,127.11 132.45,128.16 v2(131.52,128.16)
  IN4 w0.084: v2(145.54,103.31) 144.59,103.31 143.58,102.29 140.59,102.29 139.54,101.24 v2(139.54,100.46) 138.92,101.08 138.56,101.08 138.37,100.89 v2(138.37,100.46) ; v2(131.52,128.16) 131.73,128.16 132.31,127.57 v2(132.31,125.89)
  BOTTOM w0.102: v2(214.07,119.45) 213.98,119.54 213.98,121.9 214.22,122.15 UL4.13 ; v2(188.88,125.15) 188.41,124.68 188.41,120.52 190.15,118.79 190.15,101.01 v2(189.31,100.17) ; v2(167.6,126.9) 167.6,120.19 169.28,118.51 169.28,117.48 169.12,117.31 QV700.2 ; UV13.3 139.35,100.87 139.54,100.69 v2(139.54,100.46) ; v2(138.37,100.46) 138.55,100.65 UV13.5
DOCKED#: length 4.2
  BOTTOM w0.102: v1(170.65,115.57) QV700.6 171.83,116.66 RV701.2 171.64,117.31 QV700.5
DOCKED_LIO_EN: length 85.3
  TOP w0.102: v2(188.72,116) 188.23,115.51 188.23,113.15 187.81,112.73 187.81,111.78 v1(187.98,111.6) 188.17,111.42 188.17,107.22 187.87,106.92 186.76,106.92 186.44,106.61 UE1.B52
  IN3 w0.122: v2(127.45,121.4) 128.6,122.56 130.18,122.56 130.92,121.81 133.06,121.81 134.71,123.46 136.38,123.46 136.72,123.12 139.18,123.12 141.34,125.28 151.46,125.28 152.17,124.56 167.59,124.56 170.78,121.38 182.78,121.38 188.15,116 v2(188.72,116)
  BOTTOM w0.102: v2(127.45,121.4) 127.23,121.62 127.23,122.99 126.53,123.69 126.53,124.87 127.16,125.49 UI5.9
DPB_CA_DET: length 59.8
  TOP w0.102: v2(132.67,122.83) 133.66,123.82 136.55,123.82 136.68,123.94 136.68,124.74 v1(135.58,125.85) 135.58,127.12 136.08,127.63 138.31,127.63 138.75,128.07 138.75,128.83 v2(138.88,128.96)
  IN1 w0.091: v2(143.2,134.74) 143.83,134.1 143.83,132.26 142.62,131.05 142.62,129.59 141.61,128.58 139.83,128.58 139.45,128.96 v2(138.88,128.96)
  IN2 w0.114: v2(132.67,122.83) 132.69,122.85 132.72,122.85 132.73,122.86 132.84,122.86 133.16,122.55 133.16,121.41 v2(132.58,120.83)
  BOTTOM w0.102: v2(138.88,128.96) 138.81,128.9 138.81,127.44 140.96,125.29 140.96,124.97 141.67,124.26 RV508.2 ; UV11.4 132.91,123.12 132.72,122.93 132.72,122.89 132.65,122.83 v2(132.67,122.83) ; JDOCK1.6 142.75,135.18 v2(143.2,134.74) ; v2(132.58,120.83) 132.92,121.17 UV11.1 134.5,121.17 134.72,120.94 134.72,120.81 134.05,120.13 134.05,119.5 134.82,118.73 QV9.2 135.51,118.34 135.59,118.42 140.66,118.42 141.87,117.2 141.87,114.96 142.29,114.54 146.81,114.54 147.25,114.98 148.74,114.98 148.9,115.13 148.9,116.16 148.57,116.48 UV8.M14
DPB_CA_DET#: length 13.7
  TOP w0.102: RV90.2 136.91,125.57 136.91,123.82 137.04,123.69 137.74,123.69 v2(137.89,123.54) 137.89,123.05 137.72,122.89 v2(137.72,122.48)
  BOTTOM w0.102: UV11.13 138.28,121.82 137.72,122.38 v2(137.72,122.48) 137.28,122.93 136.71,122.93 136.43,122.65 136.43,119.53 136.72,119.25 QV9.1 ; UV11.10 138.11,123.77 v2(137.89,123.54)
DPB_DOCK_AUX: length 32.4
  IN4 w0.091: v2(137.34,124.54) 137.54,124.74 137.54,124.98 137.73,125.16 141.56,125.16 146.16,129.77 149.79,129.77 151.28,131.25 151.28,132.44 149.91,133.81 149.91,134.98 v2(149.71,135.18)
  BOTTOM w0.102: UV11.3 134.68,122.47 134.72,122.51 134.72,122.77 135.52,123.57 136.38,123.57 136.84,124.04 136.84,124.77 137.04,124.96 137.35,124.96 137.48,124.83 137.48,124.68 v2(137.34,124.54) 137.34,123.45 137.67,123.12 UV11.11 ; v2(149.71,135.18) 149.89,135.37 149.89,135.66 149.75,135.8 JDOCK1.34
DPB_DOCK_AUX#: length 34.7
  IN4 w0.091: v2(150.29,135.18) 150.09,134.98 150.09,133.88 151.45,132.52 151.45,131.18 149.86,129.59 146.23,129.59 141.63,124.99 137.8,124.99 137.72,124.91 137.72,124.81 v2(137.98,124.55)
  BOTTOM w0.102: UV11.6 134.54,124.42 135.16,123.79 136.29,123.79 136.63,124.13 136.63,124.86 136.95,125.17 137.44,125.17 137.7,124.92 137.7,124.83 v2(137.98,124.55) 137.98,125.49 137.89,125.58 137.14,125.58 137.04,125.68 137.04,125.94 137.14,126.04 138.48,126.04 138.61,125.91 138.61,125.16 138.71,125.07 UV11.8 ; JDOCK1.36 150.25,135.8 150.11,135.66 150.11,135.37 v2(150.29,135.18)
DPB_DOCK_HPD: length 38.9
  TOP w0.102: R271.1 C311.1 150.95,136.26 151.29,135.93 v2(151.29,135.38)
  IN4 w0.084: v2(151.29,135.38) 152.19,134.48 154.56,134.48 155.96,133.09 155.96,132.2 153.16,129.4 152.58,129.4 150.89,127.71 147.84,127.71 142.75,122.63 142.75,121.66 143.84,120.57 144.71,120.57 146.61,118.67 148.38,118.67 v2(148.82,119.12)
  BOTTOM w0.102: UV8.K14 149.87,117.01 148.82,118.06 v1(148.82,118.48) v2(148.82,119.12) ; v2(151.29,135.38) 151.25,135.42 JDOCK1.40
DPB_DOCK_LANE_N0: length 7.3
  TOP w0.102: R261.1 144.89,130.7 144.89,131.35 145.19,131.65 145.19,132.28 v2(145.39,132.48)
  BOTTOM w0.102: v2(145.39,132.48) 145.19,132.69 145.19,133.42 144.11,134.5 144.11,135.66 144.25,135.8 JDOCK1.12
DPB_DOCK_LANE_N1: length 7.1
  TOP w0.102: R256.1 146.52,130.85 146.52,131.55 v2(146.62,131.65)
  BOTTOM w0.102: JDOCK1.18 145.75,135.8 145.61,135.66 145.61,134.62 146.43,133.8 146.43,131.84 v2(146.62,131.65)
DPB_DOCK_LANE_N2: length 7.3
  TOP w0.102: v2(148.57,131.24) 148.38,131.05 148.38,130.77 R264.1
  BOTTOM w0.102: v2(148.57,131.24) 148.55,131.24 148.4,131.38 148.4,131.92 147.36,132.96 147.36,134.22 147.11,134.47 147.11,135.66 147.25,135.8 JDOCK1.24
DPB_DOCK_LANE_N3: length 7.4
  TOP w0.102: v2(150.35,131.24) 150.16,131.05 150.16,130.77 R267.1
  BOTTOM w0.102: v2(150.35,131.24) 150.17,131.41 150.17,133.67 148.61,135.23 148.61,135.66 148.75,135.8 JDOCK1.30
DPB_DOCK_LANE_P0: length 7.3
  TOP w0.102: v2(144.81,132.48) 144.97,132.32 144.97,131.74 144.68,131.44 144.68,130.83 R260.1
  BOTTOM w0.102: JDOCK1.10 143.75,135.8 143.89,135.66 143.89,134.41 144.97,133.33 144.97,132.65 v2(144.81,132.48)
DPB_DOCK_LANE_P1: length 7.1
  TOP w0.102: v2(146.04,131.65) 146.31,131.39 146.31,130.69 R254.1
  BOTTOM w0.102: JDOCK1.16 145.25,135.8 145.39,135.66 145.39,134.53 146.22,133.71 146.22,131.83 v2(146.04,131.65)
DPB_DOCK_LANE_P2: length 7.3
  TOP w0.102: v2(147.98,131.24) 148.17,131.05 148.17,130.77 R262.1
  BOTTOM w0.102: JDOCK1.22 146.75,135.8 146.89,135.66 146.89,134.38 147.14,134.13 147.14,132.87 148.19,131.83 148.19,131.44 v2(147.98,131.24)
DPB_DOCK_LANE_P3: length 7.4
  TOP w0.102: v2(149.76,131.24) 149.95,131.05 149.95,130.77 R258.1
  BOTTOM w0.102: JDOCK1.28 148.25,135.8 148.39,135.66 148.39,135.14 149.95,133.58 149.95,131.43 v2(149.76,131.24)
DPB_HPD: length 52.4
  TOP w0.102: v2(120.97,118.05) 120.47,118.05 120.4,117.98 UV7.5
  IN2 w0.122: v2(120.97,118.05) 121.42,117.59 125.16,117.59 126.48,116.28 127.72,116.28 128.18,115.82 130.67,115.82 135.35,111.15 135.35,106.73 137.12,104.96 137.12,99.21 137.36,98.98 137.36,96.76 138.24,95.88 139.7,95.88 140.56,96.73 v2(140.59,96.73)
  BOTTOM w0.076: 136.24,94.37 136.24,92.15 134.95,90.86 134.81,90.86 134.57,90.62 134.57,89.91 134.41,89.74 134.41,89.19 UC1.C8
  BOTTOM w0.102: 136.24,94.37 137.14,95.27 137.14,96.88 138.01,97.76 v1(138.37,97.76) 139.9,97.76 140.59,97.06 v2(140.59,96.73) 140.59,96.45 140.72,96.32 RC142.2
DPB_LANE_N0: length 26.5
  TOP w0.102: v2(158.02,123.79) 157.72,123.5 157.53,123.5 157.28,123.24 157.28,122.88 156.99,122.58 151.01,122.58 148.41,125.18 146.47,125.18 144.73,126.91 144.73,127.74 144.81,127.82 144.96,127.82 C296.1
  BOTTOM w0.102: UV8.E14 153.24,116.73 153.24,116.82 153.69,117.26 153.69,119.17 157.27,122.75 157.27,123.29 157.51,123.54 157.76,123.54 157.87,123.65 157.88,123.65 v2(158.02,123.79)
DPB_LANE_N0_C: length 1.3
  TOP w0.102: C296.2 144.85,128.84 144.85,129.2 R261.2
DPB_LANE_N1: length 21.7
  TOP w0.102: C303.1 146.75,127.8 146.59,127.8 146.51,127.73 146.51,127.24 147.75,126.01 148.75,126.01 151.35,123.41 155.22,123.41 155.34,123.52 156.24,123.52 v2(156.5,123.78)
  BOTTOM w0.102: UV8.F14 152.55,116.69 152.55,116.89 152.8,117.14 152.8,117.62 152.85,117.67 152.85,119.51 155.58,122.24 155.58,123.08 156.02,123.52 156.25,123.52 156.5,123.77 v2(156.5,123.78)
DPB_LANE_N1_C: length 1.3
  TOP w0.102: R256.2 146.62,129.2 146.62,128.84 C303.2
DPB_LANE_N2: length 22.1
  TOP w0.102: v2(155.72,125.96) 155.5,125.75 155.14,125.75 154.78,125.39 154.78,124.98 154.04,124.23 151.69,124.23 149.09,126.83 148.5,126.83 148.29,127.04 148.29,127.73 148.4,127.84 148.49,127.84 C307.1
  BOTTOM w0.102: v2(155.72,125.96) 155.49,125.73 155.21,125.73 154.89,125.42 154.89,124.35 154.59,124.04 154.59,122.43 152,119.84 152,118.63 151.7,118.34 151.7,117.03 151.77,116.97 151.86,116.97 151.9,116.93 151.9,116.69 UV8.G14
DPB_LANE_N2_C: length 1.3
  TOP w0.102: R264.2 148.4,129.2 148.4,128.84 C307.2
DPB_LANE_N3: length 18.1
  TOP w0.102: v2(153.59,125.53) 153.81,125.31 153.81,125.17 153.7,125.06 152.45,125.06 151.84,125.67 151.84,126.71 151.41,127.14 150.14,127.14 150.07,127.22 150.07,127.74 150.17,127.84 150.27,127.84 C309.1
  BOTTOM w0.102: v2(153.59,125.53) 153.96,125.16 153.96,124.79 153.69,124.51 153.69,122.74 151.17,120.22 151.17,119.02 150.88,118.72 150.88,116.35 150.94,116.29 151.13,116.29 151.17,116.33 UV8.H14
DPB_LANE_N3_C: length 1.3
  TOP w0.102: R267.2 150.18,129.2 150.18,128.84 C309.2
DPB_LANE_P0: length 26.5
  TOP w0.102: v2(158.02,123.21) 157.94,123.28 157.62,123.28 157.5,123.15 157.5,122.79 157.08,122.37 150.92,122.37 148.32,124.96 146.38,124.96 144.52,126.82 144.52,127.37 C294.1
  BOTTOM w0.102: v2(158.02,123.21) 157.9,123.32 157.6,123.32 157.48,123.21 157.48,122.66 153.9,119.08 153.9,117.17 153.46,116.73 153.46,116.29 UV8.E13
DPB_LANE_P0_C: length 1.3
  TOP w0.102: R260.2 144.63,129.16 144.63,128.88 C294.2
DPB_LANE_P1: length 21.8
  TOP w0.102: C298.1 146.29,127.37 146.29,127.15 147.66,125.79 148.66,125.79 151.26,123.19 155.31,123.19 155.43,123.31 156.39,123.31 v2(156.5,123.2)
  BOTTOM w0.102: UV8.F13 152.77,116.26 152.77,116.81 153.01,117.05 153.01,117.53 153.06,117.58 153.06,119.42 155.79,122.15 155.79,122.99 156.11,123.31 156.39,123.31 v2(156.5,123.2)
DPB_LANE_P1_C: length 1.3
  TOP w0.102: R254.2 146.41,129.16 146.41,128.88 C298.2
DPB_LANE_P2: length 22.2
  TOP w0.102: v2(155.72,125.38) 155.56,125.53 155.23,125.53 155,125.3 155,124.89 154.13,124.02 151.6,124.02 149.01,126.62 148.41,126.62 148.07,126.95 148.07,127.37 C305.1
  BOTTOM w0.102: UV8.G13 152.12,116.25 152.12,117.09 151.92,117.29 151.92,118.25 152.21,118.55 152.21,119.75 154.8,122.34 154.8,123.96 155.11,124.26 155.11,125.33 155.3,125.52 155.58,125.52 v2(155.72,125.38)
DPB_LANE_P2_C: length 1.3
  TOP w0.102: R262.2 148.19,129.16 148.19,128.88 C305.2
DPB_LANE_P3: length 18
  TOP w0.102: C308.1 149.85,127.37 149.85,127.13 150.05,126.93 151.32,126.93 151.63,126.62 151.63,125.58 152.36,124.84 153.79,124.84 154.03,125.08 154.03,125.38 v2(154.17,125.53)
  BOTTOM w0.102: v2(154.17,125.53) 154.17,124.7 153.9,124.43 153.9,122.65 151.39,120.13 151.39,118.93 151.09,118.63 151.09,117.14 151.47,116.76 151.47,116.25 UV8.H13
DPB_LANE_P3_C: length 1.3
  TOP w0.102: C308.2 149.96,128.88 149.96,129.16 R258.2
DPB_MB_P14: length 3.2
  BOTTOM w0.102: JMDP1.6 247.05,127.45 247.71,126.78 247.71,126.45 RV503.2
DPC_CA_DET: length 69.2
  IN2 w0.114: v2(162.82,99.98) 162.66,100.14 162.66,100.14 162.63,100.17 162.63,100.83 164.02,102.23 164.02,104.07 163.59,104.5 163.19,104.5 v2(161.78,105.91) 161.19,105.91 161.12,105.85 v2(160.47,105.85) 159.96,106.35 159.96,116.96 158.55,118.37 156.49,118.37 v2(156.47,118.39) 156.47,118.63 161.42,123.59 161.42,127.88 159.99,129.31 158.15,129.31 156.03,131.43 152.58,131.43 150.22,129.06 149.77,129.06 146.56,125.85 v2(143.17,125.85)
  BOTTOM w0.102: UV8.A14 155.72,116.85 156.06,117.19 156.06,117.99 v2(156.47,118.39) ; v2(161.78,105.91) 161.74,105.95 UV12.4 ; v2(160.47,105.85) 160.15,105.85 159.79,106.21 UV12.1 ; JDOCK1.5 142.75,126.27 v2(143.17,125.85) 142.28,125.85 141.67,125.24 RV509.2 ; v2(162.82,99.98) 163.35,99.45 QV10.2
DPC_CA_DET#: length 14.9
  IN2 w0.114: v2(162.18,99.98) 162.44,100.23 162.44,100.91 163.83,102.31 163.83,103.99 163.51,104.3 162.99,104.3 162.39,103.7 v2(162.39,102.56) 161.93,102.1 161.04,102.1 160.59,102.54 v2(160.59,102.52)
  BOTTOM w0.102: v2(160.59,102.52) 160.59,102.54 160.44,102.39 UV12.13 ; RV91.2 QV10.1 162.18,99.05 v2(162.18,99.98) ; UV12.10 v2(162.39,102.56)
DPC_DOCK_AUX: length 42.8
  IN4 w0.091: v2(149.99,126.51) 150.2,126.3 150.2,124.44 152.15,122.49 157.1,122.49 157.99,121.61 159.31,121.61 163.29,117.63 163.29,115.03 165,113.33 165,111.67 162.23,108.91 162.23,105.6 162.01,105.38 162.01,104.79 v2(161.78,104.56)
  BOTTOM w0.102: v2(149.99,126.51) 150.14,126.66 150.14,126.98 149.89,127.23 149.89,127.66 149.75,127.8 JDOCK1.33 ; UV12.11 161.74,102.91 162,103.18 162.4,103.18 162.49,103.27 162.49,103.57 161.98,104.08 161.98,104.36 v2(161.78,104.56) 161.97,104.74 161.97,104.84 161.09,105.72 UV12.3
DPC_DOCK_AUX#: length 43
  IN4 w0.091: v2(162.37,104.56) 162.18,104.74 162.18,105.31 162.41,105.53 162.41,108.83 165.17,111.6 165.17,113.4 163.46,115.1 163.46,117.7 159.38,121.78 158.06,121.78 157.17,122.67 152.22,122.67 150.37,124.51 150.37,126.3 v2(150.58,126.51)
  BOTTOM w0.102: UV12.6 163.04,105.68 162.18,104.83 162.18,104.74 v2(162.37,104.56) 162.19,104.39 162.19,104.17 162.7,103.66 162.7,103.36 162.82,103.24 163.32,103.24 163.69,102.88 UV12.8 ; v2(150.58,126.51) 150.36,126.73 150.36,127.07 150.11,127.32 150.11,127.66 150.25,127.8 JDOCK1.35
DPC_DOCK_HPD: length 32.8
  IN2 w0.122: v2(157.32,110.51) 157.01,110.51 156.18,111.34 156.18,115.78 155.45,116.51 155.45,118.86 158.76,122.17 158.76,125.09 v2(159.07,125.4)
  BOTTOM w0.102: JDOCK1.39 151.25,127.47 151.58,127.14 151.58,125.85 151.2,125.47 C310.1 R268.1 152.21,125.71 152.92,126.42 156.27,126.42 156.75,125.94 158.53,125.94 v2(159.07,125.4) v1(159.07,124.9) ; UV8.A6 155.87,111.41 155.97,111.31 156.09,111.31 156.89,110.51 v2(157.32,110.51)
DPC_DOCK_LANE_N0: length 3.8
  BOTTOM w0.102: JDOCK1.11 144.25,127.8 144.11,127.66 144.11,125.58 R252.2
DPC_DOCK_LANE_N1: length 3.9
  BOTTOM w0.102: R255.2 145.89,125.58 145.89,126.93 145.61,127.21 145.61,127.66 145.75,127.8 JDOCK1.17
DPC_DOCK_LANE_N2: length 4.1
  BOTTOM w0.102: R263.2 147.68,125.57 147.68,126.43 147.11,127 147.11,127.66 147.25,127.8 JDOCK1.23
DPC_DOCK_LANE_N3: length 4.2
  BOTTOM w0.102: JDOCK1.29 148.75,127.8 148.61,127.66 148.61,127.13 149.48,126.25 149.48,125.54 R266.2
DPC_DOCK_LANE_P0: length 3.8
  BOTTOM w0.102: R259.2 143.89,125.54 143.89,127.66 143.75,127.8 JDOCK1.9
DPC_DOCK_LANE_P1: length 3.9
  BOTTOM w0.102: JDOCK1.15 145.25,127.8 145.39,127.66 145.39,127.12 145.67,126.84 145.67,125.54 R253.2
DPC_DOCK_LANE_P2: length 4.1
  BOTTOM w0.102: JDOCK1.21 146.75,127.8 146.89,127.66 146.89,126.91 147.46,126.34 147.46,125.56 R257.2
DPC_DOCK_LANE_P3: length 4.2
  BOTTOM w0.102: JDOCK1.27 148.25,127.8 148.39,127.66 148.39,127.04 149.27,126.16 149.27,125.58 R265.2
DPC_HPD: length 141.7
  TOP w0.102: v2(238.24,131.61) QV501.3
  IN2 w0.122: v2(215.27,99.88) 215.27,100.82 216.86,102.41 216.86,105.15 214.76,107.25 214.76,110.1 217.54,112.88 217.54,114.88 217.06,115.37 217.06,118.97 218.37,120.29 220.35,120.29 221.49,121.43 225.96,121.43 230,125.47 236.79,125.47 238.24,126.91 v2(238.24,131.61)
  IN3 w0.122: v2(215.27,99.88) 214.5,99.11 211.48,99.11 210.24,100.35 209.41,100.35 207.93,101.83 206.85,101.83 206.7,101.98 203.35,101.98 203.05,102.29 198.69,102.29 198.04,101.65 195.35,101.65 192.27,98.56 191.12,98.56 189.67,97.11 186.22,97.11 185.97,96.86 178.58,96.86 177.12,98.32 171.13,98.32 169.99,97.18 156.31,97.18 155.23,96.1 146.59,96.1 143.06,92.58 136.18,92.58 v2(135.87,92.89)
  BOTTOM w0.076: UC1.A8 134.28,90.57 135.66,91.94 v1(135.66,92.38) 135.66,92.68 v2(135.87,92.89)
DPC_LANE_N0: length 27.1
  IN4 w0.091: v2(157.77,111.12) 157.36,111.53 157.36,113.6 158.58,114.82 158.58,118.07 158,118.65 157.17,118.65 155.93,119.9 146.29,119.9 144.97,121.21 144.46,121.21 144.19,121.48 144.19,121.7 144.41,121.92 v2(144.44,121.92)
  BOTTOM w0.102: v2(144.44,121.92) 144.34,122.02 144.34,122.41 C295.2 ; UV8.A7 155.78,112 155.9,112 156.16,111.74 156.87,111.74 157.09,111.53 157.36,111.53 v2(157.77,111.12)
DPC_LANE_N0_C: length 1.2
  BOTTOM w0.102: C295.1 144.11,123.8 144.11,123.96 R252.1
DPC_LANE_N1: length 26.1
  IN4 w0.091: v2(158.25,111.99) 158.6,112.34 158.64,112.34 158.82,112.51 158.82,113.91 159.35,114.45 159.35,118.39 158.31,119.43 157.41,119.43 156.3,120.54 146.59,120.54 145.91,121.23 145.91,121.66 146.18,121.92 v2(146.19,121.92)
  BOTTOM w0.102: v2(158.25,111.99) 157.88,112.35 157.67,112.35 157.65,112.34 157.1,112.34 157.08,112.35 156.4,112.35 156.04,112.71 UV8.A8 ; C299.2 146.17,122.53 145.9,122.27 145.9,122.22 v2(146.19,121.92)
DPC_LANE_N1_C: length 1.2
  BOTTOM w0.102: C299.1 145.89,123.8 145.89,123.96 R255.1
DPC_LANE_N2: length 25.6
  IN4 w0.091: v2(159.47,112.99) 159.47,113.01 159.83,113.37 160.12,113.37 160.34,113.58 160.34,118.31 158.43,120.22 157.57,120.22 156.48,121.32 147.52,121.32 147.41,121.43 147.41,121.62 147.71,121.92 v2(147.73,121.92)
  BOTTOM w0.102: v2(147.73,121.92) 147.59,122.06 147.59,122.18 147.94,122.53 C306.2 ; UV8.A9 155.99,113.36 156.16,113.19 158.41,113.19 158.58,113.36 159.1,113.36 v2(159.47,112.99)
DPC_LANE_N2_C: length 1.2
  BOTTOM w0.102: C306.1 147.67,123.8 147.67,123.96 R263.1
DPC_LANE_N3: length 31.8
  IN4 w0.091: v2(149.8,121.92) 149.53,122.2 149.53,122.41 149.62,122.51 151.13,122.51 151.79,121.85 156.64,121.85 157.66,120.83 158.49,120.83 162.01,117.31 162.01,113.44 162.72,112.74 v2(164.12,112.74)
  BOTTOM w0.102: UV8.A10 155.72,113.95 155.79,113.88 155.93,113.88 156.06,114.01 157.9,114.01 158.37,114.47 159.91,114.47 161.65,112.74 v2(164.12,112.74) ; v2(149.8,121.92) 149.56,122.16 149.56,122.29 C301.2
DPC_LANE_N3_C: length 1.2
  BOTTOM w0.102: R266.1 149.44,123.96 149.44,123.8 C301.1
DPC_LANE_P0: length 27.1
  IN4 w0.091: v2(157.19,111.12) 157.19,113.67 158.41,114.89 158.41,118 157.92,118.48 157.1,118.48 155.86,119.73 146.21,119.73 144.9,121.04 144.38,121.04 144.02,121.41 144.02,121.76 v2(143.86,121.92)
  BOTTOM w0.102: UV8.B7 155.38,111.75 155.84,111.75 156.06,111.53 156.78,111.53 v2(157.19,111.12) ; v2(143.86,121.92) 143.96,122.02 143.96,122.15 C302.2
DPC_LANE_P0_C: length 1.1
  BOTTOM w0.102: C302.1 143.89,123.76 143.89,123.99 R259.1
DPC_LANE_P1: length 26.1
  IN4 w0.091: v2(158.25,112.57) 158.3,112.51 158.57,112.51 158.64,112.58 158.64,113.98 159.18,114.52 159.18,118.32 158.24,119.26 157.34,119.26 156.23,120.37 146.52,120.37 145.74,121.16 145.74,121.8 v2(145.61,121.92)
  BOTTOM w0.102: v2(145.61,121.92) 145.68,122 145.68,122.2 C297.2 ; v2(158.25,112.57) 156.49,112.57 156.13,112.93 155.95,112.93 155.87,113.01 155.37,113.01 UV8.B8
DPC_LANE_P1_C: length 1.1
  BOTTOM w0.102: R253.1 145.67,123.99 145.67,123.76 C297.1
DPC_LANE_P2: length 25.7
  IN4 w0.091: v2(159.47,113.57) 159.5,113.54 160.05,113.54 160.17,113.66 160.17,118.24 158.36,120.05 157.5,120.05 156.41,121.14 147.45,121.14 147.24,121.36 147.24,121.83 v2(147.14,121.92)
  BOTTOM w0.102: UV8.B9 155.39,113.68 155.97,113.68 156.25,113.4 158.32,113.4 158.49,113.57 v2(159.47,113.57) ; C304.2 147.37,122.29 147.37,122.15 v2(147.14,121.92)
DPC_LANE_P2_C: length 1.1
  BOTTOM w0.102: R257.1 147.45,123.99 147.45,123.76 C304.1
DPC_LANE_P3: length 31.8
  IN4 w0.091: v2(163.7,113.15) 163.64,113.08 162.62,113.08 162.18,113.52 162.18,117.38 158.56,121 157.73,121 156.71,122.02 151.86,122.02 151.2,122.68 149.55,122.68 149.35,122.48 149.35,122.06 v2(149.21,121.92)
  BOTTOM w0.102: C300.2 149.21,122.23 v2(149.21,121.92) ; UV8.B10 155.37,114.3 155.9,114.3 155.97,114.23 157.81,114.23 158.28,114.69 160,114.69 161.74,112.95 163.51,112.95 v2(163.7,113.15)
DPC_LANE_P3_C: length 1.1
  BOTTOM w0.102: R265.1 149.23,123.99 149.23,123.76 C300.1
DSWODVREN: length 10.6
  BOTTOM w0.076: 139.18,62.53 138.9,62.53 v1(138.75,62.68) 134.98,66.45 134.98,67.99 UC1.AW7
  BOTTOM w0.089: 140.11,61.6 139.18,62.53
  BOTTOM w0.102: RC78.1 140.33,61.38 140.11,61.6
EC5048_TX: length 45.5
  TOP w0.102: v1(180.81,80.41) 180.89,80.33 v2(180.89,79.66) 181.26,79.29 181.92,79.29 182.16,79.53 183.87,79.53 184.11,79.29 185.31,79.29 186.63,77.97 187.84,77.97 188.47,78.6 188.47,79.37 187.75,80.08 JDEG1.9 187.75,81.04 188.28,81.56 RE74.2 ; v2(178.48,105.45) 178.41,105.45 178.05,105.09 UE1.B2
  IN2 w0.122: v2(180.89,79.66) 181.97,80.73 181.97,88.67 183.29,90 183.29,92.01 185.18,93.9 185.18,95.13 184.2,96.1 184.2,98.92 184.36,99.08 184.36,100.41 179.89,104.88 179,104.88 178.48,105.39 v2(178.48,105.45)
EC_32KHZ_MEC5085: length 66
  TOP w0.102: UE2.B2 209.98,88.5 209.55,88.08 v2(209.55,88.08) ; UE1.B35 187.39,97.59 189.12,95.86 v1(189.12,95.28) v2(189.12,94.73) ; UZ11.2 175.6,110.47 175.35,110.21 v2(175.35,109.31)
  IN1 w0.084: v2(189.12,94.73) 190.52,93.34 191.45,93.34 192.39,92.39 193.91,92.39 194.61,91.69 196.16,91.69 196.51,92.04 201.41,92.04 201.9,91.55 202.31,91.55 203.31,90.55 208.01,90.55 208.4,90.16 209.64,90.16 209.98,89.82 209.98,88.5 v2(209.55,88.08)
  BOTTOM w0.102: v2(175.35,109.31) 175.15,109.11 174.25,109.11 172.95,107.81 172.95,103.78 173.21,103.53 173.21,96.52 175.36,94.36 178.3,94.36 178.7,94.77 178.7,96.17 179.31,96.78 187.92,96.78 189.12,95.58 v2(189.12,94.73)
EDP_BIA_PWM: length 69.1
  TOP w0.102: DV1.3 100.37,120.17 v1(98.69,118.49) 97.98,117.78 97.98,116.55 99.14,115.4 99.35,115.4 99.57,115.18 99.57,114.54 v2(99.95,114.16)
  IN2 w0.122: v2(99.95,114.16) 100.4,113.72 100.78,113.72 101.86,114.8 105.22,114.8 105.47,114.55 116.35,114.55 117.31,113.59 128.16,113.59 129.59,112.16 131.22,112.16 131.63,111.75 131.63,105.54 130.96,104.88 130.96,101.29 131.77,100.49 132.25,100.49 133.3,99.44 133.3,97.16 134.45,96.02 134.45,93.95 135.12,93.28 135.65,93.28 v2(135.87,93.5)
  BOTTOM w0.076: v2(135.87,93.5) 135.31,92.94 135.31,91.83 133.99,90.51 133.99,89.68 UC1.B8
EDP_COMP: length 4.6
  TOP w0.089: RC133.2 v1(127.46,84.39)
  TOP w0.254: v2(128.19,87.94) 128.17,87.94 127.74,87.51 127.74,85.62 RC133.2
  BOTTOM w0.254: UC1.D20 127.81,88.32 v2(128.19,87.94)
EDP_CPU_AUX: length 55.3
  TOP w0.102: v2(93.33,119.86) 93.16,119.69 93.16,119.52 CV2.1
  IN4 w0.091: v2(111.05,92.56) 111.13,92.64 111.9,92.64 116.6,97.34 116.6,114.66 114.64,116.62 113.17,116.62 111.92,117.87 108.73,117.87 107.29,119.31 93.39,119.31 93.16,119.55 93.16,119.69 v2(93.33,119.86)
  BOTTOM w0.076: v2(111.05,92.56) 111.19,92.7 111.31,92.7 111.42,92.59 111.42,92.26 111.27,92.11 111.27,90.14 111.57,89.85 UC1.B45
EDP_CPU_AUX#: length 55.2
  TOP w0.102: CV1.1 92.93,119.41 92.93,119.42 92.94,119.43 92.94,119.66 v2(92.74,119.86)
  IN4 w0.091: v2(92.74,119.86) 92.98,119.61 92.98,119.48 93.32,119.14 107.22,119.14 108.66,117.7 111.85,117.7 113.1,116.45 114.57,116.45 116.43,114.59 116.43,97.41 111.83,92.81 111.34,92.81 111.05,93.09 v2(111.05,93.21)
  BOTTOM w0.076: UC1.A45 111.72,90.26 111.8,90.35 111.8,90.48 111.46,90.82 111.46,92.03 111.61,92.18 111.61,92.67 111.39,92.89 111.23,92.89 111.05,93.07 v2(111.05,93.21)
EDP_CPU_AUX#_C: length 6.4
  TOP w0.102: CV1.2 92.99,118.21 93.11,118.1 93.11,117.73 v2(92.83,117.45)
  BOTTOM w0.102: JEDP1.33 90.47,116.82 90.18,117.1 90.18,117.26 90.96,118.04 93.02,118.04 93.16,117.9 93.16,117.78 v2(92.83,117.45)
EDP_CPU_AUX_C: length 6.5
  TOP w0.102: CV2.2 93.32,117.97 93.32,117.54 v2(93.41,117.45)
  BOTTOM w0.102: v2(93.41,117.45) 93.37,117.49 93.37,117.99 93.11,118.25 90.87,118.25 89.97,117.35 JEDP1.34
EDP_CPU_HPD: length 80.3
  IN2 w0.122: v2(140.53,94.28) 140.31,94.5 138.41,94.5 136.4,96.51 135.15,96.51 134.3,97.36 134.3,99.85 132.67,101.48 132.18,101.48 131.96,101.71 131.96,104.45 132.82,105.31 132.82,105.61 133.42,106.2 133.42,111.66 130.5,114.58 117.72,114.58 116.18,116.13 108.49,116.13 106.9,117.72 104.88,117.72 103.7,116.55 100.29,116.55 99.11,117.72 97.06,117.72 v2(94.45,115.12)
  BOTTOM w0.076: 139.48,92.07 139.04,91.63 138.42,91.63 137.84,91.05 137.39,91.05 136.95,90.61 136.8,90.61 136.59,90.4 136.59,90.07 136.76,89.91 137.08,89.91 137.2,89.78 137.2,89.46 137.06,89.32 136.62,89.32 136.34,89.04 136.34,88.95 136.17,88.78 135.91,88.78 135.62,88.48 UC1.D6
  BOTTOM w0.102: JEDP1.26 93.97,115.6 v2(94.45,115.12) ; RC141.2 140.53,94.34 v2(140.53,94.28) 140.74,94.06 v1(140.74,93.36) 140.74,92.88 139.93,92.07 139.48,92.07
EDP_CPU_LANE_N0: length 56.4
  TOP w0.102: v2(91.04,119.86) 91.22,119.67 91.22,119.48 CV4.1
  IN4 w0.091: v2(109.97,93.02) 109.97,92.91 110.27,92.62 110.27,92.62 110.41,92.75 110.41,94.01 111.13,94.73 112.84,94.73 114.76,96.66 114.76,113.46 111.17,117.05 108.36,117.05 106.92,118.5 92.86,118.5 92.22,119.13 91.69,119.13 91.33,119.49 91.33,119.56 v2(91.04,119.86)
  BOTTOM w0.076: UC1.C45 111.3,89.23 111.3,89.47 111.11,89.66 111.11,91.17 110.65,91.63 110.65,92.54 110.35,92.85 110.14,92.85 v2(109.97,93.02)
EDP_CPU_LANE_N0_C: length 5.2
  TOP w0.102: v2(89.4,115.15) 89.57,115.33 89.57,116.08 v4(90.21,116.72) 91.24,117.75 91.24,117.85 CV4.2
  BOTTOM w0.102: JEDP1.36 88.97,115.66 89.4,115.23 v2(89.4,115.15)
EDP_CPU_LANE_N1: length 58.9
  TOP w0.102: v2(89.33,119.85) 89.46,119.72 89.46,119.5 CV6.1
  IN4 w0.091: v2(89.33,119.85) 89.73,119.45 89.73,118.36 89.98,118.11 92.33,118.11 92.59,117.85 96.09,117.85 96.19,117.76 96.19,117.03 96.39,116.83 96.79,116.83 96.99,117.03 96.99,117.76 97.08,117.85 98.61,117.85 98.96,117.51 99.99,117.51 100.32,117.83 106.63,117.83 108.06,116.41 110.9,116.41 114.12,113.19 114.12,97.74 112.32,95.94 111.4,95.94 110.48,95.01 109.81,95.01 109.66,95.17 v2(109.66,95.3)
  BOTTOM w0.076: v2(109.66,95.3) 109.66,95.13 109.55,95.02 109.24,95.02 108.82,94.61 108.82,92.49 110.54,90.77 110.54,90.66 110.47,90.59 110.34,90.59 110.28,90.53 110.28,90.42 UC1.A47
EDP_CPU_LANE_N1_C: length 2.6
  TOP w0.102: CV6.2 89.09,117.87 v2(88.65,117.42)
  BOTTOM w0.102: v2(88.65,117.42) 88.68,117.39 88.68,117.18 88.53,117.02 88.33,117.02 87.97,116.66 JEDP1.38
EDP_CPU_LANE_P0: length 56.4
  TOP w0.102: CV3.1 91.44,119.45 91.44,119.67 v2(91.62,119.86)
  IN4 w0.091: v2(91.62,119.86) 91.51,119.74 91.51,119.56 91.76,119.31 92.29,119.31 92.93,118.67 106.99,118.67 108.44,117.22 111.24,117.22 114.94,113.53 114.94,96.58 112.91,94.56 111.2,94.56 110.58,93.94 110.58,92.68 110.34,92.45 110.04,92.45 v2(109.97,92.38)
  BOTTOM w0.076: UC1.B46 110.88,89.16 110.66,89.16 110.6,89.23 110.6,89.36 110.92,89.68 110.92,91.1 110.46,91.55 110.46,92.46 110.27,92.66 110.05,92.66 109.97,92.58 v2(109.97,92.38)
EDP_CPU_LANE_P0_C: length 5.2
  TOP w0.102: CV3.2 91.46,117.91 91.46,117.66 90.56,116.76 90.56,116.74 90.18,116.37 90.17,116.37 89.79,115.99 89.79,115.34 v2(89.98,115.15)
  BOTTOM w0.102: v2(89.98,115.15) 89.47,115.66 JEDP1.35
EDP_CPU_LANE_P1: length 58.9
  TOP w0.102: v2(89.92,119.85) 89.68,119.61 89.68,119.43 CV5.1
  IN4 w0.091: v2(89.92,119.85) 89.92,118.42 90.06,118.28 92.41,118.28 92.66,118.02 96.17,118.02 96.36,117.83 96.36,117.1 96.46,117 96.71,117 96.82,117.1 96.82,117.83 97.01,118.02 98.68,118.02 99.03,117.68 99.92,117.68 100.25,118.01 106.7,118.01 108.13,116.58 110.98,116.58 114.29,113.26 114.29,97.67 112.39,95.77 111.48,95.77 110.55,94.84 109.82,94.84 v2(109.66,94.67)
  BOTTOM w0.076: UC1.B47 110.44,89.85 110.73,90.14 110.73,90.85 109.01,92.57 109.01,94.53 109.32,94.83 109.49,94.83 v2(109.66,94.67)
EDP_CPU_LANE_P1_C: length 2.7
  TOP w0.102: v2(89.23,117.42) 89.98,118.17 CV5.2
  BOTTOM w0.102: v2(89.23,117.42) 88.47,116.66 JEDP1.37
EN: length 12.2
  TOP w0.102: v1(53.43,27.71) 52.92,28.22 PR113.2
  TOP w0.254: PU100.6 44.85,25.87 v2(44.5,26.22) ; PR113.2 52.36,28.38 PC119.1 51.18,28.38 50.46,27.65 49.99,27.65 48.94,26.6 v2(48.94,26.36) 48.94,26.01 48.8,25.87 PU100.20
  IN1 w0.254: v2(48.94,26.36) 48.8,26.22 v2(44.5,26.22)
EN_+V1.05SP:
  vias: v1(188.39,64.96)
EN_DK_PWRBAR: length 3.4
  TOP w0.254: PU800.17 24.74,37.04 v1(25.03,37.33) 25.58,37.87 PR874.1 PR857.1
EN_DOCK_PWR_BAR: length 223.8
  TOP w0.102: v2(186.37,98.36) 186.6,98.59 UE1.B37
  TOP w0.254: PR857.2 27.22,38.76 28.83,37.15 v1(28.83,37.14) 30.03,37.14 31.32,35.84 31.32,31.91 v2(31.44,31.8)
  IN2 w0.122: v2(31.44,31.8) 34.25,34.61 35.31,34.61 35.79,35.09 40.22,35.09 44.28,39.15 46.51,39.15 47.73,37.93 51.47,37.93 52.39,38.85 57.66,38.85 58.78,37.73 70.9,37.73 79.26,46.09 135.47,46.09 139.53,50.16 157.23,50.16 158.88,48.5 163.32,48.5 164.23,47.6 167.12,47.6 169.96,50.43 169.96,58.58 166.82,61.72 166.82,64.7 166.34,65.18 166.34,66.96 166.45,67.07 166.45,68.8 167.78,70.14 167.78,70.92 170.86,74 170.86,75.44 173.31,77.89 181.04,77.89 182.96,79.81 182.96,86.48 183.37,86.89 183.37,88.52 184.85,90 184.85,92.47 186.53,94.15 186.53,95.18 186.09,95.62 186.09,96.9 186.78,97.59 186.78,97.96 v2(186.37,98.36)
EN_I2S_NB_CODEC#: length 39.5
  TOP w0.102: UA1.1 203.86,72.97 203.98,73.09 203.98,74.06 202.71,75.33 201.64,75.33 201.41,75.56 198.44,75.56 196.36,77.64 196.36,81.16 197.98,82.78 197.98,83.92 v1(195.78,86.13) 195.28,86.63 195.28,88.6 194.52,89.36 194.52,90.72 v2(193.87,91.37) ; v2(186.36,97.78) 186.68,98.09 UE1.B36
  BOTTOM w0.102: v2(186.36,97.78) 186.83,97.31 190.62,97.31 194.12,93.81 194.12,91.62 v2(193.87,91.37)
EN_INVPWR: length 165.4
  TOP w0.102: RE55.2 205.55,99.1 v2(205.55,98.64) 205.37,98.46 UE2.A25 ; v2(86.13,124.49) v1(86.13,117.67) 86.13,115.73 83.11,112.7 QV2.2
  IN3 w0.122: v2(86.13,124.49) 101.62,124.49 102.01,124.89 105.99,124.89 109.91,120.96 121.91,120.96 122.96,122 124.75,122 126.17,123.42 126.88,123.42 128.9,125.45 133.39,125.45 133.66,125.72 138.65,125.72 139.48,126.55 140.52,126.55 142.7,128.73 151.33,128.73 152.64,130.04 155.43,130.04 157.46,128.01 158.59,128.01 159.99,126.61 163.76,126.61 164.3,126.07 169.05,126.07 171.98,123.14 190.41,123.14 190.58,123.31 195.77,123.31 v2(197.3,121.78)
  BOTTOM w0.102: v2(197.3,121.78) 197.3,120.83 201.54,116.59 201.54,108.1 202.54,107.09 202.54,103.32 204.5,101.36 205.08,101.36 205.36,101.08 205.36,99.96 205.55,99.77 v2(205.55,98.64)
EN_LCDPWR: length 6.1
  TOP w0.102: v1(76.05,121.06) UV24.3 77.39,120.43 77.43,120.39 RV3.2 76.82,118.32 75.4,118.32 DV3.1
ENVDD_PCH: length 189.7
  TOP w0.102: v2(213.03,91.68) 213.03,91.63 212.57,91.17 211.49,91.17 211.41,91.25 UE2.A7 ; DV3.3 73.32,117.21 v2(73.33,117.2) ; v2(97.48,117.28) v1(96.56,117.28)
  IN1 w0.084: v2(175.77,98.74) 175.66,98.85 175.66,101.15 175.08,101.72 175.08,102.56 176.05,103.52 176.76,103.52 177.42,102.86 191.96,102.86 193.74,101.08 202.92,101.08 204.37,99.64 204.37,97.95 205.01,97.31 207.62,97.31 208,96.93 208,93.16 208.51,92.65 210.84,92.65 211.06,92.43 212.29,92.43 v2(213.03,91.68)
  IN2 w0.122: v2(97.48,117.28) 99.57,115.18 99.57,114.99 99.89,114.67 100.33,114.67 101.04,115.38 115.87,115.38 117.41,113.84 128.26,113.84 129.08,113.02 130.71,113.02 131.88,111.86 131.88,105.42 131.21,104.76 131.21,101.4 131.87,100.74 132.36,100.74 133.55,99.54 133.55,97.21 134.7,96.07 134.7,94.34 v2(135.32,93.72) 135.5,93.89 136.03,93.89 136.35,93.58 136.35,93.17 136.54,92.98 v2(137,92.98)
  IN3 w0.122: v2(175.77,98.74) 175.6,98.57 171.02,98.57 169.89,97.43 156.2,97.43 155.12,96.35 146.48,96.35 142.96,92.83 137.15,92.83 v2(137,92.98) ; v2(73.33,117.2) 74.39,118.26 81.72,118.26 83.47,116.51 95.39,116.51 96.16,117.28 v2(97.48,117.28)
  BOTTOM w0.076: UC1.C6 135.04,89.48 135.36,89.8 135.6,90.04 135.6,90.72 135.78,90.9 136.82,91.94 137,92.11 v2(137,92.98)
  BOTTOM w0.089: RC139.2 136.43,96.47 136.43,94.83 v2(135.32,93.72)
ERC1: length 2.3
  TOP w0.254: PC815.1 19.91,30.53 v1(19.91,31.39) PU800.3
ERC2: length 2.5
  TOP w0.254: PC817.1 25.82,34.69 v1(25.11,34.69) 24.87,34.69 24.52,35.04 PU800.13
ERC3: length 4
  TOP w0.102: PC816.1 v1(27.35,33.51)
  TOP w0.254: PC816.1 25.49,33.51 24.46,34.54 PU800.12
