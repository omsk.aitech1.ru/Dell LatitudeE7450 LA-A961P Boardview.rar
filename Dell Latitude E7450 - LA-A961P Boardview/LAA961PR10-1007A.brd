# Allegro board LAA961PR10-1007A.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+5V_ALW on IN3 (solid shape): 60.7,67.73 60.7,67.32 60.7,67.31 60.66,67.15 60.7,66.99 60.7,66.97 60.7,65.62 62.36,63.96 62.36,60.97 62.34,60.93 62.32,60.89 62.31,60.75 62.36,60.6 62.36,60.51 60.66,58.81 58.64,58.81 58.52,58.93 58.52,59.86 58.65,59.99 58.68,59.98 59.06,60.08 59.11,60.47 59.11,60.48 59.11,61 59.13,61.07 59.14,61.11 59.19,61.17 59.27,61.18 59.5,61.19 59.68,61.34 59.71,61.39 59.72,61.44 59.76,61.5 59.82,61.52 59.92,61.53 60.01,61.56 60.2,61.82 60.1,62.12 60.07,62.19 60.1,62.26 60.2,62.51 60.07,62.83 60.1,62.9 60.01,63.46 59.5,63.22 59.45,63.16 59.38,63.14 59.11,63.08 58.92,62.78 58.84,62.76 58.77,62.77 58.71,62.76 58.68,62.75 58.27,63.17 58.27,64.04 58.27,67.2 59.32,68.25 60.18,68.25
+5V_ALW on IN4 (solid shape): outline of 4182 points within 66.63,7.36 216.28,35.72
+5V_ALW on VCC: 226.46,116.14 226.46,116.13 223.44,116.13 219.12,120.45 212.77,120.45 211.27,121.95 211.27,125.91 235.31,125.91 235.87,125.35 240.84,125.35 240.89,125.4 245.09,125.4 246.36,124.13 253.01,124.13 255.74,126.86 257.28,126.86 259.78,124.37 259.78,124.02 259.26,123.5 259.26,121.22 246.03,121.22 245.11,121.09 244.27,120.71 243.23,120.05 240.04,118.02 235.7,118.02 234.24,117.49 233.46,116.14
+5V_ALW on VCC: 196.15,26.14 196.15,30.34 202.55,30.34 203.63,31.42 207.63,31.42 209.36,33.16 209.36,47.45 214.57,52.65 214.57,89.5 212.58,91.49 196.83,91.49 196.28,92.04 196.28,100.22 196.96,100.89 204.83,100.89 205.81,101.87 205.81,110.04 210.72,110.04 212.3,108.45 214.97,108.45 215.27,108.15 215.27,101.04 221.94,94.37 221.94,45.05 217.39,40.51 217.39,26.14
+5V_ALW on VCC: 188.34,6.12 188.34,12.92 187.37,13.9 164.04,13.9 163.28,13.14 86.47,13.14 85.64,13.96 18.33,13.96 15.76,16.53 15.76,44.81 16.78,45.82 16.78,61.38 34.5,61.38 52.92,66.94 65.18,81.78 66.5,81.78 69.16,84.25 66.9,87.09 65.55,106.59 53.48,121.97 73.3,121.97 76.27,124.94 76.27,126.53 77.75,128.01 79.7,128.01 79.7,117.63 73.22,111.16 73.22,78.58 48.83,54.13 41.29,54.13 39.84,55.58 37.77,55.58 36.32,54.13 29.3,54.13 29.3,23.29 30.82,21.77 132.17,21.77 134.83,19.1 169.72,19.1 172.26,21.64 194.63,21.64 194.63,17.65 195.34,16.95 230.63,16.95 230.63,12.36 230.8,11.5 231.29,10.76 232.21,9.84 235.23,8.83 235.23,6.12
+5V_ALW2 on TOP (solid shape): 46.83,24.07 46.83,22.76 47.12,22.47 47.12,21.72 47.09,21.69 46.27,21.69 46.21,21.76 46.21,22.48 46.64,22.91 46.64,24.06 46.68,24.1 46.8,24.1
+5V_ALWP on TOP (solid shape): 47.25,24.06 47.25,22.91 47.51,22.65 47.6,22.65 47.82,22.43 48.19,22.43 48.29,22.33 48.29,21.92 48.24,21.87 47.41,21.87 47.27,22.01 47.27,22.55 47.06,22.76 47.06,24.07 47.08,24.1 47.21,24.1
+5V_ALWP on BOTTOM (solid shape): outline of 232 points within 53.52,8.64 65.98,20.65
+5V_HDD on BOTTOM (solid shape): 216.28,112.16 216.28,110.73 216.39,110.63 216.98,110.63 218,109.61 218,108.32 217.87,108.18 216.65,108.18 216.41,107.94 215.65,107.94 215.59,108 215.59,109.47 215.42,109.64 213.65,109.64 213.41,109.89 213.41,110.45 213.59,110.63 215.43,110.63 215.52,110.72 215.52,112.13 215.6,112.21 216.23,112.21
+5V_RUN on TOP (solid shape): 78.49,88.26 78.49,86.41 77.92,85.84 75.12,85.84 74.93,86.03 74.93,88.51 75.19,88.76 77.98,88.76
+5V_RUN on TOP (solid shape): 196.85,96.51 196.85,94.42 196.47,94.03 194.95,94.03 194.82,94.17 194.82,96.55 195.03,96.76 196.6,96.76
+5V_RUN on TOP (solid shape): 54.14,57.31 54.14,56.8 54.17,56.77 54.85,56.77 54.88,56.8 54.88,57.31 54.9,57.33 55.31,57.33 55.34,57.31 55.34,56.8 55.36,56.77 56.28,56.77 56.35,56.7 56.35,55.88 55.72,55.25 52.26,55.25 52.14,55.38 52.14,56.57 52.34,56.77 53.66,56.77 53.69,56.8 53.69,57.31 53.71,57.33 54.12,57.33
+5V_RUN on TOP (solid shape): 214.72,59.92 214.75,59.9 215.23,59.9 215.25,59.92 215.25,60.45 215.52,60.45 215.52,59.98 215.52,59.91 215.53,59.9 216.09,59.9 216.13,59.93 216.13,60.24 216.28,60.39 216.86,60.39 216.96,60.29 216.96,58.78 215.56,57.38 212.44,57.38 211.68,56.62 211.66,56.62 211.57,56.59 211.48,56.54 211.42,56.52 211.35,56.54 210.85,56.49 210.9,55.99 210.93,55.92 210.9,55.84 209.64,54.58 209.62,54.59 209.23,54.44 209.25,54.02 209.28,53.95 209.17,53.66 209.28,53.37 209.25,53.3 209.18,52.99 209.4,52.74 209.43,52.73 209.43,44.13 203.91,38.61 203.1,38.61 201.05,40.66 201.05,42.61 207.55,49.11 207.55,50.87 207.58,50.87 207.58,53.13 207.55,53.13 207.55,55.22 211.67,59.34 211.7,59.33 212.03,59.43 212.12,59.76 212.12,59.78 212.23,59.9 213.37,59.9 213.5,59.87 213.64,59.9 214.43,59.9 214.45,59.92 214.45,60.46 214.72,60.46
+5V_RUN on BOTTOM (solid shape): 81.62,88.52 81.62,87.15 81.37,86.9 77.14,86.9 76.76,87.29 76.76,88.2 77.3,88.75 81.4,88.75
+5V_RUN on BOTTOM (solid shape): 100.51,127.65 100.51,125.99 100.15,125.63 100.15,125.08 100.09,125.01 99.39,125.01 99.11,125.29 99.11,126.12 99.03,126.2 99.03,127.55 99.27,127.79 100.38,127.79
+5V_RUN on BOTTOM (solid shape): 123.41,125.78 123.41,123.89 123.87,123.43 123.87,122.28 123.56,121.96 122.66,121.96 122.11,122.51 122.11,123.42 121.13,124.4 121.13,124.56 121.72,125.15 121.95,125.15 122.73,125.93 123.26,125.93
+5V_RUN on BOTTOM (solid shape): 217.07,107.92 217.07,107.46 217.11,107.42 217.59,107.42 217.62,107.45 217.62,107.89 217.67,107.94 217.86,107.94 217.95,107.85 217.95,106.59 217.88,106.52 216.96,106.52 216.77,106.72 216.77,107.9 216.83,107.97 217.02,107.97
+5V_RUN on BOTTOM (solid shape): 100.98,113.3 100.98,111.37 100.8,111.19 98.95,111.19 98.88,111.27 98.88,111.4 98.93,111.45 99.81,111.45 99.91,111.55 99.91,111.88 99.71,112.08 99.71,113.38 100.02,113.69 100.59,113.69
+5V_RUN on IN1 (solid shape): 85.82,113.53 85.82,112.83 85.51,112.51 83.98,112.51 83.73,112.77 83.73,113.59 84.04,113.91 85.44,113.91
+5V_RUN on IN1 (solid shape): 101.03,112.7 101.03,112 100.9,111.88 99.82,111.88 99.7,112 99.7,112.89 99.76,112.96 100.78,112.96
+5V_RUN on IN1 (solid shape): 202.76,39.92 202.76,39.37 200.05,36.65 194.29,36.65 193.51,37.44 193.51,38.62 195.2,40.31 199.66,40.31 199.66,40.26 199.67,40.21 199.68,40.16 199.71,40.11 199.74,40.07 199.77,40.03 199.81,39.99 199.86,39.97 199.91,39.95 199.96,39.93 200.01,39.93 200.07,39.93 200.12,39.95 200.17,39.97 200.22,39.99 200.26,40.03 200.29,40.07 200.32,40.11 200.35,40.16 200.36,40.21 200.37,40.26 200.37,40.31 200.36,40.37 200.35,40.42 200.32,40.47 200.29,40.51 200.26,40.55 200.22,40.58 200.17,40.61 200.12,40.63 200.07,40.64 200.01,40.64 199.96,40.64 199.91,40.63 199.86,40.61 199.81,40.58 199.77,40.55 199.74,40.51 199.71,40.47 199.68,40.42 199.67,40.37 199.66,40.31 195.2,40.31 196.18,41.3 201.38,41.3
+5V_RUN on IN2 (solid shape): 85.57,114.42 85.57,112.13 85.12,111.69 83.35,111.69 83.35,114.23 83.85,114.74 85.25,114.74
+5V_RUN on IN2 (solid shape): 81.47,88.38 81.47,86.99 81.09,86.6 76.9,86.6 76.71,86.8 76.71,88.38 77.09,88.76 81.09,88.76
+5V_RUN on IN2 (solid shape): 100.75,127.31 100.75,126.22 100.42,125.89 99.46,125.89 99.25,126.1 99.25,127.58 99.38,127.71 100.36,127.71
+5V_RUN on IN2 (solid shape): 195.44,96.05 195.44,94.43 195.27,94.25 194.86,94.25 194.49,94.62 194.49,95.95 194.69,96.16 195.34,96.16
+5V_RUN on IN2 (solid shape): outline of 996 points within 214.7,59.24 225.43,107.56
+5V_RUN on IN3 (solid shape): 195.69,38.04 195.69,37.23 195.23,36.78 192.66,36.78 192.27,37.18 192.27,38.12 192.66,38.52 195.2,38.52
+5V_RUN on IN3 (solid shape): 78.41,88.55 78.41,87.49 77.18,86.26 76.14,86.26 75.86,86.54 75.86,87.77 75.87,87.79 75.87,88.36 76.32,88.8 78.16,88.8
+5V_RUN on IN3 (solid shape): outline of 305 points within 99.13,121.15 122.89,128.15
+5V_RUN on IN3 (solid shape): outline of 491 points within 52.44,54.54 69.77,64.33
+5V_RUN_AUDIO on TOP (solid shape): 217.05,63.26 217.05,61.84 215.99,60.79 215.99,60.04 215.98,60.02 215.66,60.02 215.65,60.04 215.65,60.56 215.62,60.58 215.13,60.58 215.12,60.57 215.12,60.05 215.1,60.04 214.87,60.04 214.86,60.05 214.86,60.58 214.85,60.6 214.33,60.6 214.32,60.58 214.32,60.05 214.3,60.04 213.9,60.04 213.87,60.06 213.87,60.48 213.77,60.58 212.11,60.58 211.9,60.79 211.9,61.37 211.95,61.42 215.86,61.42 216.13,61.69 216.13,63.08 216.35,63.3 217.01,63.3
+5V_RUN_PVDD on TOP (solid shape): outline of 180 points within 196.81,75.77 203.36,80.43
+5V_RUN_UZ9 on TOP (solid shape): 56.34,60 56.34,57.43 55.93,57.03 55.6,57.03 55.53,57.1 55.53,57.42 55.46,57.48 52.76,57.48 52.67,57.57 52.67,58.59 52.85,58.77 53.94,58.77 54.23,59.06 54.23,59.77 54.27,59.81 54.93,59.81 55.17,60.05 55.51,60.05 56.29,60.05
+5V_USB_CHG_PWR on TOP (solid shape): 59.79,122.37 59.79,121.4 59.69,121.3 58.33,121.3 58.14,121.49 58.14,122.52 58.26,122.63 59.53,122.63
+5V_USB_CHG_PWR on BOTTOM (solid shape): 71.25,127.12 71.25,122.29 70.93,121.97 68.84,121.97 68.65,122.16 68.65,127.24 69.09,127.69 70.68,127.69
+5V_USB_CHG_PWR on IN2 (solid shape): outline of 128 points within 57.91,121.21 70.17,126.1
+GND_CHASSIS on TOP (solid shape): 267.53,122.55 279.97,122.55 280.08,122.44 280.08,121.48 280,121.4 265.61,121.4 265.08,121.94 265.08,123.43 265.39,123.75 266.32,123.75
+GND_CHASSIS on BOTTOM (solid shape): 266.36,123.69 266.36,121.5 266.26,121.4 264.33,121.4 264.05,121.68 264.05,124.17 264.24,124.36 265.69,124.36
+V1.05SP_B+ on TOP (solid shape): 194.38,68.57 194.38,67.9 194.27,67.8 192.55,67.8 192.5,67.85 192.5,68.58 192.6,68.68 194.26,68.68
+V1.05SP_B+ on BOTTOM (solid shape): 195.68,69.68 195.68,69.41 195.65,69.37 195.16,69.37 195.14,69.35 195.14,68.85 195.16,68.82 195.66,68.82 195.68,68.8 195.68,68.58 195.67,68.57 195.15,68.57 195.14,68.56 195.14,68.04 195.15,68.02 195.67,68.02 195.68,68.01 195.68,66.07 195.39,65.78 195.18,65.78 194.9,66.06 194.9,66.59 194.63,66.86 194.33,66.86 193.4,67.78 193.37,67.78 193.36,67.78 192.41,67.78 192.18,67.55 190.5,67.55 190.45,67.61 190.45,69.38 190.59,69.52 194.71,69.52 194.9,69.71 195.65,69.71
+VCC_CORE on TOP (solid shape): 108.07,77.99 108.07,76.79 107.83,76.55 104.51,76.55 103.8,77.26 103.8,78.25 104.04,78.49 107.57,78.49
+VCC_CORE on TOP (solid shape): outline of 5123 points within 98.24,78.67 124.81,112.99
+VCC_CORE on BOTTOM (solid shape): outline of 119 points within 97.63,96.57 118.91,112.45
+VCC_CORE on BOTTOM (solid shape): outline of 1760 points within 103.16,75.38 126.1,88.41
+VCC_CORE on IN2 (solid shape): outline of 6038 points within 98.16,76.22 124.15,112.8
+VCC_CORE on IN4 (solid shape): outline of 4560 points within 98.53,77.18 124.53,112.49
+VCC_CORE on VCC: 102.47,75.56 101.67,76.36 101.67,88.81 98.81,91.66 98.81,103.71 99.42,104.32 101.26,104.32 103.04,106.1 108.63,106.1 111.55,109.02 113.69,109.02 113.82,108.89 122.13,108.89 124.15,106.88 124.15,76.13 103.85,76.13 103.28,75.56
+VCC_PWR_SRC on TOP (solid shape): 95.39,107.83 95.39,106.62 95.32,106.54 92.35,106.54 92.25,106.64 92.25,107.86 92.46,108.07 95.16,108.07
+VCC_PWR_SRC on BOTTOM (solid shape): 92.42,110.42 92.42,109.84 92.76,109.49 92.76,109.17 93.08,108.86 94,108.86 94.17,109.03 94.17,110.54 94.27,110.64 96.16,110.64 96.17,110.63 96.17,106.7 96.07,106.59 92.62,106.59 92.28,106.25 92.28,105.73 92.09,105.54 84.49,105.54 83.53,104.58 82.36,104.58 82.34,104.57 82.16,104.46 82.05,104.28 82.05,104.27 81.5,103.71 81.5,102.48 81.3,102.28 80.23,102.28 80.23,102.28 80.23,102.73 80.23,102.82 79.48,102.82 79.48,102.28 79.03,102.28 79.03,102.82 78.3,102.82 78.3,102.28 77.16,102.28 77.03,102.42 77.03,105.4 78.87,107.25 82.74,107.25 83.56,108.06 83.56,109.88 84.54,110.86 91.97,110.86
+VDDA_AVDD1 on TOP (solid shape): 211.1,68.44 211.11,68.44 211.17,68.39 214.06,68.39 214.2,68.25 214.2,67.83 214.11,67.75 211.67,67.75 211.58,67.75 210.91,68.42 210.85,68.42 210.06,69.2 210.05,69.2 209.98,69.27 209.15,69.27 209.08,69.33 209.08,69.43 209.13,69.49 210.06,69.49
+VDDA_PVDD on TOP (solid shape): 215.05,76 215.05,75.39 214.9,75.24 212.22,75.24 212.14,75.32 212.14,75.93 212.19,75.97 212.99,75.97 213.13,76.11 214.94,76.11
GND on TOP (solid shape): 198.25,26.85 198.25,25.96 197.87,25.58 197.11,25.58 197.11,27.04 198.06,27.04
GND on TOP (solid shape): 95.52,13.76 95.52,12.58 95.39,12.45 94.66,12.45 94.5,12.6 94.5,13.71 94.64,13.85 95.43,13.85
GND on TOP (solid shape): 121.43,37.78 121.43,33.44 121.01,33.03 116.62,33.03 116.11,33.54 116.11,37.29 116.89,38.07 121.14,38.07
GND on TOP (solid shape): 192.41,53.23 192.41,52.58 191.87,52.05 189.28,52.05 189.12,52.21 189.12,52.81 189.79,53.48 192.15,53.48
GND on TOP (solid shape): 236.25,5.85 236.25,5.82 235.74,5.82 235.74,5.85 235.74,8.85 236.25,8.85
GND on TOP (solid shape): 42.58,46.1 42.58,44.96 42.3,44.68 41.23,44.68 41.12,44.8 41.12,45.98 41.3,46.17 42.52,46.17
GND on TOP (solid shape): 122.62,31.68 122.62,30.41 123.13,29.9 123.13,29.01 122.05,29.01 121.92,29.14 121.92,31.61 122.05,31.74 122.56,31.74
GND on TOP (solid shape): 198.19,29.58 197.36,28.76 196.22,28.76 196.22,29.39 196.73,29.39 196.98,29.65 196.98,32.31 197.11,32.44 198.19,32.44
GND on TOP (solid shape): 44.59,23.61 44.59,23.26 43.98,22.65 42.76,22.65 42.64,22.77 42.64,23.61 42.7,23.68 44.53,23.68
GND on TOP (solid shape): 155.45,4.56 155.45,1.84 155.09,1.48 149.18,1.48 148.93,1.73 148.93,4.76 149.05,4.88 155.13,4.88
GND on TOP (solid shape): 93.58,20.35 93.58,19.21 95.28,17.5 95.28,16.59 95.19,16.5 90.02,16.5 89.88,16.64 89.88,20.32 90.1,20.54 93.39,20.54
GND on TOP (solid shape): 119.89,25.71 119.89,23.04 119.7,22.85 119.07,22.85 119.07,25.01 117.86,26.22 117.86,26.47 117.99,26.6 119,26.6
GND on TOP (solid shape): 193.99,65.19 193.99,64.23 193.66,63.91 191.72,63.91 191.63,64 191.63,64.8 191.7,64.86 192.37,64.86 192.98,65.47 193.7,65.47
GND on TOP (solid shape): 221.71,77.26 221.71,77 221.71,77 221.71,76.42 221.49,76.2 219.99,76.2 219.89,76.3 219.89,77.24 219.98,77.34 221.63,77.34
GND on TOP (solid shape): 34.25,44.48 34.25,43.08 33.66,43.08 33.35,43.39 33.35,43.73 33.2,43.88 32.98,43.88 32.84,44.02 32.84,44.35 33.13,44.63 34.1,44.63
GND on TOP (solid shape): 193.6,71.86 193.6,69.49 193.16,69.04 192.6,69.04 192,69.64 187.37,69.64 187.18,69.83 187.18,70.96 187.37,71.15 188.78,71.15 189.7,72.08 193.39,72.08
GND on TOP (solid shape): 47.14,21.48 47.14,20.35 47.1,20.32 45.05,20.32 45,20.37 45,20.9 45.04,20.93 45.54,20.93 45.6,20.98 45.6,21.44 45.71,21.56 45.71,21.56 47.06,21.56
GND on TOP (solid shape): 209.16,109.27 209.16,108.83 209.39,108.6 209.39,108.04 209.36,108.02 208.83,108.02 208.7,108.14 206.68,108.14 206.49,108.33 206.49,108.65 206.66,108.82 206.66,109.45 206.67,109.46 208.97,109.46
GND on TOP (solid shape): 101.03,37.52 101.03,36.02 103.16,33.89 103.16,33.05 102.9,32.78 99.08,32.78 97.25,34.61 97.25,37.96 97.35,38.06 100.49,38.06
GND on TOP (solid shape): 157.43,108.58 157.43,105.48 156.96,105.02 155.81,105.02 155.51,105.31 155.51,106.73 155.3,106.95 155.3,107.82 155.44,107.97 156.15,107.97 156.83,108.65 157.36,108.65
GND on TOP (solid shape): 47.97,40.9 47.97,39.07 48.11,38.93 48.52,38.93 48.71,38.74 48.71,38.28 48.62,38.19 47.31,38.19 46.99,38.51 46.93,38.6 46.84,38.66 46.75,38.75 46.75,40.97 46.78,41 47.87,41
GND on TOP (solid shape): 100.85,111.54 100.85,106.58 100.69,106.42 97.73,106.42 95.82,104.51 92.38,104.51 92.19,104.7 92.19,106.21 92.4,106.42 95.44,106.42 95.7,106.67 95.7,111.43 95.94,111.68 100.71,111.68
GND on TOP (solid shape): 214.49,63.21 215.88,63.21 215.93,63.16 215.93,62.03 215.79,61.89 213.55,61.89 213.38,62.07 213.38,63.15 213.45,63.22 214.48,63.22
GND on TOP (solid shape): 90.55,102.77 90.55,97.59 90.43,97.46 89.98,97.46 89.7,97.75 87.47,97.75 87.19,98.03 87.19,98.99 86.36,99.81 85.98,99.81 85.92,99.88 85.92,100.71 85.98,100.78 86.65,100.78 86.95,101.07 86.95,101.46 87.2,101.72 88.75,101.72 89.2,102.16 89.2,102.73 89.35,102.89 90.44,102.89
GND on TOP (solid shape): 25.69,55.08 25.69,53.28 25.54,53.12 20.25,53.12 19.84,53.02 19.54,52.72 17.22,52.72 17.13,52.81 17.13,53.88 17.21,53.95 18.21,53.95 18.57,54.31 18.57,60.56 18.74,60.72 20.06,60.72
GND on TOP (solid shape): 38.05,60.51 38.05,54.79 37.79,54.53 37.79,54.51 37.64,54.36 37.64,49.79 37.41,49.57 34.48,49.57 34.29,49.75 34.29,55.79 33.61,56.48 30.51,56.48 29.74,55.72 29.74,55.13 29.74,55.13 29.74,54.96 29.65,54.86 28.74,54.86 28.67,54.93 28.67,56.44 29.35,57.13 29.35,60.54 29.97,61.17 37.39,61.17
GND on TOP (solid shape): 74.73,104.11 74.73,102.68 74.49,102.45 71.33,102.45 71.01,102.9 70.63,102.49 70.47,102.34 70.47,102.24 70.4,102.16 67.69,102.16 67.5,102.35 67.5,103.94 68.01,104.45 74.39,104.45
GND on TOP (solid shape): 44.86,21.02 44.86,20.15 44.87,20.13 47.32,20.13 47.5,20.31 48.45,20.31 48.58,20.18 48.58,18.71 48.45,18.58 47.67,18.58 47.58,18.67 46.61,18.67 46.51,18.57 46.51,17.29 46.89,16.91 47.3,16.91 47.53,17.14 48.33,17.14 48.36,17.1 48.36,15.76 48.31,15.71 46.52,15.71 46.05,16.17 43.06,16.17 42.79,16.44 41.11,16.44 41.01,16.54 41.01,17.1 41.79,17.87 41.79,18.61 43.02,19.84 43.02,21.19 43.17,21.34 44.54,21.34
GND on TOP (solid shape): 178.94,3.64 178.73,3.32 178.65,2.94 178.65,0.5 178.5,0.15 178.15,0 173.25,0 173.25,3.25 173.43,3.82 173.91,4.19 175.75,4.85 180.15,4.85
GND on TOP (solid shape): 147.84,114.96 147.84,114.29 148.46,113.67 148.89,113.67 149.04,113.52 149.04,113.06 148.96,112.98 147.15,112.98 147.14,112.99 147.12,113.03 147.14,113.07 146.92,113.71 146.69,113.07 146.71,113.03 146.69,112.99 146.68,112.98 146.13,112.98 145.72,113.39 145.72,114.27 146.23,114.77 146.24,114.78 146.42,114.92 146.48,115.14 146.48,115.16 146.62,115.31 147.5,115.31
GND on TOP (solid shape): 218.66,69.23 218.66,67.63 218.77,67.52 218.77,67.36 218.92,67.06 219.26,67 219.28,67 219.42,66.87 219.52,66.67 219.72,66.57 219.98,66.31 219.98,65.46 219.97,65.46 219.74,65.23 219.56,65.23 219.01,64.68 219.01,64.51 218.51,64 218.51,63.74 218.42,63.51 218.49,63.28 218.51,63.27 218.51,63.16 218.46,63.09 218.38,63.01 218.38,62.39 218.25,62.26 217.46,62.26 217.29,62.44 217.29,63.76 217.55,64.02 217.99,64.02 217.99,64.26 218.11,64.39 218.11,67 218.04,67.08 218.04,67.1 218.02,67.22 217.96,67.33 217.96,69.13 218.15,69.32 218.57,69.32
GND on TOP (solid shape): 129.4,140.6 129.57,140.52 129.65,140.35 129.65,139.85 130.01,138.96 130.9,138.6 136.1,138.6 136.99,138.96 137.35,139.85 137.35,140.35 137.43,140.52 137.6,140.6 138.86,140.6 138.86,135.98 136.26,135.98 136.02,135.75 130.35,135.75 129.53,134.93 126.4,134.93 125.94,134.47 124.42,134.47 124.15,134.73 124.15,139.85 124.37,140.38 124.9,140.6
GND on TOP (solid shape): 266.6,139.23 268.01,137.85 269.4,139.25 269.4,140.25 270.23,140.25 270.37,140.23 270.5,140.19 270.5,139.32 268.03,136.75 265.5,139.26 265.5,141.25 266.6,141.25
GND on TOP (solid shape): 183.4,140.6 183.57,140.52 183.65,140.35 183.65,139.85 184.01,138.96 184.9,138.6 190.1,138.6 190.99,138.96 191.35,139.85 191.35,140.35 191.43,140.52 191.6,140.6 196.1,140.6 196.63,140.38 196.85,139.85 196.85,132.9 197.28,130.37 198.52,128.12 182.48,128.12 182.48,129.62 184.88,129.62 184.88,136.08 182.48,136.08 182.48,140.6
GND on TOP (solid shape): 243.4,138.6 243.57,138.52 243.65,138.35 243.65,138.02 243.73,137.73 243.95,137.53 243.95,136.42 244.05,136.06 244.35,135.82 244.35,134.74 244.35,133.39 244.35,133.31 243.76,132.72 243.76,132.37 243.75,132.24 243.76,132.11 243.76,131.02 244.2,130.58 244.2,128.76 243.91,128.46 243.34,128.46 242.8,129.01 242.8,132.8 242.62,132.98 239.92,132.98 239.43,133.47 238.23,133.47 237.76,132.99 237.76,127.51 237.49,127.24 236.38,127.24 235.72,127.91 234.15,127.91 234.07,127.98 234.07,128.8 235.93,128.8 236.67,129.42 236.18,130.26 236.18,137.85 236.4,138.38 236.93,138.6 243.03,138.6
GND on TOP (solid shape): 82.12,140 82.29,139.92 82.37,139.75 82.37,136.73 82.37,136.73 82.37,134.51 81.88,133.67 82.62,133.05 85.07,133.05 85.07,132.65 85.08,132.65 85.08,131.78 84.84,131.54 84.84,131.16 83.35,129.67 83.35,129.31 80.32,126.28 71.76,126.28 71.16,126.87 71.16,128 71.16,128 71.16,128.8 72.9,128.8 73.64,129.42 73.15,130.26 73.15,137.25 73.37,137.78 73.9,138 74.03,138 79,138 79.66,138.18 80.12,138.69 80.57,139.58 80.85,139.88 81.24,140
GND on TOP (solid shape): 232.25,34.35 232.09,33.96 231.7,33.8 230.62,33.8 230.6,33.8 227.9,33.8 227.01,33.44 226.65,32.55 226.65,26.05 227.01,25.16 227.9,24.8 230.9,24.8 231.43,24.58 231.65,24.05 231.65,12.36 231.74,11.88 232.01,11.48 232.71,10.78 232.71,10.43 232.34,10.43 231.65,11.12 231.27,11.69 231.14,12.36 231.14,24.05 231.07,24.22 230.9,24.29 227.9,24.29 226.65,24.8 226.14,26.05 226.14,32.55 226.65,33.8 227.9,34.31 230.6,34.31 230.98,34.47 231.14,34.85 231.14,35.74 232.25,35.74
GND on TOP (solid shape): outline of 261 points within 121.52,58.52 123.17,67.05
GND on TOP (solid shape): 266.35,139.25 268,137.6 269.65,139.25 269.65,140 270.18,140 270.57,139.88 270.85,139.58 270.86,139.56 271.43,138.41 271.71,138.11 272.11,138 272.3,138 272.47,137.92 272.55,137.75 272.55,135.45 272.91,134.56 273.8,134.2 282.4,134.2 283.29,134.56 283.65,135.45 283.65,139.25 283.87,139.78 284.4,140 285.43,140 285.6,139.92 285.68,139.75 285.68,131.78 285.3,131.4 285.3,128.22 285.07,128 280.11,128 275.74,132.37 274.37,132.37 274.28,132.42 274.28,132.53 273.98,133.08 273.69,132.53 273.69,132.42 273.6,132.37 273.1,132.37 273.01,132.42 273.01,132.53 272.71,133.08 272.42,132.53 272.42,132.42 272.33,132.37 271.79,132.37 271.12,133.03 269.67,133.03 269.59,133.06 269.56,133.14 269.37,133.47 268.98,133.42 268.92,133.4 268.85,133.42 268.47,133.47 268.27,133.14 268.24,133.06 268.17,133.03 252.82,133.03 252.73,133.07 252.72,133.16 252.75,133.28 252.75,133.39 252.75,134.79 252.75,135.82 253.05,136.06 253.15,136.42 253.15,137.47 253.51,137.65 253.65,138.02 253.65,138.35 253.73,138.52 253.9,138.6 254.7,138.6 259.6,138.6 259.6,140.75 259.68,140.92 259.85,141 266.35,141
GND on TOP (solid shape): outline of 86 points within 231.14,39.48 262.98,120.71
GND on TOP (solid shape): outline of 109 points within 0.25,0.25 228.15,14.24
GND on TOP (solid shape): outline of 776 points within 0.25,16.3 68.66,138.6
GND on TOP (solid shape): outline of 904 points within 56.87,22.18 71.75,34.9
GND on TOP (solid shape): outline of 1253 points within 156.58,24.03 174.95,33.23
GND on TOP (solid shape): outline of 1333 points within 176.62,21.82 193.77,35.02
GND on TOP (solid shape): outline of 1382 points within 95.84,124.76 224.02,140.6
GND on TOP (solid shape): outline of 1466 points within 80.29,23.78 98.03,32.24
GND on BOTTOM (solid shape): 10.58,42.38 10.58,41.1 10.48,41.01 8,41.01 7.93,41.08 7.93,42.5 7.99,42.56 10.39,42.56
GND on BOTTOM (solid shape): 11.44,14.32 11.44,12.71 11.32,12.59 9.39,12.59 9.16,12.82 9.16,14.27 9.27,14.39 11.38,14.39
GND on BOTTOM (solid shape): 42.71,46.69 42.71,45.44 42.59,45.32 41.11,45.32 41.01,45.42 41.01,46.76 41.14,46.89 42.51,46.89
GND on BOTTOM (solid shape): 47.61,25.48 47.61,24.39 47.37,24.15 46.14,24.15 45.96,24.32 45.96,25.58 46.07,25.68 47.41,25.68
GND on BOTTOM (solid shape): 61.13,21.28 61.13,18.69 60.71,18.27 58.36,18.27 57.84,18.79 57.84,21.19 58.32,21.67 60.73,21.67
GND on BOTTOM (solid shape): 78.59,15.74 78.59,13.99 78.47,13.87 78.16,13.87 78.04,13.99 78.04,15.9 78.09,15.95 78.37,15.95
GND on BOTTOM (solid shape): 81.6,13.68 81.6,12.47 81.38,12.26 80.08,12.26 79.99,12.35 79.99,13.69 80.13,13.83 81.45,13.83
GND on BOTTOM (solid shape): 100.78,105.15 100.78,97.1 100.41,96.73 99.56,96.73 99.25,97.03 99.25,105.08 99.44,105.27 100.65,105.27
GND on BOTTOM (solid shape): 78.25,20.21 78.25,19.41 77.84,19 77.84,18.22 77.79,18.16 77.69,18.16 77.65,18.2 77.65,20.2 77.76,20.31 78.15,20.31
GND on BOTTOM (solid shape): 104.08,105.08 104.08,97.04 103.79,96.75 102.82,96.75 102.56,97.02 102.56,105.08 102.75,105.27 103.89,105.27
GND on BOTTOM (solid shape): 113.92,100.97 113.92,96.76 113.79,96.64 112.84,96.64 112.52,96.96 112.52,100.99 112.64,101.11 113.79,101.11
GND on BOTTOM (solid shape): 261.81,123.7 261.81,121.69 261.53,121.41 260.01,121.41 259.93,121.48 259.93,123.85 260.07,123.99 261.52,123.99
GND on BOTTOM (solid shape): 85.79,13.69 85.79,12.6 85.65,12.46 84.7,12.46 84.51,12.65 84.51,13.9 84.67,14.06 85.42,14.06
GND on BOTTOM (solid shape): 120.3,16.37 120.3,14.04 119.92,13.66 116.31,13.66 116.06,13.91 116.06,16.57 116.28,16.79 119.88,16.79
GND on BOTTOM (solid shape): 203.14,15.57 203.14,14.71 203.08,14.65 201.83,14.65 201.78,14.7 201.78,15.51 201.63,15.66 201.63,16.46 201.68,16.51 202.2,16.51
GND on BOTTOM (solid shape): 30.94,17.07 30.94,15.02 30.81,14.9 29.36,14.9 29.2,15.05 29.2,17 29.4,17.21 30.8,17.21
GND on BOTTOM (solid shape): 42.01,29.27 42.01,28.04 41.9,27.93 41.85,27.89 41.81,27.84 41.67,27.7 39.17,27.7 38.69,28.18 38.69,30.89 38.81,31.01 40.27,31.01
GND on BOTTOM (solid shape): 107.38,105.08 107.38,96.83 107.19,96.64 106.11,96.64 105.92,96.83 105.92,105.15 106.05,105.27 107.19,105.27
GND on BOTTOM (solid shape): 117.29,105.24 117.29,98.86 117.16,98.73 115.95,98.73 115.76,98.92 115.76,102.63 115.86,102.72 115.86,103.15 115.76,103.25 115.76,105.2 115.92,105.35 117.17,105.35
GND on BOTTOM (solid shape): 130.01,102.11 130.01,100.53 129.97,100.48 128.45,100.48 128.4,100.49 128.35,100.48 128.31,100.48 128.23,100.57 128.23,102.21 128.34,102.32 129.8,102.32
GND on BOTTOM (solid shape): 110.65,105.11 110.65,98.51 110.62,98.48 110.62,96.96 110.3,96.64 109.48,96.64 109.22,96.89 109.22,105.15 109.35,105.27 110.49,105.27
GND on BOTTOM (solid shape): 129.83,123.47 129.83,123.3 129.79,123.26 129.72,123.17 128.78,123.17 128.12,123.83 128.12,124.06 128.2,124.13 129.17,124.13
GND on BOTTOM (solid shape): 162.2,63.72 162.2,60.97 161.99,60.77 158.46,60.77 158.46,60.77 157.87,60.77 157.61,61.04 157.61,62.98 157.83,63.2 158.85,63.2 159.48,63.83 162.09,63.83
GND on BOTTOM (solid shape): 184.04,60.71 184.04,58.46 183.78,58.2 176.58,58.2 176.11,58.66 176.11,60.75 176.38,61.01 183.73,61.01
GND on BOTTOM (solid shape): 23,14.32 23.03,14.32 23.07,14.32 23.45,14.32 23.68,14.09 23.68,12.04 23.6,11.95 22.38,11.95 22.25,12.08 22.25,12.59 21.91,12.93 21.91,14.22 22.01,14.32
GND on BOTTOM (solid shape): 74.04,125.07 74.04,122.42 73.6,121.97 72.19,121.97 71.63,122.53 71.63,125.1 71.8,125.26 73.85,125.26
GND on BOTTOM (solid shape): 120.59,108.64 120.59,105.02 121.61,103.99 121.61,100.93 121.03,100.35 120.79,100.35 120.4,99.96 120.4,99.05 120.21,98.86 119.26,98.86 119.13,98.99 119.13,109.53 119.32,109.72 119.51,109.72
GND on BOTTOM (solid shape): 24.13,43.11 24.13,41.07 24.06,41 22.06,41 22,41.06 22,42.03 22.03,42.15 22,42.28 22,42.98 22.3,43.28 23.96,43.28
GND on BOTTOM (solid shape): 213.16,59.85 214.12,59.85 214.21,59.76 216.03,59.76 216.17,59.62 216.17,59.35 215.99,59.17 210.7,59.17 210.51,59.36 210.51,59.81 210.51,59.81 210.51,60.35 210.72,60.57 212.44,60.57
GND on BOTTOM (solid shape): 240.82,121.8 240.82,120.6 240.52,120.3 240.52,118.42 240.29,118.19 238.99,118.19 238.9,118.28 238.9,118.68 239.12,118.9 239.12,120.02 239.03,120.11 239.03,121.67 239.23,121.87 240.74,121.87
GND on BOTTOM (solid shape): 78.21,17.85 78.21,16.26 78.16,16.21 77.54,16.21 77.45,16.12 77.45,15.12 77.4,15.07 77.35,15.07 77.26,15.15 77.26,16.13 77.19,16.2 76.56,16.2 76.48,16.27 76.48,17.87 76.52,17.91 78.15,17.91
GND on BOTTOM (solid shape): 131.25,131.59 131.25,130.97 131.57,130.65 131.57,129.64 130.88,128.95 128.78,128.95 128.31,129.42 127.17,129.42 127.02,129.57 127.02,130.28 127.65,130.91 127.65,131.64 127.92,131.91 130.94,131.91
GND on BOTTOM (solid shape): 196.73,77.75 196.73,76.25 196.6,76.13 196.18,76.13 196,75.95 196,75.19 195.67,74.86 194.69,74.86 194.46,75.09 194.46,76.76 194.71,77 195.62,77 195.76,77.14 195.76,77.78 195.86,77.88 196.6,77.88
GND on BOTTOM (solid shape): 34.89,43.67 35.74,43.67 35.83,43.58 36.58,43.58 36.62,43.54 36.62,42.78 36.49,42.65 36.34,42.65 36.16,42.83 35.57,42.83 35.18,43.22 32.93,43.22 32.83,43.32 32.83,44.29 33.15,44.61 33.95,44.61
GND on BOTTOM (solid shape): 37.69,60.93 37.69,54.79 37.04,54.15 37.04,52.6 36.79,52.35 34.21,52.35 34.2,52.36 33.71,52.36 33.4,52.66 33.4,60.46 34.19,61.26 37.37,61.26
GND on BOTTOM (solid shape): 91.67,114.26 91.67,111.92 91.64,111.89 90.27,111.89 90.23,111.89 89.77,111.43 87.98,111.43 87.95,111.41 87.34,111.41 87.19,111.26 86.39,111.26 86.11,111.53 86.11,113.55 86.91,114.35 91.57,114.35
GND on BOTTOM (solid shape): 94.96,126.92 95.93,126.92 96.28,127.27 96.51,127.27 96.97,126.82 97.62,126.82 97.79,126.64 97.79,125.43 97.53,125.16 94.56,125.16 93.6,126.12 93.6,126.38 93.99,126.78 93.99,127.23 94.04,127.28 94.61,127.28
GND on BOTTOM (solid shape): 87.44,101.47 90.14,101.47 90.18,101.42 90.18,98.71 90.13,98.66 87.41,98.66 87.35,98.72 87.35,100.16 87.34,100.17 86.35,100.17 86.29,100.23 86.29,100.32 86.33,100.36 87.36,100.36 87.36,101.44 87.38,101.47 87.44,101.47
GND on BOTTOM (solid shape): 193.92,70.84 193.92,69.82 193.8,69.7 190.36,69.7 190.29,69.62 190.29,67.1 190.25,67.06 188.31,67.06 188.25,67.11 188.25,67.29 188.31,67.34 189.54,67.34 189.63,67.43 189.63,68.86 189.52,68.96 188.37,68.96 188.14,69.19 188.14,71.15 188.32,71.33 193.44,71.33
GND on BOTTOM (solid shape): 47.44,21.11 47.44,18.98 47.31,18.85 47.04,18.85 46.97,18.93 46.65,18.93 46.4,18.67 46.4,16.75 46.04,16.4 44.63,16.4 44.36,16.13 43.47,16.13 42.94,16.67 42.94,19.14 43.94,20.15 46.31,20.15 46.59,20.42 46.59,21.1 46.71,21.23 47.32,21.23
GND on BOTTOM (solid shape): 98.68,112.44 98.68,111.1 98.76,111.03 99.79,111.03 99.85,110.96 99.85,110.86 99.8,110.81 98.75,110.81 98.68,110.75 98.68,108.02 98.54,107.88 98.54,107.47 95.9,104.83 92.73,104.83 92.62,104.93 92.62,106.23 92.75,106.35 93.46,106.35 93.47,106.35 96.39,106.35 96.45,106.4 96.45,112.4 96.64,112.59 98.53,112.59
GND on BOTTOM (solid shape): 72.84,104.07 73.54,104.07 73.55,104.08 73.55,104.59 74.04,104.59 74.04,104.07 74.04,104.07 74.74,104.07 74.74,104.07 74.74,104.59 75.8,104.59 76.14,104.26 76.14,99.16 75.81,98.83 73.74,98.83 73.49,99.08 73.49,100.17 72.2,101.46 72.2,101.97 71.45,102.72 71.45,103.47 71.46,103.48 71.46,103.77 72.29,104.59 72.84,104.59
GND on BOTTOM (solid shape): 178.94,3.64 178.73,3.32 178.65,2.94 178.65,0.5 178.5,0.15 178.15,0 173.25,0 173.25,3.25 173.43,3.82 173.91,4.19 175.75,4.85 180.15,4.85
GND on BOTTOM (solid shape): 100.7,74.39 100.81,74.39 100.88,74.36 100.91,74.29 100.91,74.23 100.71,74.23 100.55,74.16 100.48,74.16 100.32,74.23 99.94,74.23 99.69,73.98 99.6,73.98 99.37,73.75 98.95,73.75 98.85,73.81 98.88,73.92 99.21,74.25 99.66,74.25 99.79,74.39 100.32,74.39 100.48,74.46 100.55,74.46
GND on BOTTOM (solid shape): 100.7,71.96 100.81,71.96 100.88,71.93 100.91,71.86 100.91,71.8 100.71,71.8 100.55,71.73 100.48,71.73 100.32,71.8 99.73,71.8 99.07,71.15 98.9,71.15 98.82,71.18 98.8,71.26 98.78,71.43 98.67,71.56 98.65,71.58 98.65,71.68 99.3,71.68 99.58,71.96 100.32,71.96 100.48,72.03 100.55,72.03
GND on BOTTOM (solid shape): 264.8,138.53 264.14,137.24 262.8,136.7 262.18,136.7 260.85,137.25 260.2,138.53 260.2,141.25 264.8,141.25
GND on BOTTOM (solid shape): 120.74,68.36 120.78,68.34 120.8,68.31 120.8,68.15 120.87,67.99 120.87,67.93 120.8,67.77 120.8,67.24 120.9,67.14 120.9,66.85 120.78,66.73 120.78,66 120.59,66 120.5,66.01 120.41,66 120.26,66 120.26,66.4 120.4,66.53 120.4,67.15 120.64,67.39 120.64,67.77 120.57,67.93 120.57,68 120.64,68.15 120.64,68.26 120.67,68.33 120.73,68.36
GND on BOTTOM (solid shape): 125.87,68.36 125.91,68.34 125.93,68.31 125.93,68.15 126,67.99 126,67.93 125.93,67.77 125.93,67.39 126.16,67.15 126.16,66.06 126.15,66.02 126.11,66.01 126.07,66.01 126.02,66 125.94,66 125.94,66.63 125.66,66.91 125.66,67.27 125.77,67.39 125.77,67.77 125.7,67.93 125.7,68 125.77,68.15 125.77,68.26 125.8,68.33 125.87,68.36
GND on BOTTOM (solid shape): 78.8,26.77 78.86,26.68 78.86,25.84 78.8,25.75 78.69,25.76 78.27,25.81 78.1,25.43 78.11,25.4 77.75,25.05 77.68,25.01 77.62,24.97 77.55,24.93 77.48,24.97 77.45,24.99 77.43,25.01 77.43,25.75 78.36,26.68 78.38,26.67 78.55,26.68 78.69,26.76
GND on BOTTOM (solid shape): 134.66,99.81 134.79,99.68 134.9,99.61 135.04,99.57 135.1,99.54 135.13,99.47 135.13,98.73 134.88,98.48 132.84,98.48 132.65,98.29 132.65,97.4 132.97,97.08 133.23,97.08 133.29,97.02 133.29,96.25 133.66,95.88 133.66,95.23 133.55,95.11 132.59,95.11 131.64,96.07 131.64,97.96 131.64,97.97 131.66,98.1 131.64,98.22 131.64,98.23 131.64,98.94 131.75,99.05 131.95,99.05 132.4,99.1 132.44,99.55 132.43,99.56 132.43,99.65 132.45,99.66 132.5,99.72 132.54,99.78 132.56,99.81 133.17,99.81
GND on BOTTOM (solid shape): 137.63,71.21 137.81,71.21 137.89,71.17 137.91,71.09 138.08,70.82 138.38,70.91 138.44,70.91 138.49,70.88 138.48,70.83 138.21,70.56 138.19,70.56 137.96,70.46 137.93,70.22 137.93,70.21 137.93,70.15 137.83,70.15 137.77,70.22 137.77,70.24 137.73,70.4 137.6,70.51 137.54,70.55 137.53,70.62 137.46,70.89 137.22,71.01 137.15,71.04 137.12,71.11 137.12,71.14 137.23,71.26 137.58,71.26
GND on BOTTOM (solid shape): 137.19,77.24 137.58,77.24 137.62,77.2 137.81,77.2 137.89,77.17 137.91,77.09 138.08,76.81 138.38,76.91 138.46,76.91 138.5,76.89 138.51,76.84 138.22,76.55 138.2,76.55 137.97,76.46 137.93,76.22 137.93,76.21 137.93,76.15 137.83,76.15 137.77,76.21 137.77,76.23 137.72,76.41 137.57,76.51 137.51,76.55 137.49,76.62 137.43,76.87 137.21,77 137.15,77.03 137.12,77.1 137.11,77.15 137.1,77.19 137.08,77.22 137.15,77.28
GND on BOTTOM (solid shape): 137.95,22.94 138.03,22.9 138.1,22.85 138.18,22.81 138.2,22.81 138.51,22.5 138.5,22.47 138.68,22.09 139.1,22.15 139.21,22.17 139.27,22.08 139.27,22.01 140.31,20.98 140.3,20.95 140.3,20.81 140.36,20.67 140.37,20.57 140.28,20.51 139.22,20.51 139.13,20.57 139.14,20.67 139.15,21.07 138.78,21.23 138.76,21.23 137.83,22.16 137.83,22.86 137.85,22.88 137.88,22.9
GND on BOTTOM (solid shape): 129.4,140.6 129.57,140.52 129.65,140.35 129.65,139.85 130.01,138.96 130.9,138.6 136.1,138.6 136.99,138.96 137.35,139.85 137.35,140.35 137.43,140.52 137.6,140.6 138.86,140.6 138.86,135.98 136.26,135.98 136.02,135.75 130.35,135.75 129.53,134.93 126.4,134.93 125.94,134.47 124.42,134.47 124.15,134.73 124.15,139.85 124.37,140.38 124.9,140.6
GND on BOTTOM (solid shape): 137.62,74.2 137.81,74.2 137.89,74.17 137.91,74.09 138.08,73.81 138.38,73.91 138.46,73.91 138.54,73.94 138.63,73.8 138.55,73.74 138.32,73.51 138.29,73.53 138,73.5 137.93,73.22 137.93,73.21 137.93,73.15 137.83,73.15 137.77,73.21 137.77,73.24 137.72,73.41 137.57,73.51 137.51,73.55 137.49,73.63 137.43,73.88 137.21,74 137.15,74.04 137.12,74.1 137.12,74.14 137.22,74.24 137.58,74.24
GND on BOTTOM (solid shape): 262.98,120.2 246.03,120.2 245.4,120.11 244.82,119.85 241.26,117.59 240.52,117.12 240.33,117.03 240.12,117 235.7,117 234.81,116.64 234.45,115.75 234.45,114.94 234.44,114.82 234.41,114.71 233.77,114.71 233.89,114.8 233.94,114.94 233.94,115.75 234.45,117 235.7,117.51 240.12,117.51 240.19,117.52 240.25,117.55 241.1,118.09 244.54,120.28 245.25,120.6 246.03,120.71 262.98,120.71
GND on BOTTOM (solid shape): 266.6,139.23 268.01,137.85 269.4,139.25 269.4,140.25 270.23,140.25 270.37,140.23 270.5,140.19 270.5,139.32 268.03,136.75 265.5,139.26 265.5,141.25 266.6,141.25
GND on BOTTOM (solid shape): 183.4,140.6 183.57,140.52 183.65,140.35 183.65,139.85 184.01,138.96 184.9,138.6 190.1,138.6 190.99,138.96 191.35,139.85 191.35,140.35 191.43,140.52 191.6,140.6 196.1,140.6 196.63,140.38 196.85,139.85 196.85,132.9 197.28,130.37 198.52,128.12 182.48,128.12 182.48,129.62 184.88,129.62 184.88,136.08 182.48,136.08 182.48,140.6
GND on BOTTOM (solid shape): outline of 103 points within 106.13,61.27 119.16,64.56
GND on BOTTOM (solid shape): 125.61,119.02 125.85,118.83 126.15,118.9 127.49,117.56 128.65,117.56 128.97,117.36 129.29,117.56 131.44,117.56 132.31,116.69 133.35,116.69 133.39,116.62 133.36,116.55 133.35,116.53 133.39,116.06 133.87,116.05 133.93,116.07 133.99,116.05 134.47,116.06 134.51,116.53 134.5,116.55 134.47,116.62 134.51,116.69 136.48,116.69 136.51,116.72 136.62,116.72 137.25,117.35 137.4,117.35 137.47,117.42 137.51,117.42 137.54,117.46 137.57,117.45 137.71,117.47 137.84,117.54 137.9,117.6 137.94,117.68 137.95,117.71 140.57,117.71 141.27,117.01 141.27,114.91 139.12,112.76 138.81,112.76 138.8,112.77 133.29,112.77 129.97,116.08 125.97,116.08 125.05,115.16 123.28,115.16 123.03,115.42 123.03,118.65 123.4,119.02
GND on BOTTOM (solid shape): 137.25,80.84 137.33,80.58 137.54,80.5 137.57,80.51 137.71,80.36 137.88,80.36 137.97,80.31 137.96,80.2 138.1,79.8 138.42,80.08 138.42,80.1 138.53,80.21 138.58,80.15 138.57,80.12 138.56,80.04 138.58,79.95 138.59,79.92 138.22,79.55 138.19,79.55 137.97,79.46 137.93,79.21 137.93,79.2 137.93,79.15 137.83,79.15 137.77,79.21 137.77,79.23 137.72,79.41 137.52,79.55 137.5,79.61 137.42,79.85 137.21,79.97 137.14,80 137.12,80.07 136.81,80.33 136.64,79.96 136.63,79.9 136.57,79.9 136.53,79.92 136.49,79.94 136.44,79.99 136.43,80.06 136.44,80.12 136.43,80.17 136.44,80.24 136.49,80.29 136.59,80.36 136.66,80.46 136.71,80.51 136.79,80.52 137.03,80.56 137.12,80.79 137.13,80.84 137.17,80.85 137.21,80.85
GND on BOTTOM (solid shape): outline of 199 points within 7.2,5.45 16,10.45
GND on BOTTOM (solid shape): outline of 213 points within 234.07,127.24 244.35,138.6
GND on BOTTOM (solid shape): 266.35,139.25 268,137.6 269.65,139.25 269.65,140 270.18,140 270.57,139.88 270.85,139.58 270.86,139.56 271.43,138.41 271.71,138.11 272.11,138 272.3,138 272.47,137.92 272.55,137.75 272.55,135.45 272.91,134.56 273.8,134.2 282.4,134.2 283.29,134.56 283.65,135.45 283.65,139.25 283.87,139.78 284.4,140 285.43,140 285.6,139.92 285.68,139.75 285.68,131.71 285.15,131.19 284.72,131.19 282.21,133.69 273.8,133.69 272.8,134 272.15,134.83 261.73,134.83 259.93,133.03 252.66,133.03 252.73,133.21 252.75,133.39 252.75,133.83 252.75,135.82 253.05,136.06 253.15,136.42 253.15,137.47 253.51,137.65 253.65,138.02 253.65,138.35 253.73,138.52 253.9,138.6 259.6,138.6 259.6,140.75 259.68,140.92 259.85,141 266.35,141
GND on BOTTOM (solid shape): outline of 327 points within 71.47,118.48 85.08,140
GND on BOTTOM (solid shape): outline of 775 points within 0.25,16.3 68.66,138.6
GND on BOTTOM (solid shape): outline of 132 points within 95.91,124.95 224.02,140.6
GND on BOTTOM (solid shape): outline of 202 points within 0.25,0.25 236.25,110.67
GND on BOTTOM (solid shape): outline of 315 points within 133.29,83.71 138.72,89.56
GND on BOTTOM (solid shape): outline of 1010 points within 103.88,86.86 129.75,90.91
GND on BOTTOM (solid shape): outline of 2579 points within 173.18,22.25 194.66,34.93
GND on BOTTOM (solid shape): outline of 2688 points within 96.78,14.81 119.33,34.65
GND on BOTTOM (solid shape): outline of 2646 points within 132.88,19.76 155.7,34.62
GND on BOTTOM (solid shape): outline of 2793 points within 56.77,22.23 78.86,34.94
GND on BOTTOM (solid shape): outline of 8396 points within 98.82,66.45 134.42,90.91
GND on IN1 (solid shape): 37.68,58.67 37.68,53.57 37.36,53.25 34.27,53.25 33.98,53.54 33.98,58.75 34.52,59.29 37.05,59.29
GND on IN1 (solid shape): 44.78,23.51 44.78,20.4 45.05,20.13 47.36,20.13 47.5,19.99 47.5,18.7 47.35,18.55 46.69,18.55 46.42,18.28 46.42,17.82 45.71,17.11 45.71,16.74 45.46,16.49 43.04,16.49 42.84,16.69 42.84,23.41 43.09,23.66 44.63,23.66
GND on IN1 (solid shape): 100.8,111.51 100.8,105.91 100.57,105.67 98.68,105.67 97.84,104.83 92.52,104.83 92.29,105.07 92.29,107.2 92.41,107.32 94.4,107.32 94.43,107.29 96.15,107.29 96.47,107.61 96.47,107.62 96.47,111.22 96.46,111.23 96.46,111.55 96.59,111.67 96.93,111.67 96.93,111.68 100.63,111.68
GND on IN1 (solid shape): 129.4,140.6 129.57,140.52 129.65,140.35 129.65,139.85 130.01,138.96 130.9,138.6 136.1,138.6 136.99,138.96 137.35,139.85 137.35,140.35 137.43,140.52 137.6,140.6 138.86,140.6 138.86,135.98 136.26,135.98 136.02,135.75 130.35,135.75 129.53,134.93 126.4,134.93 125.94,134.47 124.42,134.47 124.15,134.73 124.15,139.85 124.37,140.38 124.9,140.6
GND on IN1 (solid shape): 183.4,140.6 183.57,140.52 183.65,140.35 183.65,139.85 184.01,138.96 184.9,138.6 190.1,138.6 190.99,138.96 191.35,139.85 191.35,140.35 191.43,140.52 191.6,140.6 196.1,140.6 196.63,140.38 196.85,139.85 196.85,132.9 197.28,130.37 198.52,128.12 182.48,128.12 182.48,129.62 184.88,129.62 184.88,136.08 182.48,136.08 182.48,140.6
GND on IN1 (solid shape): 82.12,140 82.29,139.92 82.37,139.75 82.37,134.11 81.88,133.27 82.62,132.65 85.08,132.65 85.08,131.04 80.32,126.28 71.76,126.28 71.16,126.87 71.16,128.8 72.92,128.8 73.65,129.43 73.15,130.26 73.15,137.25 73.37,137.78 73.9,138 74.03,138 79,138 79.66,138.18 80.12,138.69 80.57,139.58 80.85,139.88 81.24,140
GND on IN1 (solid shape): outline of 273 points within 234.07,127.06 244.35,138.6
GND on IN1 (solid shape): outline of 529 points within 252.72,128.88 285.68,141
GND on IN1 (solid shape): 58.4,138.6 58.93,138.38 59.15,137.85 59.15,130.26 58.66,129.42 59.4,128.8 60.46,128.8 61.14,128.8 61.14,128.29 59.79,128.29 53.83,122.33 53.83,121.1 65.32,105.76 66.26,86.61 66.5,86.61 68.66,84.45 66.5,82.29 64.84,82.29 52.78,67.46 34.5,61.89 6.2,61.89 5.68,61.67 5.46,61.15 5.46,54.27 5.29,53.41 4.8,52.67 4.18,52.05 4.02,51.81 3.96,51.53 3.96,45.25 3.45,44 2.2,43.49 1,43.49 0.83,43.42 0.76,43.25 0.76,16.3 0.25,16.3 0.25,43.25 0.47,43.78 1,44 2.2,44 3.09,44.36 3.45,45.25 3.45,51.53 3.55,52.01 3.82,52.41 4.44,53.03 4.82,53.6 4.95,54.27 4.95,61.15 5.32,62.03 6.2,62.4 34.5,62.4 52.62,67.97 64.48,82.76 64.5,82.8 66.5,82.8 68.15,84.45 66.5,86.1 65.73,86.1 65.65,86.14 65.64,86.23 64.09,107.48 49.64,123.13 48.19,124.51 47.65,126.44 47.65,138.35 47.73,138.52 47.9,138.6 58.36,138.6
GND on IN1 (solid shape): outline of 240 points within 0.25,0.25 263.02,120.71
GND on IN1 (solid shape): outline of 1306 points within 95.84,124.76 224.01,140.6
GND on IN1 (solid shape): outline of 1577 points within 156.22,20.79 172.78,32.1
GND on IN1 (solid shape): outline of 1558 points within 181.24,19.15 201.87,35.67
GND on IN1 (solid shape): outline of 2190 points within 97.93,23.28 129.82,35.27
GND on IN2 (solid shape): 94.99,106.62 94.99,105.57 94.72,105.3 92.04,105.3 91.94,105.4 91.94,106.58 92.22,106.86 94.74,106.86
GND on IN2 (solid shape): 37.6,56.01 37.6,53.08 37.24,52.72 33.84,52.72 33.56,53 33.56,55.79 34.04,56.28 34.04,56.3 37.3,56.3
GND on IN2 (solid shape): 100.42,111.23 100.42,107.02 100.13,106.73 96.71,106.73 96.43,107.01 96.43,111.24 96.88,111.69 99.96,111.69
GND on IN2 (solid shape): 129.4,140.6 129.57,140.52 129.65,140.35 129.65,139.85 130.01,138.96 130.9,138.6 136.1,138.6 136.99,138.96 137.35,139.85 137.35,140.35 137.43,140.52 137.6,140.6 138.86,140.6 138.86,136.21 138.63,135.98 136.26,135.98 136.02,135.75 130.35,135.75 129.53,134.93 126.4,134.93 125.94,134.47 124.42,134.47 124.15,134.73 124.15,139.85 124.37,140.38 124.9,140.6
GND on IN2 (solid shape): 243.4,138.6 243.57,138.52 243.65,138.35 243.65,138.02 243.73,137.73 243.95,137.53 243.95,136.42 244.05,136.06 244.35,135.82 244.35,134.57 244.35,133.39 244.35,133.31 244.36,133.23 243.63,132.49 243.63,131.08 244.23,130.47 244.23,128.76 243.95,128.47 242.62,128.47 241.04,130.06 241.04,132.8 240.01,133.83 238.43,133.83 237.87,133.28 237.87,127.88 237.3,127.31 236.1,127.31 235.46,127.94 235.02,127.94 234.83,127.75 234.83,127.31 234.7,127.18 234.2,127.18 234.07,127.31 234.07,128.8 235.93,128.8 236.67,129.42 236.18,130.26 236.18,137.85 236.4,138.38 236.93,138.6 242.6,138.6
GND on IN2 (solid shape): 183.4,140.6 183.57,140.52 183.65,140.35 183.65,139.85 184.01,138.96 184.9,138.6 190.1,138.6 190.99,138.96 191.35,139.85 191.35,140.35 191.43,140.52 191.6,140.6 196.1,140.6 196.63,140.38 196.85,139.85 196.85,132.9 197.24,130.46 198.4,128.28 198.41,128.18 198.32,128.12 197.88,128.12 196.92,129.07 189.21,129.07 188.93,128.79 182.78,128.79 182.48,129.1 182.48,129.62 184.88,129.62 184.88,136.08 182.48,136.08 182.48,140.6
GND on IN2 (solid shape): 82.12,140 82.29,139.92 82.37,139.75 82.37,134.51 81.88,133.67 82.62,133.05 85.08,133.05 85.08,132.15 85.08,131.04 80.32,126.28 71.76,126.28 71.16,126.87 71.16,128.8 72.92,128.8 73.65,129.43 73.15,130.26 73.15,137.25 73.37,137.78 73.9,138 74.03,138 79,138 79.66,138.18 80.12,138.69 80.57,139.58 80.64,139.69 80.73,139.79 80.96,139.94 81.24,140
GND on IN2 (solid shape): outline of 381 points within 252.72,131.36 285.68,141
GND on IN2 (solid shape): 58.4,138.6 58.93,138.38 59.15,137.85 59.15,130.26 58.66,129.42 59.4,128.8 60.25,128.8 61.14,128.8 61.14,128.29 59.78,128.29 54.1,122.6 54.1,120.91 65.38,105.6 66.26,86.61 66.5,86.61 68.66,84.45 66.5,82.29 64.84,82.29 52.78,67.46 34.5,61.89 6.2,61.89 5.68,61.67 5.46,61.15 5.46,54.27 5.29,53.41 4.8,52.67 4.18,52.05 4.02,51.81 3.96,51.53 3.96,45.25 3.45,44 2.2,43.49 1,43.49 0.83,43.42 0.76,43.25 0.76,16.3 0.25,16.3 0.25,43.25 0.47,43.78 1,44 2.2,44 3.09,44.36 3.45,45.25 3.45,51.53 3.55,52.01 3.82,52.41 4.44,53.03 4.82,53.6 4.95,54.27 4.95,61.15 5.32,62.03 6.2,62.4 34.5,62.4 52.62,67.97 64.48,82.76 64.5,82.8 66.5,82.8 68.15,84.45 66.5,86.1 65.73,86.1 65.65,86.14 65.64,86.23 64.09,107.48 49.64,123.13 48.19,124.51 47.65,126.44 47.65,138.35 47.73,138.52 47.9,138.6 58.36,138.6
GND on IN2 (solid shape): outline of 239 points within 0.25,0.25 263.02,120.71
GND on IN2 (solid shape): outline of 1283 points within 95.84,124.76 223.93,140.6
GND on IN2 (solid shape): outline of 3223 points within 132.67,26.01 191.48,34.42
GND on IN2 (solid shape): outline of 4592 points within 56.9,21.87 119.26,35.97
GND on IN3 (solid shape): 37.65,55.81 37.65,53.91 37.17,53.43 34.32,53.43 34.16,53.58 34.16,55.73 34.45,56.02 37.45,56.02
GND on IN3 (solid shape): 102.3,110.62 102.3,106.76 101.98,106.44 99.44,106.44 97.83,104.83 94.02,104.83 93.97,104.78 92.23,104.78 91.96,105.05 91.96,106.58 92.36,106.98 95.4,106.98 96.45,108.02 96.43,108.02 96.43,111.41 96.71,111.68 101.23,111.68
GND on IN3 (solid shape): 129.4,140.6 129.57,140.52 129.65,140.35 129.65,139.85 130.01,138.96 130.9,138.6 136.1,138.6 136.99,138.96 137.35,139.85 137.35,140.35 137.43,140.52 137.6,140.6 138.86,140.6 138.86,135.98 136.26,135.98 136.02,135.75 130.35,135.75 129.53,134.93 126.4,134.93 125.94,134.47 124.42,134.47 124.15,134.73 124.15,139.85 124.37,140.38 124.9,140.6
GND on IN3 (solid shape): 183.4,140.6 183.57,140.52 183.65,140.35 183.65,139.85 184.01,138.96 184.9,138.6 190.1,138.6 190.99,138.96 191.35,139.85 191.35,140.35 191.43,140.52 191.6,140.6 196.1,140.6 196.63,140.38 196.85,139.85 196.85,132.9 197.28,130.37 198.52,128.12 182.48,128.12 182.48,129.62 184.88,129.62 184.88,136.08 182.48,136.08 182.48,140.6
GND on IN3 (solid shape): 82.12,140 82.29,139.92 82.37,139.75 82.37,134.51 81.88,133.67 82.62,133.05 85.08,133.05 85.08,131.04 80.65,126.61 71.43,126.61 71.16,126.87 71.16,128.8 72.92,128.8 73.65,129.43 73.15,130.26 73.15,137.25 73.37,137.78 73.9,138 74.03,138 79,138 79.66,138.18 80.12,138.69 80.52,139.48 80.57,139.58 80.85,139.88 81.24,140
GND on IN3 (solid shape): outline of 235 points within 234.07,127.19 244.65,138.6
GND on IN3 (solid shape): 196.1,140.6 196.63,140.38 196.85,139.85 196.85,132.9 204.48,125.27 212.1,132.9 212.1,137.85 212.32,138.38 212.85,138.6 221.43,138.6 221.96,138.38 222.18,137.85 222.18,130.26 221.69,129.42 222.43,128.8 224.02,128.8 224.02,127.62 223.63,127.23 220.75,127.23 220.51,127.46 220.45,127.89 220.03,127.95 219.14,128.84 211.53,128.84 202.37,125.04 196.34,132.9 196.34,139.85 196.27,140.02 196.1,140.09 191.88,140.09 191.88,140.6
GND on IN3 (solid shape): outline of 300 points within 197.54,67.7 214.53,75.09
GND on IN3 (solid shape): outline of 380 points within 252.72,131.36 285.68,141
GND on IN3 (solid shape): outline of 91 points within 95.84,124.95 190.57,140.6
GND on IN3 (solid shape): 58.4,138.6 58.93,138.38 59.15,137.85 59.15,130.26 58.66,129.42 59.4,128.8 61.14,128.8 61.14,128.29 59.88,128.29 54.06,122.47 54.06,120.93 65.37,105.62 66.26,86.61 66.5,86.61 68.66,84.45 66.5,82.29 64.84,82.29 52.78,67.46 34.5,61.89 6.2,61.89 5.68,61.67 5.46,61.15 5.46,54.27 5.29,53.41 4.8,52.67 4.18,52.05 4.02,51.81 3.96,51.53 3.96,45.25 3.45,44 2.2,43.49 1,43.49 0.83,43.42 0.76,43.25 0.76,16.3 0.25,16.3 0.25,43.25 0.47,43.78 1,44 2.2,44 3.09,44.36 3.45,45.25 3.45,51.53 3.55,52.01 3.82,52.41 4.44,53.03 4.82,53.6 4.95,54.27 4.95,61.15 5.32,62.03 6.2,62.4 34.5,62.4 52.62,67.97 64.48,82.76 64.5,82.8 66.5,82.8 68.15,84.45 66.5,86.1 65.73,86.1 65.65,86.14 65.64,86.23 64.09,107.48 49.64,123.13 48.19,124.51 47.65,126.44 47.65,138.35 47.73,138.52 47.9,138.6 58.38,138.6
GND on IN3 (solid shape): outline of 240 points within 0.25,0.25 263.02,120.71
GND on IN3 (solid shape): outline of 2167 points within 98.98,96.89 125.97,110.32
GND on IN3 (solid shape): outline of 9321 points within 100.63,69.84 132.44,96.95
GND on IN3 (solid shape): outline of 10919 points within 56.67,19.68 194.9,34.79
GND on VCC (solid shape): 0.25,14.37 0.5,14.28 0.76,14.3 0.76,11.61 2.2,11.61 3.45,11.1 3.96,9.85 3.96,6.85 4.32,5.97 5.2,5.61 8.18,5.61 8.18,5.1 5.2,5.1 3.97,5.62 3.45,6.85 3.45,9.85 3.09,10.74 2.2,11.1 1,11.1 0.47,11.32 0.25,11.85
GND on VCC (solid shape): 259.25,120.2 246.02,120.2 245.39,120.11 244.81,119.85 241.27,117.59 240.52,117.12 240.33,117.03 240.12,117 235.7,117 234.81,116.64 234.45,115.75 234.45,114.94 234.3,114.49 233.91,114.22 233.78,114.18 233.67,114.11 233.61,114.05 233.56,114 233.47,114.26 233.36,114.5 233.55,114.63 233.77,114.71 233.89,114.8 233.94,114.94 233.94,115.75 234.45,117 235.7,117.51 240.12,117.51 240.19,117.52 240.25,117.55 241.97,118.64 244.54,120.28 245.25,120.6 246.03,120.71 259.25,120.71
GND on VCC (solid shape): outline of 919 points within 194.54,124.76 232.54,140.6
GND on VCC (solid shape): outline of 1345 points within 11.26,0.25 236.25,110.64
GND on VCC (solid shape): outline of 1693 points within 233.06,124.91 286.21,141
GND on IN4 (solid shape): 37.62,61.13 37.62,53.6 37.23,53.22 34.29,53.22 34.05,53.45 34.05,54.29 34.05,54.29 34.05,60.59 34.83,61.37 37.38,61.37
GND on IN4 (solid shape): 99.98,111.76 100.12,111.61 100.12,107.53 97.43,104.84 92.64,104.84 92.51,104.97 92.51,106.33 92.6,106.42 96.04,106.42 96.48,106.86 96.48,111.44 96.8,111.76 99.27,111.76
GND on IN4 (solid shape): 129.4,140.6 129.57,140.52 129.65,140.35 129.65,139.85 130.01,138.96 130.9,138.6 136.1,138.6 136.99,138.96 137.35,139.85 137.35,140.35 137.43,140.52 137.6,140.6 138.86,140.6 138.86,135.98 136.26,135.98 136.02,135.75 130.35,135.75 129.53,134.93 126.4,134.93 125.94,134.47 124.42,134.47 124.15,134.73 124.15,139.85 124.37,140.38 124.9,140.6
GND on IN4 (solid shape): 183.4,140.6 183.57,140.52 183.65,140.35 183.65,139.85 184.01,138.96 184.9,138.6 190.1,138.6 190.99,138.96 191.35,139.85 191.35,140.35 191.43,140.52 191.6,140.6 196.1,140.6 196.63,140.38 196.85,139.85 196.85,132.9 197.28,130.37 198.52,128.12 182.48,128.12 182.48,129.62 184.88,129.62 184.88,136.08 182.48,136.08 182.48,140.6
