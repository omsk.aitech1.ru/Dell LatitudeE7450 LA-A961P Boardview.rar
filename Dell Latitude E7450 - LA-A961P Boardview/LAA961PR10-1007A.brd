# Allegro board LAA961PR10-1007A.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_B_D55: length 101.8
  IN4 w0.084: v2(125.72,73.67) 125.33,73.28 125.33,72.85 124.33,71.86 124.33,69.58 128.1,65.82 128.1,63.24 128.81,62.54 128.81,61.22 129.97,60.05 132.44,60.05 134.51,57.98 135.4,57.98 136.67,56.71 142.57,56.71 143.38,55.9 146.38,55.9 147.19,55.1 171.5,55.1 178.67,47.93 178.67,45.91 188.54,36.03 188.54,32.66 188.62,32.58 189.15,32.58 189.23,32.49 189.23,32.17 189.15,32.09 188.62,32.09 188.54,32 188.54,31.68 188.62,31.6 189.15,31.6 189.23,31.51 189.23,27.63 189.13,27.53 v2(188.63,27.53)
  BOTTOM w0.089: v2(125.72,73.67) 126.05,74 UC1.AK22
  BOTTOM w0.102: v2(188.63,27.53) 189.85,26.3 JDIMM2.182
DDR_B_D56: length 67.7
  IN1 w0.084: v2(127.63,71.72) 127.22,71.31 127.22,69.45 128.95,67.71 128.95,66.65 129.22,66.38 129.87,66.38 130.67,65.58 130.67,62.36 131.57,61.47 132.32,61.47 134.87,58.92 134.87,56.59 135.06,56.4 135.06,53.78 136.5,52.33 136.5,52 135.86,51.36 135.86,51.18 136.04,51 136.22,51 136.85,51.64 137.03,51.64 137.2,51.47 137.2,51.29 136.52,50.61 136.52,50.24 149.98,36.78 149.98,36.17 150.11,36.05 150.9,36.05 151.03,35.92 151.03,35.62 150.9,35.49 150.23,35.49 150.11,35.37 150.11,35.13 150.23,35 150.9,35 151.03,34.88 151.03,34.57 150.9,34.45 150.62,34.45 150.49,34.32 150.49,32.67 150.57,32.59 150.94,32.59 151.03,32.5 151.03,32.18 150.94,32.1 150.57,32.1 150.49,32.01 150.49,31.69 150.57,31.61 150.94,31.61 151.03,31.52 151.03,31.2 150.94,31.12 150.57,31.12 150.49,31.03 150.49,28.02 150.62,27.89 151.42,27.89 151.55,28.02 151.55,28.65 v2(151.15,29.05)
  BOTTOM w0.076: v2(127.63,71.72) 127.95,72.05 UC1.AN20
  BOTTOM w0.102: v2(151.15,29.05) 149.95,30.25 JDIMM2.57
DDR_B_D57: length 66.3
  IN1 w0.084: v2(151.15,30.57) 151.34,30.76 151.34,33.19 151.21,33.32 150.93,33.32 150.8,33.44 150.8,33.97 150.93,34.1 151.21,34.1 151.34,34.23 151.34,36.1 150.61,36.83 150.61,36.83 140.62,46.81 140.62,46.93 141.42,47.73 141.42,47.85 141.19,48.08 141.08,48.08 140.27,47.28 140.16,47.28 140.09,47.35 140.09,47.78 140.73,48.43 140.73,48.55 140.5,48.77 140.38,48.77 139.58,47.97 139.46,47.97 139.23,48.2 139.23,48.32 140.04,49.12 140.04,49.24 139.81,49.47 139.69,49.47 138.89,48.66 138.77,48.66 138.54,48.89 138.54,49.01 139.34,49.81 139.34,49.93 139.11,50.16 139,50.16 138.19,49.36 138.08,49.36 137.85,49.59 137.85,49.71 138.65,50.51 138.65,50.63 138.42,50.85 138.3,50.85 137.54,50.09 137.34,50.09 137.15,50.28 137.15,50.4 137.96,51.2 137.96,51.32 135.37,53.91 135.37,56.53 135.18,56.72 135.18,59.18 132.68,61.67 131.6,61.67 130.85,62.43 130.85,65.65 129.95,66.56 129.46,66.56 129.13,66.89 129.13,67.78 127.63,69.29 v2(127.63,70.42)
  BOTTOM w0.076: UC1.AR20 127.95,70.75 v2(127.63,70.42)
  BOTTOM w0.102: JDIMM2.59 150.55,31.17 v2(151.15,30.57)
DDR_B_D58: length 68.2
  IN1 w0.084: v2(128.54,73.63) 128.92,73.25 128.92,72.89 129.12,72.7 129.12,71.02 129.3,70.84 129.3,69.12 131.05,67.36 131.05,67.1 133.41,64.74 133.41,63.76 137.75,59.42 137.75,54.78 147.56,44.97 147.56,44.86 146.78,44.08 146.78,43.96 147.01,43.73 147.12,43.73 147.9,44.51 148.02,44.51 148.25,44.28 148.25,44.16 147.47,43.38 147.47,43.26 147.7,43.03 147.82,43.03 148.6,43.82 148.72,43.82 148.94,43.59 148.94,43.47 148.16,42.69 148.16,42.57 148.39,42.34 148.51,42.34 149.29,43.12 149.41,43.12 149.64,42.89 149.64,42.78 148.86,41.99 148.86,41.88 149.09,41.65 149.2,41.65 149.98,42.43 150.1,42.43 150.33,42.2 150.33,42.08 149.55,41.3 149.55,41.18 149.78,40.95 149.9,40.95 150.51,41.57 150.65,41.57 150.86,41.36 150.86,41.22 150.24,40.61 150.24,40.49 154.48,36.25 154.48,30.9 v2(154.15,30.57)
  BOTTOM w0.089: v2(128.54,73.63) 128.9,74 UC1.AK18
  BOTTOM w0.102: JDIMM2.69 153.55,31.17 v2(154.15,30.57)
DDR_B_D59: length 68.3
  IN1 w0.084: v2(128.55,73.02) 128.95,72.63 128.95,70.94 129.12,70.77 129.12,69.05 130.88,67.29 130.88,67.03 133.22,64.69 133.22,63.33 137.38,59.17 137.38,54.71 144.12,47.97 144.12,47.86 143.41,47.15 143.41,47.01 143.62,46.81 143.76,46.81 144.46,47.51 144.58,47.51 144.81,47.28 144.81,47.16 144.03,46.38 144.03,46.26 144.25,46.05 144.39,46.05 145.16,46.82 145.27,46.82 145.5,46.59 145.5,46.47 144.72,45.69 144.72,45.57 144.95,45.34 145.07,45.34 145.85,46.12 145.97,46.12 146.2,45.89 146.2,45.78 145.41,44.99 145.41,44.88 145.64,44.65 145.76,44.65 146.44,45.33 146.59,45.33 146.79,45.13 146.79,44.98 146.11,44.3 146.11,44.18 153.53,36.76 153.53,31.74 153.75,31.52 153.75,29.45 v2(154.15,29.05)
  BOTTOM w0.089: v2(128.55,73.02) 128.88,73.35 UC1.AL18
  BOTTOM w0.102: JDIMM2.67 152.95,30.98 153.52,30.41 153.52,29.68 v2(154.15,29.05)
DDR_B_D60: length 68.9
  IN1 w0.084: v2(127.63,73.67) 127.59,73.67 127.22,74.05 126.49,74.05 126.22,73.77 126.22,68.38 127.12,67.48 127.24,67.48 127.69,67.94 127.84,67.94 128.04,67.74 128.04,67.59 127.58,67.14 127.58,67.02 128.31,66.28 128.83,66.28 129.08,66.04 129.73,66.04 130.33,65.44 130.33,62.21 131.5,61.04 132.1,61.04 133.76,59.39 133.76,55.22 134.43,54.55 134.43,53.52 135.23,52.72 135.23,50.65 149.36,36.52 149.36,33.37 149.87,32.86 149.87,24.82 149.78,24.74 149.41,24.74 149.31,24.63 149.31,24.35 149.41,24.25 149.78,24.25 149.87,24.16 149.87,23.39 v2(150.85,22.41)
  BOTTOM w0.089: UC1.AK20 127.95,74 v2(127.63,73.67)
  BOTTOM w0.102: v2(150.85,22.41) 150.25,23.01 JDIMM2.58
DDR_B_D61: length 68.1
  IN1 w0.084: v2(127.63,72.37) 127.04,71.79 127.04,69.38 128.78,67.64 128.78,66.58 129.15,66.21 129.8,66.21 130.5,65.51 130.5,62.29 131.57,61.22 132.26,61.22 134.55,58.92 134.55,56.32 134.74,56.13 134.74,53.65 135.54,52.85 135.54,50.78 149.67,36.65 149.67,34.37 150.18,33.86 150.18,26.57 151.3,25.45 151.3,24.58 151.22,24.49 150.66,24.49 150.56,24.39 150.56,24.11 150.66,24 151.22,24 151.3,23.92 151.3,21.33 v2(150.85,20.88)
  BOTTOM w0.089: v2(127.63,72.37) 127.95,72.7 UC1.AM20
  BOTTOM w0.102: v2(150.85,20.88) 149.65,22.08 JDIMM2.56
DDR_B_D62: length 65
  IN1 w0.084: v2(128.58,70.42) 128.58,69.11 130.53,67.15 130.53,66.89 132.08,65.34 132.08,63.57 136.76,58.89 136.76,54.45 142.79,48.42 142.79,46.58 152.77,36.59 152.77,30.89 153.13,30.53 153.13,27.7 153.26,27.57 153.86,27.57 153.99,27.44 153.99,27.13 153.86,27 153.36,27 153.23,26.88 153.23,26.55 153.36,26.42 154.47,26.42 154.6,26.3 154.6,25.99 154.47,25.86 154.07,25.86 153.95,25.73 153.95,25.07 154.07,24.94 154.47,24.94 154.6,24.81 154.6,24.49 154.47,24.36 154.07,24.36 153.95,24.23 153.95,22.53 154.07,22.41 v2(154.45,22.41)
  BOTTOM w0.076: v2(128.58,70.42) 128.9,70.75 UC1.AR18
  BOTTOM w0.102: v2(154.45,22.41) 153.85,23.01 JDIMM2.70
DDR_B_D63: length 65.5
  IN1 w0.084: v2(128.58,71.07) 128.95,70.7 128.95,68.98 130.71,67.22 130.71,66.96 132.96,64.7 132.96,63.13 137.07,59.02 137.07,54.58 143.1,48.55 143.1,46.71 153.15,36.65 153.15,31.68 153.44,31.39 153.44,28.44 155.1,26.78 155.1,21.53 v2(154.45,20.88)
  BOTTOM w0.076: UC1.AP18 128.9,71.4 v2(128.58,71.07)
  BOTTOM w0.102: v2(154.45,20.88) 153.25,22.08 JDIMM2.68
DDR_B_DQS0: length 87.5
  IN4 w0.091: v2(120.5,65.03) 120.74,65.27 121.14,65.27 121.51,64.9 121.51,59.96 122.03,59.44 122.03,55.5 130.8,46.73 135.22,46.73 137.21,44.73 157.19,44.73 158.31,43.61 166.59,43.61 174.56,35.63 174.56,33.07 175.05,32.58 175.05,29.56 175.32,29.28 175.54,29.28 v2(175.77,29.05)
  BOTTOM w0.076: v2(120.5,65.03) 120.26,65.27 120.09,65.27 119.93,65.43 119.93,66.54 120.09,66.7 120.09,67.27 120.33,67.51 120.33,67.7 120.29,67.8 120.28,67.81 120.26,67.86 120.26,68.06 120.33,68.22 120.33,68.35 120.29,68.45 120.26,68.51 120.26,68.71 120.33,68.85 120.33,68.87 120.4,68.94 120.49,69.03 120.64,69.03 120.72,69.11 UC1.AV30
  BOTTOM w0.102: v2(175.77,29.05) 175.96,29.24 176.17,29.24 176.57,29.65 176.57,30.81 176.35,31.04 JDIMM2.137
DDR_B_DQS1: length 61.1
  IN1 w0.091: v2(137.05,21.64) 137.05,21.44 137.29,21.2 137.45,21.2 137.6,21.36 137.6,22.55 135.69,24.47 135.69,30.82 133.52,32.99 133.52,33.85 122.75,44.61 122.75,62.83 123.29,63.37 123.96,63.37 124.21,63.61 v2(124.21,63.73)
  BOTTOM w0.076: UC1.AW26 123.11,68.65 123,68.65 122.93,68.57 122.93,68.18 122.91,68.13 122.86,68.05 122.86,68.03 122.86,67.9 122.88,67.84 122.93,67.74 122.93,67.33 122.64,67.04 122.56,66.96 122.56,66.64 123.18,66.02 123.18,63.89 123.75,63.31 123.92,63.31 124.21,63.6 v2(124.21,63.73)
  BOTTOM w0.102: v2(137.05,21.64) 137.05,21.44 136.9,21.29 136.79,21.29 136.44,21.64 136.44,21.96 136.07,22.34 136.07,22.6 136.17,22.71 136.39,22.71 136.45,22.77 JDIMM2.12
DDR_B_DQS2: length 94.9
  IN4 w0.091: v2(181.95,26.76) 181.72,27 181.32,27 181.16,27.15 181.16,31.01 180.46,31.71 180.46,35.44 168.47,47.44 159.9,47.44 158.57,48.77 141.76,48.77 139.97,50.56 132.71,50.56 125.86,57.41 125.86,59.31 124.58,60.59 124.58,65.83 123.72,66.69 123.72,67.57 121.47,69.83 121.47,72.01 121.63,72.17 121.82,72.17 v2(122.02,72.37)
  BOTTOM w0.076: UC1.AM28 122.34,72.7 v2(122.02,72.37)
  BOTTOM w0.102: JDIMM2.154 181.45,24.93 181.21,25.17 181.21,26.96 181.32,27.08 181.64,27.08 v2(181.95,26.76)
DDR_B_DQS3: length 63
  IN1 w0.091: v2(140.78,29.05) 140.62,29.21 140.36,29.21 140.15,29.41 140.15,31.26 140.42,31.52 140.9,31.52 141,31.63 141,32.04 140.9,32.14 140.35,32.14 140.16,32.34 140.16,32.9 140.35,33.09 140.88,33.09 141,33.22 141,33.76 136.5,38.26 136.37,38.26 136.25,38.15 135.97,38.15 135.59,38.53 135.59,38.81 135.72,38.94 135.72,39.09 135.44,39.37 135.29,39.37 134.94,39.02 134.66,39.02 134.27,39.4 134.27,39.69 134.61,40.03 134.61,40.15 134.32,40.45 134.19,40.45 133.85,40.11 133.56,40.11 133.18,40.49 133.18,40.78 133.52,41.12 133.52,41.25 133.23,41.54 133.1,41.54 132.76,41.2 132.47,41.2 132.09,41.58 132.09,41.87 132.43,42.21 132.43,42.34 132.13,42.63 132,42.63 131.67,42.29 131.38,42.29 131,42.68 131,42.96 131.34,43.3 131.34,43.43 127.57,47.19 127.57,55.28 126.79,56.06 126.79,59.6 125.53,60.87 125.53,66.06 125.25,66.34 125.25,67.39 123.35,69.29 123.35,72.02 123.55,72.22 123.77,72.22 v2(123.92,72.37)
  BOTTOM w0.089: v2(123.92,72.37) 124.25,72.7 UC1.AM25
  BOTTOM w0.102: JDIMM2.29 141.55,32.14 141.55,29.41 141.29,29.15 140.89,29.15 v2(140.78,29.05)
DDR_B_DQS4: length 91.8
  IN4 w0.091: v2(126.11,65.03) 126.34,65.26 126.51,65.26 127.13,64.63 127.13,60.89 127.42,60.59 127.48,60.54 127.96,60.54 129.61,58.89 129.79,58.89 134.28,54.41 141.62,54.41 142.43,53.6 145.3,53.6 146.3,52.6 160.16,52.6 160.72,52.04 171.31,52.04 176.37,46.98 176.37,44.95 186.15,35.17 186.15,30.43 186.27,30.32 186.27,29.27 186.13,29.13 186,29.13 185.83,29.3 v2(185.83,29.43)
  BOTTOM w0.076: v2(126.11,65.03) 125.61,65.53 125.61,66.53 125.35,66.78 125.35,67.4 125.47,67.51 125.47,67.7 125.42,67.8 125.42,67.81 125.39,67.86 125.39,68.06 125.47,68.22 125.47,68.35 125.42,68.45 125.39,68.51 125.39,68.71 125.46,68.85 125.46,68.87 125.53,68.94 125.62,69.03 125.77,69.03 125.85,69.11 UC1.AV22
  BOTTOM w0.102: JDIMM2.171 186.55,31.14 186.05,30.64 185.67,30.64 185.34,30.3 185.34,29.29 185.46,29.16 185.56,29.16 v2(185.83,29.43)
DDR_B_DQS5: length 59.7
  IN1 w0.091: v2(129.59,63) 129.59,62.88 129.23,62.52 129.01,62.52 128.82,62.34 128.82,60.9 130.63,59.09 130.63,57.95 131.41,57.16 131.41,51.22 131.81,50.83 131.81,50.7 131.51,50.4 131.51,50.13 131.91,49.73 132.18,49.73 132.47,50.03 132.6,50.03 132.9,49.73 132.9,49.6 132.6,49.31 132.6,49.04 133,48.64 133.27,48.64 133.57,48.94 133.69,48.94 133.99,48.64 133.99,48.51 133.7,48.22 133.7,47.95 134.09,47.55 134.36,47.55 134.66,47.84 134.79,47.84 135.08,47.55 135.08,47.42 134.79,47.13 134.79,46.85 135.18,46.46 135.46,46.46 135.75,46.75 135.88,46.75 136.17,46.46 136.17,46.33 135.88,46.03 135.88,45.76 136.28,45.36 136.55,45.36 136.84,45.66 136.97,45.66 137.27,45.36 137.27,45.24 136.97,44.94 136.97,44.67 146.95,34.69 146.95,32.6 146.68,32.32 146.68,31.5 147.48,30.69 147.48,29.48 147.39,29.39 147.24,29.39 147.01,29.61 v2(147.01,29.81)
  BOTTOM w0.076: UC1.AW18 128.1,68.61 128.06,68.57 128.06,68.18 128.04,68.13 128,68.05 127.99,68.03 127.99,67.9 128.02,67.84 128.06,67.74 128.06,67.42 127.82,67.18 127.82,66.86 128.72,65.96 128.72,63.03 129.16,62.6 129.28,62.6 129.59,62.91 v2(129.59,63)
  BOTTOM w0.102: JDIMM2.47 146.95,31.12 146.84,31 146.63,31 146.57,30.94 146.57,30.74 146.41,30.59 146.41,29.59 146.58,29.42 146.83,29.42 147.01,29.6 v2(147.01,29.81)
DDR_B_DQS6: length 99.4
  IN4 w0.091: v2(190.63,27.22) 190.83,27.02 191.13,27.02 191.26,27.15 191.26,30.69 191.17,30.78 191.03,30.78 190.8,31.01 190.8,31.49 191.03,31.72 191.17,31.72 191.26,31.81 191.26,36.24 183.68,43.82 183.68,45.08 171.93,56.83 147.64,56.83 147.04,57.44 144.16,57.44 142.82,58.77 136.64,58.77 136.11,59.3 134.57,59.3 130.44,63.44 130.44,65.88 129.92,66.4 129.41,66.4 127.93,67.89 127.16,67.89 126.12,68.93 126.12,72 126.31,72.19 126.49,72.19 v2(126.67,72.37)
  BOTTOM w0.076: v2(126.67,72.37) 127,72.7 UC1.AM21
  BOTTOM w0.102: JDIMM2.188 191.65,25.09 191.46,25.28 191.46,26.62 191.13,26.95 190.9,26.95 v2(190.63,27.22)
DDR_B_DQS7: length 66.7
  IN1 w0.091: v2(128.58,72.37) 128.58,72.22 128.45,72.08 128.21,72.08 128.02,71.89 128.02,69.17 130.11,67.08 130.11,66.82 131.3,65.63 131.3,63.53 135.99,58.84 135.99,54.13 142.02,48.1 142.02,46.26 151.93,36.34 151.93,29.3 152.36,28.87 152.36,26.23 153.18,25.41 153.18,21.33 153.06,21.21 152.89,21.21 152.65,21.45 v2(152.65,21.64)
  BOTTOM w0.076: v2(128.58,72.37) 128.9,72.7 UC1.AM18
  BOTTOM w0.102: v2(152.65,21.64) 152.33,21.33 152.04,21.33 151.87,21.49 151.87,22.48 152.05,22.65 JDIMM2.64
DDR_B_DQS#0: length 87.6
  IN4 w0.091: v2(175.77,29.81) 175.77,29.58 175.65,29.45 175.39,29.45 175.22,29.63 175.22,32.65 174.73,33.14 174.73,35.71 166.66,43.78 158.39,43.78 157.26,44.91 137.28,44.91 135.29,46.9 130.87,46.9 122.2,55.57 122.2,59.51 121.68,60.03 121.68,64.97 121.21,65.44 120.73,65.44 v2(120.5,65.68)
  BOTTOM w0.076: v2(120.5,65.68) 120.52,65.7 120.61,65.7 120.63,65.68 120.63,65.57 120.52,65.46 120.17,65.46 120.12,65.5 120.12,66.46 120.26,66.59 120.26,67.2 120.5,67.45 120.5,67.74 120.48,67.79 120.48,67.79 120.43,67.9 120.43,68.03 120.43,68.05 120.47,68.13 120.5,68.18 120.5,68.39 120.43,68.55 120.43,68.68 120.47,68.78 120.56,68.86 120.64,68.86 120.72,68.79 UC1.AW30
  BOTTOM w0.102: v2(175.77,29.81) 175.77,29.54 175.86,29.45 176.08,29.45 176.36,29.73 176.36,30.72 176.11,30.97 175.9,30.97 175.75,31.11 JDIMM2.135
DDR_B_DQS#1: length 61.2
  IN1 w0.091: v2(124.21,63.08) 124.12,63.16 123.33,63.16 122.93,62.76 122.93,44.68 133.69,33.92 133.69,33.06 135.86,30.89 135.86,24.54 137.77,22.63 137.77,21.29 137.52,21.03 137.2,21.03 v2(137.05,20.88)
  BOTTOM w0.076: UC1.AV26 122.92,69.04 122.92,68.86 122.76,68.7 122.76,68.22 122.69,68.06 122.69,67.86 122.76,67.7 122.76,67.4 122.52,67.16 122.4,67.03 122.4,66.57 122.99,65.98 122.99,63.81 123.67,63.12 124.16,63.12 v2(124.21,63.08)
  BOTTOM w0.102: JDIMM2.10 135.85,22.25 136.22,21.87 136.22,21.55 136.7,21.08 136.86,21.08 v2(137.05,20.88)
DDR_B_DQS#2: length 95
  IN4 w0.091: v2(122.02,71.72) 122.02,71.88 121.9,72 121.7,72 121.64,71.94 121.64,69.9 123.9,67.65 123.9,66.76 124.75,65.9 124.75,60.66 126.03,59.39 126.03,57.48 132.78,50.73 140.04,50.73 141.83,48.94 158.65,48.94 159.97,47.61 168.54,47.61 180.64,35.51 180.64,31.78 181.33,31.08 181.33,27.22 181.39,27.17 181.6,27.17 v2(181.95,27.53)
  BOTTOM w0.076: UC1.AN28 122.41,71.78 122.35,71.72 v2(122.02,71.72)
  BOTTOM w0.102: v2(181.95,27.53) 181.72,27.3 181.23,27.3 180.99,27.05 180.99,25.15 180.85,25.01 JDIMM2.152
DDR_B_DQS#3: length 62.9
  IN1 w0.091: v2(123.92,71.72) 123.92,71.86 123.74,72.05 123.62,72.05 123.53,71.95 123.53,69.36 125.42,67.46 125.42,66.41 125.7,66.13 125.7,60.94 126.97,59.67 126.97,56.13 127.75,55.35 127.75,47.26 131.51,43.5 131.51,43.23 131.17,42.89 131.17,42.75 131.45,42.47 131.59,42.47 131.93,42.81 132.2,42.81 132.6,42.41 132.6,42.14 132.26,41.8 132.26,41.66 132.54,41.38 132.69,41.38 133.02,41.71 133.3,41.71 133.69,41.32 133.69,41.05 133.35,40.71 133.35,40.56 133.63,40.28 133.78,40.28 134.12,40.62 134.39,40.62 134.79,40.23 134.79,39.95 134.45,39.61 134.45,39.47 134.73,39.19 134.87,39.19 135.22,39.54 135.51,39.54 135.89,39.16 135.89,38.87 135.76,38.74 135.76,38.6 136.04,38.32 136.18,38.32 136.3,38.44 136.57,38.44 141.18,33.83 141.18,33.15 140.95,32.92 140.43,32.92 140.33,32.82 140.33,32.41 140.43,32.32 140.97,32.32 141.17,32.11 141.17,31.55 140.97,31.35 140.49,31.35 140.33,31.19 140.33,29.48 140.43,29.38 140.56,29.38 140.78,29.61 v2(140.78,29.81)
  BOTTOM w0.089: UC1.AN25 124.12,72.05 123.92,71.85 v2(123.92,71.72)
  BOTTOM w0.102: JDIMM2.27 140.95,31.13 141.33,30.74 141.33,29.5 141.2,29.37 141.04,29.37 140.78,29.63 v2(140.78,29.81)
DDR_B_DQS#4: length 91.8
  IN4 w0.091: v2(185.83,28.67) 185.83,28.67 185.83,28.83 185.95,28.96 186.2,28.96 186.44,29.2 186.44,30.39 186.33,30.5 186.33,35.24 176.54,45.02 176.54,47.05 171.38,52.21 160.79,52.21 160.23,52.77 146.38,52.77 145.37,53.77 142.5,53.77 141.69,54.58 134.35,54.58 129.87,59.07 129.68,59.07 128.03,60.71 127.55,60.71 127.3,60.96 127.3,64.7 126.58,65.43 126.36,65.43 v2(126.11,65.68)
  BOTTOM w0.076: UC1.AW22 125.85,68.79 125.78,68.86 125.69,68.86 125.61,68.78 125.56,68.68 125.56,68.55 125.63,68.39 125.63,68.18 125.61,68.13 125.57,68.05 125.56,68.03 125.56,67.9 125.58,67.84 125.63,67.74 125.63,67.45 125.52,67.33 125.52,66.85 125.8,66.57 125.8,65.76 125.89,65.68 v2(126.11,65.68)
  BOTTOM w0.102: JDIMM2.169 185.95,31.14 186.03,31.05 186.03,30.93 185.96,30.85 185.58,30.85 185.12,30.39 185.12,29.2 185.37,28.95 185.55,28.95 v2(185.83,28.67)
DDR_B_DQS#5: length 59.8
  IN1 w0.091: v2(147.01,29.05) 147.18,29.21 147.46,29.21 147.66,29.41 147.66,30.76 146.85,31.57 146.85,32.25 147.12,32.52 147.12,34.76 137.14,44.74 137.14,44.87 137.44,45.16 137.44,45.44 137.04,45.83 136.77,45.83 136.48,45.54 136.35,45.54 136.05,45.83 136.05,45.96 136.35,46.26 136.35,46.53 135.95,46.92 135.68,46.92 135.38,46.63 135.26,46.63 134.96,46.92 134.96,47.05 135.25,47.35 135.25,47.62 134.86,48.02 134.59,48.02 134.29,47.72 134.16,47.72 133.87,48.02 133.87,48.15 134.16,48.44 134.16,48.71 133.77,49.11 133.49,49.11 133.2,48.81 133.07,48.81 132.78,49.11 132.78,49.24 133.07,49.53 133.07,49.8 132.67,50.2 132.4,50.2 132.11,49.91 131.98,49.91 131.68,50.2 131.68,50.33 131.98,50.62 131.98,50.9 131.59,51.29 131.59,57.23 130.8,58.02 130.8,59.17 128.99,60.97 128.99,62.27 129.08,62.35 v2(129.59,62.35)
  BOTTOM w0.076: v2(129.59,62.35) 129.53,62.41 129.08,62.41 128.53,62.95 128.53,65.88 127.66,66.76 127.66,67.26 127.9,67.5 127.9,67.7 127.82,67.86 127.82,68.06 127.9,68.22 127.9,68.7 128.06,68.86 128.06,69.04 UC1.AV18
  BOTTOM w0.102: JDIMM2.45 146.35,30.83 146.19,30.68 146.19,29.5 146.49,29.2 146.86,29.2 v2(147.01,29.05)
DDR_B_DQS#6: length 99.4
  IN4 w0.091: v2(190.63,26.46) 190.63,26.69 190.8,26.85 191.2,26.85 191.43,27.08 191.43,30.76 191.24,30.95 191.1,30.95 190.97,31.08 190.97,31.42 191.1,31.55 191.24,31.55 191.43,31.74 191.43,36.31 183.86,43.89 183.86,45.15 172,57.01 147.71,57.01 147.11,57.61 144.23,57.61 142.9,58.94 136.71,58.94 136.18,59.47 134.64,59.47 130.61,63.51 130.61,65.96 129.99,66.58 129.48,66.58 128,68.06 127.24,68.06 126.3,69 126.3,71.93 126.38,72.01 126.52,72.01 126.67,71.86 v2(126.67,71.72)
  BOTTOM w0.089: v2(126.67,71.72) 127,72.05 UC1.AN21
  BOTTOM w0.102: JDIMM2.186 191.05,25.09 191.24,25.28 191.24,26.53 191.04,26.74 190.91,26.74 v2(190.63,26.46)
DDR_B_DQS#7: length 66.8
  IN1 w0.091: v2(152.65,20.88) 152.8,21.03 153.13,21.03 153.35,21.26 153.35,25.48 152.53,26.3 152.53,28.95 152.11,29.37 152.11,36.41 142.19,46.33 142.19,48.17 136.16,54.2 136.16,58.91 131.47,63.6 131.47,65.7 130.28,66.89 130.28,67.15 128.19,69.25 128.19,71.82 128.28,71.91 128.5,71.91 128.58,71.83 v2(128.58,71.72)
  BOTTOM w0.089: v2(128.58,71.72) 128.9,72.05 UC1.AN18
  BOTTOM w0.102: JDIMM2.62 151.45,22.66 151.65,22.45 151.65,21.4 151.95,21.11 152.42,21.11 v2(152.65,20.88)
DDR_B_MA0: length 86.5
  IN4 w0.132: v2(164.72,26.14) 164.23,26.62 164.23,30.01 159.72,34.53 148.36,34.53 147.77,35.12 134.2,35.12 132.83,36.49 128.8,36.49 113.55,51.73 113.55,58.81 113.73,58.99 113.73,61.12 114.42,61.82 114.42,69.86 114.67,70.1 114.67,70.7 v2(114.29,71.07)
  BOTTOM w0.076: UC1.AP40 114.62,71.4 v2(114.29,71.07)
  BOTTOM w0.17: v2(164.72,26.14) 164.65,26.07 JDIMM2.98
DDR_B_MA1: length 87.5
  IN4 w0.132: v2(163.21,27.91) 163.21,27.79 163.43,27.58 163.63,27.58 163.78,27.73 163.78,29.92 159.56,34.14 148.2,34.14 147.68,34.66 134.12,34.66 132.74,36.03 128.43,36.03 112.93,51.53 112.93,60.55 113.43,61.05 113.43,64.52 114.07,65.16 114.07,70.22 v2(114.27,70.42)
  BOTTOM w0.076: v2(114.27,70.42) 114.59,70.75 UC1.AR40
  BOTTOM w0.17: JDIMM2.97 164.35,29.05 163.21,27.91 v2(163.21,27.91)
DDR_B_MA2: length 89.5
  IN4 w0.132: v2(163.21,26.38) 162.75,26.38 162.58,26.55 162.58,29.82 159.7,32.71 139.67,32.71 139.54,32.84 139.54,33.69 139.41,33.81 139.01,33.81 138.88,33.69 138.88,32.84 138.75,32.71 138.35,32.71 138.22,32.84 138.22,33.1 138.09,33.23 134.35,33.23 132.47,35.12 128.04,35.12 112.16,50.99 112.16,58.36 112.25,58.45 112.25,60.73 112.82,61.3 112.82,70.57 v2(113.38,71.12)
  BOTTOM w0.089: v2(113.38,71.12) 113.6,71.12 UC1.AP42
  BOTTOM w0.17: JDIMM2.96 164.05,24.83 163.81,25.07 163.81,26.19 163.62,26.38 v2(163.21,26.38)
DDR_B_MA3: length 87.7
  IN4 w0.132: v2(113.38,70.47) 113.19,70.28 113.19,61.32 112.55,60.68 112.55,51.27 128.24,35.57 132.55,35.57 133.93,34.2 140.94,34.2 141.06,34.07 141.06,33.22 141.19,33.09 141.92,33.09 142.05,33.22 142.05,34.14 142.17,34.27 142.84,34.27 142.97,34.14 142.97,33.22 143.09,33.09 145.65,33.09 145.77,33.22 145.77,34.14 145.9,34.27 146.98,34.27 147.11,34.14 147.11,33.22 147.24,33.09 159.96,33.09 163.21,29.84 v2(163.21,29.43)
  BOTTOM w0.076: v2(113.38,70.47) 113.65,70.75 UC1.AR42
  BOTTOM w0.17: v2(163.21,29.43) 163.75,29.97 JDIMM2.95
DDR_B_MA4: length 93.3
  IN4 w0.089: 111.93,60.88 112.49,61.44 112.49,69.48 v2(111.48,70.5)
  IN4 w0.132: v2(163.45,21.77) 162.84,22.38 162.84,24.13 162.54,24.43 161.6,24.43 161.47,24.56 161.47,25.12 161.6,25.25 162.6,25.25 162.73,25.37 162.73,25.81 162.6,25.93 162.3,25.93 162.13,26.1 162.13,29.63 159.44,32.32 137.72,32.32 137.2,32.84 133.36,32.84 131.54,34.66 127.85,34.66 111.77,50.73 111.77,58.36 111.93,58.52 111.93,60.88
  BOTTOM w0.076: v2(111.48,70.5) 111.72,70.75 UC1.AR45
  BOTTOM w0.17: v2(163.45,21.77) 162.85,22.37 JDIMM2.92
DDR_B_MA5: length 92
  IN4 w0.089: v2(111.48,71.15) 111.09,70.77 111.09,70.09 111.69,69.5 111.69,61.09
  IN4 w0.132: v2(161.64,29.43) 161.64,29.47 159.18,31.93 137.3,31.93 137.17,32.07 137.17,32.32 137.04,32.46 136.64,32.46 136.51,32.32 136.51,32.07 136.38,31.93 135.98,31.93 135.85,32.07 135.85,32.32 135.72,32.46 135.32,32.46 135.19,32.32 135.19,32.07 135.06,31.93 134.66,31.93 134.53,32.07 134.53,32.32 134.4,32.46 134,32.46 133.87,32.32 133.87,32.07 133.74,31.93 133.1,31.93 132.97,32.06 132.97,32.68 132.84,32.81 132.41,32.81 132.29,32.68 132.29,32.06 132.16,31.93 131.73,31.93 131.61,32.06 131.61,33.02 131.51,33.12 131.51,33.91 131.33,34.09 130.89,34.09 130.76,33.96 130.76,32.99 130.64,32.86 130.12,32.86 130,32.99 130,34.07 129.87,34.2 127.66,34.2 111.09,50.77 111.09,58.7 110.94,58.86 110.94,60.34 111.69,61.09
  BOTTOM w0.076: UC1.AP45 111.72,71.4 v2(111.48,71.15)
  BOTTOM w0.17: JDIMM2.91 162.55,29.3 162.42,29.18 161.77,29.18 161.64,29.3 v2(161.64,29.43)
DDR_B_MA6: length 97.9
  IN4 w0.089: v2(110.51,67.99) 110.09,67.57 110.09,67.05 110.26,66.88 110.67,66.88 111.28,66.27 111.28,61.92 110.31,60.94
  IN4 w0.132: 110.31,60.94 110.31,50.26 116.09,44.48 116.09,44.29 115.82,44.03 115.82,43.84 116.1,43.56 116.28,43.56 116.55,43.83 116.74,43.83 117.02,43.55 117.02,43.36 116.75,43.09 116.75,42.9 117.03,42.62 117.22,42.62 117.49,42.89 117.67,42.89 117.96,42.61 117.96,42.43 117.69,42.16 117.69,41.97 117.97,41.69 118.15,41.69 118.42,41.96 118.61,41.96 118.89,41.68 118.89,41.49 118.62,41.22 118.62,41.04 118.9,40.76 119.09,40.76 119.36,41.03 119.54,41.03 120.27,40.3 120.27,39.48 125.82,33.94 126.73,33.94 129.58,31.09 158.73,31.09 160.12,29.69 160.12,28.21 160.86,27.48 160.86,23.69 160.98,23.56 162.01,23.56 162.13,23.43 162.13,21.56 v2(163.45,20.25)
  BOTTOM w0.076: UC1.AW46 110.82,68.29 110.52,67.99 v2(110.51,67.99)
  BOTTOM w0.17: v2(163.45,20.25) 162.25,21.45 JDIMM2.90
DDR_B_MA7: length 96.2
  IN4 w0.089: 109.93,60.9 111.09,62.07 111.09,65.9 v2(110.52,66.47)
  IN4 w0.132: v2(161.65,21.77) 161.64,21.77 160.79,22.62 160.79,22.92 160.4,23.31 160.4,27.39 159.74,28.05 159.74,29.43 158.56,30.61 157.65,30.61 156.91,29.87 155.63,29.87 155.15,29.39 155.15,27.93 155.02,27.8 153.79,27.8 153.67,27.93 153.67,30.25 153.54,30.38 151.76,30.38 151.63,30.25 151.63,27.93 151.51,27.8 134.98,27.8 132.08,30.7 128.4,30.7 115.22,43.89 115.22,44.7 109.92,50 109.92,53.52 109.93,53.52 109.93,60.9
  BOTTOM w0.076: UC1.AY46 110.92,66.87 v2(110.52,66.47)
  BOTTOM w0.17: JDIMM2.86 161.05,22.37 v2(161.65,21.77)
DDR_B_MA8: length 95.9
  IN4 w0.089: 110.71,60.76 111.5,61.55 111.5,66.84 111.05,67.29 v2(110.51,67.29)
  IN4 w0.132: v2(161.64,27.91) 161.64,28.1 161.54,28.2 160.68,28.2 160.58,28.3 160.58,28.76 160.68,28.86 161.05,28.86 161.15,28.96 161.15,29.42 161.05,29.52 160.61,29.52 160.51,29.62 160.51,29.95 158.92,31.55 131.35,31.55 131.22,31.68 131.22,32.35 131.09,32.48 130.53,32.48 130.41,32.35 130.41,31.68 130.31,31.58 129.71,31.58 129.61,31.68 129.61,33.69 129.48,33.81 128.92,33.81 128.79,33.69 128.79,33.18 128.67,33.06 128.16,33.06 128.03,33.18 128.03,33.69 127.91,33.81 127.4,33.81 126.62,34.6 126.38,34.6 126.13,34.35 125.95,34.35 125.61,34.7 125.61,34.88 125.93,35.2 125.93,35.38 125.62,35.7 125.44,35.7 125.11,35.37 124.93,35.37 124.64,35.66 124.64,35.84 124.97,36.17 124.97,36.34 124.68,36.63 124.5,36.63 124.18,36.31 123.99,36.31 123.71,36.59 123.71,36.78 124.04,37.1 124.04,37.28 123.75,37.57 123.57,37.57 123.25,37.24 123.06,37.24 122.78,37.52 122.78,37.71 123.1,38.03 123.1,38.21 122.81,38.5 122.64,38.5 122.31,38.18 122.13,38.18 121.84,38.46 121.84,38.64 122.17,38.97 122.17,39.15 121.88,39.43 121.7,39.43 121.37,39.11 121.19,39.11 120.91,39.4 120.91,39.57 121.18,39.85 121.18,40.03 110.71,50.51 110.71,60.76
  BOTTOM w0.076: v2(110.51,67.29) 110.16,67.64 UC1.AY47
  BOTTOM w0.17: v2(161.64,27.91) 161.2,28.35 161.2,29.61 161.95,30.36 161.95,32.14 JDIMM2.89
DDR_B_MA9: length 98.1
  IN4 w0.089: 107.35,60.43 108.71,61.79 108.71,65.16 109.86,66.31 109.86,69.03 110.12,69.29 v2(110.52,69.29)
  IN4 w0.132: v2(158.54,26.25) 157.49,26.25 157.33,26.09 157.33,25.61 156.91,25.19 156.49,25.19 156.21,25.47 155.1,25.47 154.96,25.33 154.96,25.05 154.77,24.85 154.09,24.85 153.97,24.98 153.97,25.34 153.84,25.47 153.29,25.47 153.16,25.34 153.16,25.01 153.01,24.85 152.29,24.85 152.17,24.98 152.17,25.34 152.04,25.47 151.46,25.47 151.33,25.34 151.33,24.98 151.21,24.85 150.46,24.85 150.35,24.97 150.35,25.33 150.21,25.47 149.69,25.47 149.58,25.37 149.58,25.01 149.43,24.85 148.72,24.85 148.57,25.01 148.57,25.34 148.44,25.47 148.06,25.47 147.95,25.36 147.95,25 147.8,24.85 138.47,24.85 138.37,24.96 138.37,25.34 138.24,25.47 137.66,25.47 137.53,25.34 137.53,24.97 137.42,24.85 136.69,24.85 136.57,24.98 136.57,25.34 136.44,25.47 135.86,25.47 135.73,25.34 135.73,24.98 135.61,24.85 133.17,24.85 132.97,25.05 132.97,25.95 132.75,26.17 129.64,26.17 109.64,46.16 109.64,47.18 107.35,49.47 107.35,60.43
  BOTTOM w0.089: UC1.AU46 110.67,69.29 v2(110.52,69.29)
  BOTTOM w0.17: v2(158.54,26.25) 159.11,26.81 159.11,29.43 160.75,31.07 JDIMM2.85
DDR_B_MA10: length 102.6
  IN4 w0.132: v2(116.72,73.83) 116.44,73.83 116.25,73.63 116.25,61.83 115.89,61.47 115.89,52.6 129.55,38.94 142.07,38.94 142.19,38.81 142.19,37.43 142.32,37.3 142.83,37.3 142.98,37.45 142.98,38.79 143.13,38.94 143.63,38.94 143.75,38.81 143.75,37.43 143.88,37.3 144.29,37.3 144.41,37.43 144.41,38.81 144.55,38.94 144.94,38.94 145.07,38.81 145.07,37.43 145.21,37.3 145.6,37.3 145.73,37.43 145.73,38.81 145.86,38.94 146.27,38.94 146.4,38.81 146.4,37.43 146.52,37.3 146.93,37.3 147.06,37.43 147.06,38.81 147.19,38.94 147.58,38.94 147.72,38.81 147.72,37.43 147.84,37.3 148.25,37.3 148.38,37.43 148.38,38.81 148.51,38.94 148.9,38.94 149.04,38.81 149.04,36.94 149.27,36.71 160.95,36.71 162.38,35.29 162.56,35.29 162.97,35.69 163.15,35.69 163.43,35.41 163.43,35.22 163.03,34.82 163.03,34.64 163.31,34.35 163.49,34.35 163.9,34.75 164.09,34.75 165.9,32.94 165.9,32.28 167.32,30.87 v2(167.32,30.57)
  BOTTOM w0.076: v2(116.72,73.83) 116.89,74 UC1.AK36
  BOTTOM w0.17: JDIMM2.107 167.35,30.84 167.32,30.8 v2(167.32,30.57)
DDR_B_MA11: length 98.8
  IN4 w0.089: v2(110.52,65.82) 110.9,65.44 110.9,62.84 109.79,61.73 109.79,61.22 109.71,61.14
  IN4 w0.132: v2(161.65,20.25) 160.33,21.56 160.33,22.73 159.94,23.13 159.94,27.3 159.35,27.89 159.35,29.17 158.37,30.15 157.84,30.15 157.1,29.42 155.82,29.42 155.6,29.2 155.6,27.47 155.48,27.35 153.34,27.35 153.21,27.47 153.21,28.44 153.08,28.57 152.22,28.57 152.09,28.44 152.09,27.47 151.96,27.35 134.89,27.35 131.92,30.32 127.94,30.32 114.83,43.43 114.83,44.44 109.54,49.74 109.54,53.72 109.54,53.72 109.54,60.97 109.71,61.14
  BOTTOM w0.076: UC1.AV47 109.8,68.64 109.8,67.45 110.12,67.13 110.12,66.23 v2(110.52,65.82)
  BOTTOM w0.17: JDIMM2.84 160.45,21.45 v2(161.65,20.25)
DDR_B_MA12: length 95
  IN4 w0.089: 106.58,60.36 108.27,62.05 108.27,65.26 109.39,66.38 109.39,67.47 v2(108.93,67.93)
  IN4 w0.132: v2(158.54,29.3) 158.97,28.88 158.97,27.73 159.48,27.21 159.48,25.36 158.06,23.94 130.57,23.94 106.58,47.93 106.58,60.36
  BOTTOM w0.076: UC1.AU47 110.04,69.3 109.64,68.89 109.64,68.16 109.43,67.96 108.96,67.96 v2(108.93,67.93)
  BOTTOM w0.17: v2(158.54,29.3) 158.54,29.46 160.15,31.07 JDIMM2.83
DDR_B_MA13: length 102.2
  IN4 w0.089: v2(118.63,73.74) 118.11,74.25 118.11,74.68 118.21,74.78 119,74.78 119.1,74.68 119.1,73.37 119.2,73.27 119.74,73.27 119.84,73.17 119.84,72.9 119.74,72.8 119.32,72.8 119.22,72.7 119.22,64.52
  IN4 w0.132: 119.22,64.52 119.22,61.79 118.56,61.13 118.56,53.88 129.27,43.17 131.27,43.17 131.72,42.72 131.72,42.53 131.17,41.98 131.17,41.79 131.45,41.51 131.64,41.51 132.19,42.06 132.38,42.06 133.18,41.25 155.82,41.25 156.89,40.18 165.1,40.18 169.66,35.61 169.66,35.31 168.98,34.63 168.98,32.48 170.62,30.84 170.62,29.25 171.12,28.75 171.45,28.75 171.58,28.62 171.58,27.14 171.45,27.02 170.97,27.02 170.84,27.14 170.84,27.4 170.71,27.53 v2(170.2,27.53)
  BOTTOM w0.076: UC1.AK33 118.89,74 v2(118.63,73.74)
  BOTTOM w0.17: v2(170.2,27.53) 170.76,28.08 170.76,30.92 170.95,31.11 JDIMM2.119
DDR_B_MA14: length 98.6
  IN4 w0.089: 106.19,60.36 108.08,62.24 108.08,65.33 108.68,65.93 108.68,66.77 108.52,66.94 108.52,69.37 108.98,69.84 109.96,69.84 110.52,70.4 v2(110.52,70.55)
  IN4 w0.132: 106.19,60.36 106.19,47.67 130.38,23.48 146.86,23.48 146.99,23.36 146.99,21.86 147.12,21.73 147.98,21.73 148.11,21.86 148.11,23.36 148.24,23.48 159.3,23.48 159.43,23.36 159.43,22.75 159.3,22.62 158.6,22.62 158.47,22.5 158.47,21.9 158.6,21.77 v2(159.85,21.77)
  BOTTOM w0.076: v2(110.52,70.55) 110.82,70.55 UC1.AR46
  BOTTOM w0.17: JDIMM2.80 159.25,22.37 v2(159.85,21.77)
DDR_B_MA15: length 99
  IN4 w0.089: v2(110.52,71.2) 110.09,70.77 110.09,70.35 109.77,70.03 108.91,70.03 108.33,69.45 108.33,66.86 108.49,66.69 108.49,66.01 107.87,65.39 107.87,62.54 105.81,60.48
  IN4 w0.132: v2(158.05,21.77) 158.05,21.54 157.92,21.41 156.6,21.41 156.47,21.54 156.47,22.15 156.54,22.23 157.45,22.23 157.63,22.41 157.63,22.97 157.5,23.1 148.69,23.1 148.57,22.97 148.57,21.4 148.44,21.28 146.66,21.28 146.53,21.4 146.53,22.9 146.41,23.03 130.19,23.03 105.81,47.41 105.81,60.48
  BOTTOM w0.076: v2(110.52,71.2) 110.82,71.2 UC1.AP46
  BOTTOM w0.17: v2(158.05,21.77) 158.65,22.37 JDIMM2.78
DDR_B_RAS#: length 101.6
  IN4 w0.089: v2(117.7,72.37) 118.08,71.99 118.08,70.16 117.82,69.9 117.82,62.22
  IN4 w0.102: 117.19,61.59 117.82,62.22
  IN4 w0.132: v2(167.56,27.66) 168.08,27.66 168.22,27.8 168.22,28.64 169.09,29.51 169.09,30.73 167.82,32 167.82,34.38 164.34,37.87 160.05,37.87 159.92,38 159.92,38.33 159.78,38.46 159.39,38.46 159.26,38.33 159.26,38 159.12,37.87 158.73,37.87 158.6,38 158.6,38.33 158.46,38.46 158.07,38.46 157.93,38.33 157.93,38 157.8,37.87 157.41,37.87 157.27,38 157.27,38.33 157.14,38.46 156.75,38.46 156.61,38.33 156.61,38 156.48,37.87 155.84,37.87 155.71,38 155.71,39.35 155.59,39.48 155.18,39.48 155.05,39.35 155.05,38 154.93,37.87 154.52,37.87 154.39,38 154.39,39.97 154.26,40.1 153.76,40.1 153.64,39.97 153.64,38 153.51,37.87 152.99,37.87 152.86,38 152.86,39.97 152.73,40.1 130.41,40.1 117.19,53.31 117.19,53.72 117.19,53.72 117.19,61.59
  BOTTOM w0.076: UC1.AM35 118.02,72.7 v2(117.7,72.37)
  BOTTOM w0.17: JDIMM2.110 168.25,26.97 v2(167.56,27.66)
DDR_B_WE#: length 101.2
  IN4 w0.089: v2(117.67,73.67) 118.27,73.08 118.27,70.18 118.78,69.68 118.78,66.36 118.66,66.24 118.35,66.24 118.01,65.91 118.01,61.95
  IN4 w0.102: 117.65,61.59 118.01,61.95
  IN4 w0.132: 117.65,61.59 117.65,53.5 130.67,40.48 155.13,40.48 156.76,38.84 159.94,38.84 160.53,38.25 164.5,38.25 168.21,34.54 168.21,32.16 169.55,30.82 169.55,29.42 168.61,28.48 168.61,24.21 168.74,24.08 169.36,24.08 169.49,24.21 169.49,28.26 170.2,28.97 v2(170.2,29.05)
  BOTTOM w0.076: v2(117.67,73.67) 118,74 UC1.AK35
  BOTTOM w0.17: JDIMM2.113 169.15,30.1 v2(170.2,29.05)
DDR_CKE0_DIMMA: length 61.3
  IN1 w0.132: v2(112.1,69.29) 112.52,68.86 112.52,64.09 107.22,58.78 107.22,58.13 106.41,57.32 106.41,57.13 106.92,56.62 106.92,56.44 106.63,56.16 106.45,56.16 105.94,56.66 105.34,56.66 99.23,50.56 98.15,50.56 93.03,45.45 91.05,45.45 80.04,34.43 80.04,32.01 80.17,31.87 80.66,31.87 80.79,31.74 80.79,31.48 80.66,31.35 80.17,31.35 80.04,31.21 80.04,30.07 80.16,29.95 80.33,29.95 80.46,30.07 80.46,30.47 80.56,30.57 v2(80.79,30.57)
  BOTTOM w0.089: v2(112.1,69.29) 112.4,69.59 UC1.AU43
  BOTTOM w0.17: v2(80.79,30.57) 81.15,30.93 81.15,32.14 JDIMM1.73
DDR_CKE1_DIMMA: length 60.6
  IN1 w0.132: v2(81.45,25.5) 79.65,27.3 79.65,34.59 90.95,45.89 92.93,45.89 97.99,50.95 99.07,50.95 111.45,63.32 111.45,64.21 111.69,64.46 111.69,67.6 v2(112.08,67.99)
  BOTTOM w0.076: v2(112.08,67.99) 112.1,67.99 112.4,68.29 UC1.AW43
  BOTTOM w0.17: JDIMM1.74 v2(81.45,25.5)
DDR_CKE2_DIMMB: length 89.9
  IN4 w0.089: 109.45,61.34 109.57,61.46 109.57,64.22 v2(110.52,65.17)
  IN4 w0.132: v2(156.8,28.05) 156.24,27.49 156.24,27.21 155.74,26.71 134.63,26.71 131.65,29.68 127.68,29.68 114.19,43.16 113.9,43.46 113.9,43.81 114.14,44.05 114.14,44.23 113.8,44.57 113.62,44.57 113.29,44.24 113.11,44.24 112.82,44.53 112.82,44.71 113.15,45.04 113.15,45.22 112.86,45.51 112.68,45.51 112.36,45.19 112.17,45.19 111.89,45.47 111.89,45.65 112.21,45.97 112.21,46.16 111.93,46.44 111.74,46.44 111.42,46.12 111.24,46.12 110.96,46.4 110.96,46.59 111.28,46.91 111.28,47.09 108.38,49.99 108.38,51.59 108.51,51.73 108.76,51.73 108.9,51.86 108.9,52.25 108.76,52.39 108.51,52.39 108.38,52.52 108.38,52.91 108.51,53.05 108.76,53.05 108.9,53.18 108.9,53.57 108.76,53.71 108.51,53.71 108.38,53.84 108.38,54.23 108.51,54.37 108.76,54.37 108.9,54.5 108.9,54.89 108.76,55.03 108.51,55.03 108.38,55.16 108.38,55.56 108.51,55.69 108.76,55.69 108.9,55.82 108.9,56.22 108.76,56.35 108.51,56.35 108.38,56.48 108.38,56.88 108.51,57.01 108.76,57.01 108.9,57.14 108.9,57.54 108.76,57.67 108.51,57.67 108.38,57.8 108.38,60.27 109.45,61.34
  BOTTOM w0.076: UC1.AY49 109.34,66.35 v2(110.52,65.17)
  BOTTOM w0.17: JDIMM2.73 157.15,29.52 157.24,29.43 157.24,28.49 v2(156.8,28.05)
DDR_CKE3_DIMMB: length 90.8
  IN4 w0.089: 109.09,61.53 v2(109.09,64.22)
  IN4 w0.132: 109.09,61.53 107.99,60.44 107.99,49.73 110.28,47.44 110.28,46.53 127.52,29.29 128.81,29.29 128.94,29.17 128.94,27.8 129.06,27.68 129.45,27.68 129.58,27.8 129.58,29.17 129.7,29.29 130.09,29.29 130.22,29.17 130.22,27.01 130.34,26.88 133.74,26.88 133.87,26.75 133.87,25.62 134,25.49 134.39,25.49 134.51,25.62 134.51,26.14 134.64,26.27 156.54,26.27 v2(156.8,26.52)
  BOTTOM w0.076: v2(109.09,64.22) 108.5,64.81 108.5,66.64 108.14,67 108.14,68.03 108.06,68.18 108.06,68.39 108.09,68.44 108.13,68.53 108.14,68.54 108.14,69.3 UC1.AU50
  BOTTOM w0.17: JDIMM2.74 157.45,24.92 157.1,25.27 155.86,25.27 155.73,25.4 155.73,26.39 155.86,26.52 v2(156.8,26.52)
DDR_CS0_DIMMA#: length 61.9
  IN1 w0.089: 119.91,61.1 119.91,69.43 119.12,70.21 119.12,70.66 v2(118.65,71.14)
  IN1 w0.132: v2(94.38,25.5) 95.41,26.53 95.41,30.18 98.38,33.15 101.21,33.15 108.82,40.76 110.23,40.76 118.41,48.94 118.41,51.46 119.91,52.96 119.91,61.1 119.91,61.1
  BOTTOM w0.089: v2(118.65,71.14) 118.91,71.4 UC1.AP33
  BOTTOM w0.17: JDIMM1.114 93.45,24.79 94.15,25.5 v2(94.38,25.5)
DDR_CS1_DIMMA#: length 63.4
  IN1 w0.089: v2(119.6,70.42) 120.12,69.91 120.12,60.13 120.35,59.9 120.35,59.74
  IN1 w0.132: 120.35,59.74 120.35,52.86 118.85,51.35 118.85,48.83 107.97,37.96 107.78,37.96 107.26,38.48 107.08,38.48 106.8,38.19 106.8,38.01 107.32,37.49 107.32,37.3 107.04,37.02 106.85,37.02 106.33,37.54 106.15,37.54 105.86,37.25 105.86,37.07 106.38,36.55 106.38,36.37 106.1,36.09 105.91,36.09 105.4,36.61 105.22,36.61 104.93,36.32 104.93,36.14 105.45,35.62 105.45,35.43 105.17,35.15 104.98,35.15 104.46,35.67 104.28,35.67 103.99,35.39 103.99,35.21 104.44,34.76 104.44,34.58 104.15,34.29 103.97,34.29 103.6,34.66 103.27,34.66 101.28,32.68 98.45,32.68 95.87,30.1 v2(95.87,29.81)
  BOTTOM w0.076: v2(119.6,70.42) 119.93,70.75 UC1.AR32
  BOTTOM w0.17: v2(95.87,29.81) 95.87,30.87 95.55,31.19 95.55,32.14 JDIMM1.121
DDR_CS2_DIMMB#: length 97.1
  IN4 w0.089: v2(119.6,72.37) 119.98,71.99 119.98,70.22 119.48,69.72 119.48,64.93
  IN4 w0.132: v2(170.2,26) 170.2,24.68 170.33,24.55 172.09,24.55 172.22,24.68 172.22,29.26 172.09,29.39 171.39,29.39 171.26,29.52 171.26,31.11 169.62,32.74 169.62,34.36 170.48,35.22 170.48,35.7 165.36,40.82 157.16,40.82 156.08,41.89 133.45,41.89 131.54,43.81 129.54,43.81 119.2,54.15 119.2,61.32 119.67,61.79 119.67,64.74 119.48,64.93
  BOTTOM w0.076: v2(119.6,72.37) 119.93,72.7 UC1.AM32
  BOTTOM w0.17: JDIMM2.114 169.45,25.44 170.01,26 v2(170.2,26)
DDR_CS3_DIMMB#: length 95.4
  IN4 w0.089: v2(119.58,73.67) 119.58,73.84 119.71,73.97 120.05,73.97 120.17,73.84 120.17,70.14 119.67,69.64 119.67,65.09 120.04,64.72
  IN4 w0.132: 120.04,64.72 120.04,61.75 119.59,61.3 119.59,54.31 129.7,44.19 131.7,44.19 133.61,42.28 156.24,42.28 157.32,41.2 165.52,41.2 170.86,35.86 170.86,35.03 170.99,34.91 171.82,34.91 171.95,34.78 171.95,34.37 171.82,34.24 170.59,34.24 170.47,34.11 170.47,33.7 170.59,33.57 171.82,33.57 171.95,33.45 171.95,33.06 171.82,32.93 170.64,32.93 170.52,32.81 170.52,32.4 170.64,32.27 171.52,32.27 171.65,32.14 171.65,30.34 171.77,30.21 172.13,30.21 172.25,30.34 v2(172.25,30.57)
  BOTTOM w0.076: v2(119.58,73.67) 119.9,74 UC1.AK32
  BOTTOM w0.17: JDIMM2.121 171.55,30.42 171.68,30.29 172.13,30.29 172.25,30.42 v2(172.25,30.57)
DDR_PG_CTRL: length 128.1
  TOP w0.102: UD1.2 v2(95.95,14.29)
  IN1 w0.084: v2(95.95,14.29) 95.95,19.35 95.39,19.9 95.39,20.69 94.33,21.76 94.33,22.16 93.41,23.08 57.12,23.08 56.77,22.74 v2(56.77,22.41)
  IN3 w0.122: v2(53.79,33.65) 53.79,25.39 v2(56.77,22.41)
  IN4 w0.084: v2(82.3,62.16) 80.99,62.16 70.45,51.62 70.45,43.18 62.95,35.68 55.82,35.68 v2(53.79,33.65)
  BOTTOM w0.076: UC1.AV61 101.43,69.29 100.46,69.29 100.43,69.26 99.6,69.26
  BOTTOM w0.089: 99.6,69.26 96.75,66.41 95.66,66.41
  BOTTOM w0.102: 95.66,66.41 v1(91.89,66.41) 91.51,66.41 89.51,64.41 84.55,64.41 v2(82.3,62.16)
DDR_XDP_WAN_SMBCLK: length 355.5
  TOP w0.102: UN1.4 223.9,116.86 RN4.2 224.42,118.46 v2(223.65,118.46) ; v2(70.81,40.38) 70.45,40.38 70.27,40.57 70.27,44.64 69.79,45.13 69.25,45.13 69.1,45.27 69.1,45.42 69.25,45.57 JXDP1.53
  IN1 w0.084: v2(158.88,69.27) 159.04,69.43 159.62,69.43 161.4,67.65 161.4,66.76 163.13,65.03 163.13,63.05 164.38,61.8 165.75,61.8 166.44,61.11 166.81,61.11 169.51,58.41 171.62,58.41 172.58,57.45 189.44,57.45 189.8,57.09 191.97,57.09 192.24,57.35 194.61,57.35 196.9,55.07 204.89,55.07 210.19,49.76 214.23,49.76 214.85,49.14 218.06,49.14 219.3,50.38 220.31,50.38 v2(220.51,50.18) 220.71,50.38 221.1,50.38 221.75,49.72 221.75,42.38 221.54,42.16 217.18,42.16 208.31,33.28 205.03,33.28 203.53,31.79 202.78,31.79 201.52,30.52 201.52,27.9 198.85,25.23 195.77,25.23 195.62,25.38 195.62,25.63 v2(195.8,25.81)
  IN4 w0.084: v2(220.51,50.18) 220.11,50.58 220.11,52.14 220.61,52.64 220.61,55.37 221.25,56.01 221.25,64.38 222.2,65.33 222.2,99.87 226.73,104.4 226.73,115.29 226.25,115.78 226.25,117.04 224.31,118.98 223.65,118.98 223.52,118.85 223.52,118.59 v2(223.65,118.46) ; v2(195.8,25.81) 195.62,25.63 195.62,24.53 195.08,23.99 191.01,23.99 188.09,21.07 165.92,21.07 164.37,19.53 161.18,19.53 160.75,19.96 156.57,19.96 156.14,19.53 145.76,19.53 145,20.29 130.97,20.29 124.85,26.41 120.92,26.41 v2(120.69,26.19) 120.47,26.41 120.28,26.41 117.82,23.95 111.11,23.95 110.65,23.49 98.34,23.49 95.1,26.73 94.25,26.73 93.77,27.21 93.77,30.98 91.8,32.94 74.66,32.94 72.02,35.59 72.02,40.19 71.1,41.11 70.84,41.11 70.39,40.66 70.39,40.5 70.5,40.38 v2(70.81,40.38)
  BOTTOM w0.102: v2(158.88,69.27) 158.88,68.83 158.48,68.43 QC1.1 ; JDIMM2.202 195.85,25.09 195.6,25.34 195.6,25.61 v2(195.8,25.81) ; v2(120.69,26.19) 120.47,26.41 119.89,26.41 119.66,26.18 119.66,25.28 119.85,25.09 119.85,23.94 JDIMM1.202
DDR_XDP_WAN_SMBDAT: length 356.9
  TOP w0.102: RN3.2 224.73,119.07 223.67,119.07 v2(223.07,118.46) 222.93,118.59 222.55,118.59 222.38,118.42 UN1.6 ; JXDP1.51 68.75,45.57 68.9,45.42 68.9,45.19 69.17,44.92 69.7,44.92 70.07,44.56 70.07,40.48 70.4,40.15 v2(70.4,39.97)
  IN1 w0.084: v2(195.21,25.81) 195.43,25.59 195.43,25.31 195.69,25.05 198.93,25.05 201.7,27.82 201.7,30.45 202.86,31.6 203.61,31.6 205.11,33.1 208.38,33.1 217.26,41.98 221.62,41.98 221.94,42.3 221.94,49.8 221.17,50.57 220.71,50.57 v2(220.51,50.77) 220.31,50.57 219.23,50.57 217.98,49.33 214.93,49.33 214.3,49.95 210.27,49.95 204.97,55.25 196.97,55.25 194.68,57.54 192.16,57.54 191.9,57.27 189.88,57.27 189.42,57.72 172.62,57.72 171.7,58.64 169.54,58.64 166.88,61.3 166.52,61.3 165.83,61.98 164.46,61.98 163.31,63.13 163.31,65.17 161.64,66.84 161.64,67.73 159.76,69.61 159.19,69.61 v2(158.89,69.91)
  IN4 w0.084: v2(223.07,118.46) 223.34,118.73 223.34,118.93 223.57,119.16 224.39,119.16 226.43,117.12 226.43,115.85 226.91,115.37 226.91,104.32 222.39,99.79 222.39,65.25 221.44,64.3 221.44,55.93 220.79,55.29 220.79,52.56 220.3,52.07 220.3,50.98 v2(220.51,50.77) ; v2(70.4,39.97) 70.4,40.22 70.2,40.42 70.2,40.73 70.76,41.29 71.18,41.29 72.2,40.27 72.2,35.67 74.74,33.13 91.88,33.13 93.95,31.06 93.95,27.29 94.33,26.91 95.18,26.91 98.42,23.67 110.58,23.67 111.04,24.14 117.74,24.14 120.2,26.6 120.47,26.6 v2(120.69,26.83) 120.92,26.6 124.92,26.6 131.05,20.48 145.07,20.48 145.84,19.71 156.06,19.71 156.49,20.15 160.82,20.15 161.25,19.71 164.29,19.71 165.84,21.26 188.01,21.26 190.93,24.18 195.01,24.18 195.44,24.61 195.44,25.59 v2(195.21,25.81)
  BOTTOM w0.102: JDIMM2.200 195.25,25.09 195.4,25.23 195.4,25.63 v2(195.21,25.81) ; QC1.4 159.43,69.73 159.24,69.92 158.91,69.92 v2(158.89,69.91) ; v2(120.69,26.83) 120.49,26.62 119.8,26.62 119.44,26.26 119.44,25.2 119.25,25.01 119.25,23.94 JDIMM1.200
DGPU_PWROK: length 10.1
  BOTTOM w0.076: 143.99,81.4 143.61,81.78 v1(142.57,81.78) 142.11,81.78 141.57,82.32 139.26,82.32 138.94,82 138.63,82 138.46,81.84 137.68,81.84 137.64,81.88 137.45,81.88 137.07,82.26 UC1.P4
  BOTTOM w0.089: RPC6.6 144.36,81.03 143.99,81.4
DH_1.35V:
  vias: v1(81.41,18.9) v2(79.88,17.55) v2(80.46,17.46)
DIMM_DET: length 12.4
  TOP w0.089: RC303.1 RC302.2
  TOP w0.102: RC303.1 144.82,84.34 140.29,84.34 v1(139.33,83.39) 138.79,82.85 138.59,82.85 138.03,82.29 136.61,82.29 v2(136.4,82.49)
  BOTTOM w0.076: UC1.U4 136.54,81.08 136.54,82.35 v2(136.4,82.49)
DIS_BAT_PROCHOT#: length 256.8
  TOP w0.102: UE1.B51 187.46,105.59 v2(187.87,106) ; v2(4.66,37.43) v1(4.66,37.94)
  TOP w0.254: v2(4.66,37.43) PR812.1
  IN2 w0.122: v2(44.58,38.22) 45.15,38.79 46.52,38.79 47.71,37.59 51.48,37.59 52.49,38.6 57.55,38.6 58.67,37.48 71.01,37.48 79.36,45.84 135.57,45.84 139.64,49.91 157.13,49.91 160.74,46.29 170.19,46.29 170.71,46.81 170.71,62.08 170.41,62.38 168.48,62.38 167.57,63.29 167.57,65.25 167.12,65.7 167.12,66.67 167.97,67.52 167.97,68.76 168.57,69.36 168.57,70.66 172.55,74.63 172.55,75.97 173.72,77.14 176.5,77.14 177.7,75.94 181.31,75.94 184.44,79.08 184.44,83.26 184.12,83.59 184.12,87.99 186.18,90.06 186.18,91.85 186.53,92.2 186.53,93.1 187.54,94.1 187.54,105.67 v2(187.87,106)
  IN3 w0.122: v2(44.58,38.22) 44.14,38.66 43.69,38.66 43.06,38.03 40.64,38.03 39.64,37.03 35.59,37.03 34.49,35.93 30.34,35.93 29.12,37.15 25.49,37.15 24.9,37.75 13.75,37.75 12.82,36.81 5.28,36.81 v2(4.66,37.43)
DISP_ON: length 11.2
  TOP w0.102: DV2.1 103.51,113.71 RV2.1 v1(101.04,113.71) 99.49,113.71 99.25,113.47 v2(95.76,113.47)
  BOTTOM w0.102: JEDP1.22 95.97,115.5 95.76,115.29 v2(95.76,113.47)
DK_AC_OFF: length 8.1
  TOP w0.254: PU800.25 19.91,41.8 v1(19.14,42.57) 18.76,42.94 16.94,42.94 16.69,43.2 PD815.3
DK_AC_OFF_EN: length 2.7
  TOP w0.254: PU800.22 21.41,39.2 v1(21.89,39.68) 22.57,40.36 22.57,40.59 PR850.1
DK_CSS_GC: length 44.7
  TOP w0.102: v2(55.4,44.45) v1(54.84,44.45)
  TOP w0.254: v2(23.51,31.98) 24.34,31.98 24.96,32.6 24.96,33.5 24.42,34.04 PU800.11 ; PR709.1 v2(55.4,44.45)
  IN3 w0.254: v2(55.4,44.45) 52.92,44.45 51.79,43.32 51.79,39.17 49.47,36.84 44.12,36.84 43.23,35.95 36.04,35.95 34.92,34.84 29.96,34.84 27.1,31.98 v2(23.51,31.98)
DK_PWRBAR: length 2.3
  TOP w0.254: PU800.33 16.23,35.04 PR832.1
DL_1.35V: length 12.8
  TOP w0.102: v2(78.64,19.22) v1(79.3,19.22)
  IN3 w1.016: 78.88,20.2 79.99,21.3 90.55,21.3
  vias: v2(78.64,18.6) v2(91.48,21.24) v2(92.09,21.25)
DMIC0: length 186.2
  TOP w0.203: v2(204.23,74.74) 204.23,74.7 204.68,74.26 UA1.47
  IN1 w0.084: v2(204.23,74.74) 204.85,75.37 204.85,75.95 205.3,76.39 208.71,76.39 210.11,77.79 210.12,77.79 210.86,78.53 215.18,78.53 v2(215.53,78.88)
  IN2 w0.122: v2(103.55,117.36) 104.7,118.51 104.7,123.35 v2(105.82,124.46) 106.76,124.46 109.03,122.19 122.51,122.19 122.77,121.92 125.62,121.92 126.53,122.84 128.09,122.84 129.62,124.36 129.62,126.1 130.21,126.69 132.96,126.69 133.27,127 137.76,127 138.42,127.66 147.48,127.66 149.71,129.89 150.14,129.89 151.79,131.54 151.79,133.68 152.2,134.08 155.53,134.08 156.29,133.32 163.84,133.32 165.77,131.39 171.54,131.39 175.11,127.82 175.11,127.26 175.9,126.47 177.32,126.47 180.4,123.39 191.44,123.39 193.8,121.03 196.64,121.03 201.43,116.23 201.43,104.57 202.82,103.18 205.63,103.18 209.91,98.9 213.72,98.9 215.78,96.84 215.78,91.48 216.99,90.27 216.99,87.24 216.23,86.49 216.23,79.99 215.53,79.29 v2(215.53,78.88)
  BOTTOM w0.102: v2(105.82,124.46) 105.82,125.01 106.15,125.34 v1(106.24,125.34) CA6.1 ; JEDP1.7 103.47,116.18 103.47,117.28 v2(103.55,117.36)
DMIC_CLK: length 194.1
  TOP w0.102: v2(201.25,75.14) 200.78,74.67 RA14.2 CA30.1 ; v2(105.21,124.47) v1(105.21,125.83)
  IN1 w0.084: v2(201.25,75.14) 201.42,75.31 203.41,75.31 204.73,76.63 208.47,76.63 210.78,78.95 211.56,78.95 212.05,79.44 215.67,79.44 v2(216.23,78.88)
  IN2 w0.122: v2(216.23,78.88) 216.23,79.62 216.48,79.87 216.48,86.39 217.23,87.14 217.23,90.37 216.42,91.19 216.42,91.21 216.03,91.6 216.03,96.94 213.82,99.15 210.01,99.15 205.73,103.43 202.92,103.43 201.68,104.68 201.68,116.34 196.74,121.28 193.91,121.28 191.55,123.64 180.51,123.64 177.37,126.77 175.94,126.77 175.36,127.36 175.36,127.92 171.64,131.64 165.88,131.64 163.95,133.57 156.39,133.57 155.63,134.33 152.1,134.33 151.54,133.78 151.54,131.64 150.04,130.14 149.61,130.14 147.37,127.91 138.32,127.91 137.66,127.24 133.16,127.24 132.86,126.94 130.1,126.94 129.36,126.21 129.36,124.47 127.99,123.09 126.43,123.09 125.52,122.17 122.88,122.17 122.61,122.44 109.14,122.44 106.65,124.92 105.65,124.92 105.21,124.48 v2(105.21,124.47) 104.21,123.46 104.21,118.96 v2(102.65,117.4)
  BOTTOM w0.102: v2(102.65,117.4) 102.47,117.22 JEDP1.9 ; CA5.1 106.97,126.55 105.21,124.79 v2(105.21,124.47)
DMIC_CLK_L: length 4.4
  TOP w0.102: UA1.2 202.97,72.57 202.81,72.74 202.81,73.85 202.45,74.21 202.02,74.21 RA14.1 202.01,74.86 v1(202.71,74.86)
DOCK_AC_OFF: length 227.7
  TOP w0.102: v2(52.83,47.93) v1(52.07,47.93)
  TOP w0.254: PD815.1 16.87,42.33 v2(16.55,42.01) 15.85,42.01 15.62,42.24 PR844.1
  IN2 w0.254: v2(52.83,47.93) 52.53,47.63 44.59,47.63 43.14,46.18 43.14,44.25 42.52,43.63 42.06,43.63 40.85,42.41 40.13,42.41 39.8,42.08 38.94,42.08 38.65,42.37 35.51,42.37 35.13,42.75 34.04,42.75 33.02,41.74 31.44,41.74 31.09,42.08 22.48,42.08 21.86,42.7 20.5,42.7 19.81,42.01 v2(16.55,42.01)
  IN3 w0.122: v2(141.66,135.53) 141.42,135.28 141.42,128.96 140.07,127.61 133.71,127.61 132.49,128.83 126.67,128.83 123.67,125.82 121.64,125.82 119.74,123.92 119.14,123.92 118.87,124.19 112.91,124.19 108.46,128.64 94.96,128.64 92.44,126.11 64.39,126.11 61.37,123.09 61.37,116.39 68.72,109.04 68.72,102.62 70.55,100.79 70.55,81.37 67.95,78.77 66,78.77 54.17,66.93 54.17,59.74 52.14,57.71 52.14,48.63 v2(52.83,47.93)
  BOTTOM w0.102: JDOCK1.2 141.75,136.44 141.75,136.44 141.75,135.62 v2(141.66,135.53)
DOCK_AC_OFF_EC: length 220.8
  TOP w0.102: UE1.A63 179.19,107.42 178.47,108.13 v1(175.76,108.13) v2(174.61,108.13)
  TOP w0.254: v2(21.67,42.15) PR858.1 PR850.2
  IN2 w0.122: v2(174.61,108.13) 171.44,108.13 169.6,106.29 169.6,102.41 167.26,100.08 167.26,92.87 166.49,92.1 166.49,85.02 167.52,84 167.52,81.78 166.08,80.34 166.08,77.85 165.45,77.22 165.45,74.2 163.61,72.36 163.61,71.29 162.01,69.68 162.01,67.97 159.88,65.84 159.88,63.34 159.09,62.55 157.94,62.55 157.62,62.23 157.62,53.88 157.79,53.71 157.79,51.69 156.5,50.4 139.43,50.4 135.63,46.6 79.42,46.6 70.8,37.98 64.75,37.98 63.88,38.85 v2(59.76,38.85)
  IN4 w0.254: v2(21.67,42.15) 30.66,42.15 31.5,42.99 31.5,43.7 32.41,44.62 33.94,44.62 35.65,42.9 38.57,42.9 39.13,43.46 43.65,43.46 47.95,39.17 56.33,39.17 57.46,38.04 58.94,38.04 v2(59.76,38.85)
DOCK_DCIN_IS+: length 237.5
  TOP w0.254: PQ703.6 59.11,40.25 58.41,39.55 v2(58.41,39.39)
  IN4 w0.254: v2(176.95,135.12) 177.06,135.22 177.06,136.25 176.54,136.77 169.29,136.77 167.83,135.31 165.48,135.31 164.72,136.07 156.6,136.07 155.84,135.31 153.86,135.31 152.78,136.39 144.94,136.39 144.21,135.66 144.21,132.42 142.94,131.15 142.94,129.83 141.18,128.07 138.24,128.07 137.48,127.31 134.21,127.31 132.67,128.84 127.71,128.84 122.2,123.33 112.77,123.33 109.8,126.3 108.54,126.3 106.77,128.07 95.35,128.07 94.02,129.4 86.84,129.4 83.42,125.99 70.9,125.99 67.4,122.49 67.4,118.58 68.62,117.36 68.62,103.62 70.33,101.91 73.69,101.91 75.76,99.84 75.76,88.32 77.28,86.8 81.16,86.8 83.63,84.32 83.63,73.68 73.12,63.17 71.42,63.17 66.8,58.56 66.8,53.39 63.77,50.36 63.77,49.39 57.65,43.27 57.65,39.52 57.88,39.28 58.31,39.28 v2(58.41,39.39)
  BOTTOM w0.254: JDOCK1.134 176.75,135.32 v2(176.95,135.12)
