# Allegro board LAA961PR10-1007A.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
GNDA: length 20.5
  TOP w0.203: UA1.37 208.68,74.11 208.79,74.22 209.87,74.22 v2(210.12,74.48) ; v2(210.69,67.8) 210.54,67.95 210.54,68.4 209.97,68.97 UA1.26
  TOP w0.305: JIO1.29 220.18,73.2 v2(219.92,73.46)
  TOP w0.406: v2(217.94,75.11) QA2.1 217.94,76.52 218.13,76.7 218.89,76.7 219.24,77.06 QA2.4
  TOP w0.508: v2(210.86,75.9) CA52.2 CA16.2 211.97,77.11 CA17.2 212.98,77.16 CA18.2 ; RA36.1 220.27,75.1 v2(219.94,74.77) ; CA25.2 216.63,70.07 v2(215.97,70.73)
  BOTTOM w0.508: v2(215.97,70.73) 215.97,74.35 216.73,75.11 v2(217.94,75.11)
  vias: v2(213.48,67.11) v2(214.06,67.11) v2(214.51,64.57) v2(215.14,64.51) v2(216.23,67.06) v2(216.82,67.06) v3(211.46,64.19) v3(214.19,66.35) v3(216.28,66.48)
GNDA_CHG: length 8.1
  IN4 w0.508: v2(42.99,39.28) 42.81,39.28 41.28,40.82 41.28,41.71 40.05,42.94 v2(39.42,42.94)
  BOTTOM w0.508: PC718.1 PR711.2 ; PR711.2 v2(42.99,39.28) ; PR711.2 PC711.2
  vias: v1(38.29,43.07) v2(37.09,41.87) v2(37.72,41.09) v2(37.71,40.22) v2(38.47,41.86) v2(38.55,40.29)
VCCSENSE: length 11.4
  TOP w0.152: PR531.1 RC209.2 98.75,94.73 98.55,94.54 97.73,94.54 97.6,94.42 97.6,93.84 97.73,93.72 97.92,93.72 98.05,93.59 98.05,88.93 v2(99.02,87.96)
  BOTTOM w0.152: v2(99.02,87.96) 99.25,87.72 100.08,87.72 UC1.E63
VDD_1.35V: length 5.6
  TOP w0.508: v2(77.94,20.97) 77.29,21.62 v1(75.81,21.62) 74.65,21.62 74.4,21.36 74.4,20.73 74.41,20.72
  BOTTOM w0.508: v2(77.94,20.97) 77.94,21.11 77.6,21.45 PR201.1
  vias: v2(74.42,20.69)
VSSSENSE: length 12.5
  TOP w0.152: v2(98.37,87.96) 97.28,89.04 97.28,93.02 v1(96.36,93.95) 95.95,94.35 RC218.1 PR532.1
  BOTTOM w0.152: UC1.E62 100.71,87.58 100.34,87.21 99.99,87.21 99.76,87.45 98.88,87.45 v2(98.37,87.96)
3301_ACAV_IN_NB: length 2.3
  TOP w0.254: PR848.1 20.41,40.23 v1(20.41,39.7) PU800.24
3301_PWRSRC: length 2.6
  TOP w0.254: PR860.1 25.31,36.04 v1(25.02,36.04) PU800.15
+AUX_LDO: length 4.8
  TOP w0.102: CR17.2 17.47,22.8 16.69,23.57 v1(16.23,23.57)
  TOP w0.203: UR1.12 20.09,22.26 19.81,22.53 18.74,22.53 18.47,22.8 CR17.2
+BL_PWR_SRC:
  vias: v2(97.74,115.01) v2(97.74,114.43) v2(99.14,114.87) v2(99.14,114.29) v3(96.52,115.81)
+CAP_LDO: length 11
  TOP w0.102: CE7.1 190.06,102.58 190.49,102.15 192.13,102.15 192.39,101.88 192.39,101.45 v1(192.09,101.15)
  TOP w0.254: CE7.1 190.28,102.86 v2(190.79,103.37) ; UE1.B46 186.78,103.09 186.57,103.31 v2(185.97,103.31)
  IN3 w0.254: v2(185.97,103.31) 185.97,103.31 186.37,102.91 190.33,102.91 v2(190.79,103.37)
+COINCELL: length 9.4
  BOTTOM w0.127: v1(213.15,49.03) 213.27,49.15 PR1.1
  BOTTOM w0.508: PR1.1 219.28,50.16 220.5,48.94 JRTC1.1
+DC_IN: length 57.6
  TOP w0.102: v3(68.2,105.16) 67.05,104 67.05,101.84 67.71,101.18 PR16.1
  TOP w0.508: PR835.1 v2(16.12,28.58)
  IN3 w0.508: v2(39.32,34.67) 38.54,35.45 36.25,35.45 35.13,34.33 31.71,34.33 28.14,30.76 18.3,30.76 v2(16.12,28.58)
  BOTTOM w0.508: v2(39.32,34.67) PR737.1 40.01,35.29 41.15,34.15 41.15,32.35 43.41,30.09 43.41,29.57 44.71,28.27 47.78,28.27 49.91,30.41 49.91,37.58 v2(49.15,38.34)
  vias: v2(46.61,62.78) v2(47.21,63) v2(47.96,63.26) v2(48.67,63.59) v2(49.37,63.91) v2(49.41,41.84) v2(49.41,41.2) v2(49.41,40.58) v2(49.39,39.96) v2(50.02,64.25) v2(50.07,41.82) v2(50.07,41.19) v2(50.07,40.57) v2(50.05,39.96) v2(50.66,64.53) v2(51.34,64.89) v3(67.82,99.88) v3(69.85,99.81) v4(68.42,99.93) v4(68.42,99.27) v4(68.4,98.63) v4(69.1,99.9) v4(69.12,99.24) v4(69.1,98.61)
+DC_IN_SS: length 43.2
  TOP w0.508: 45.85,41.01 46.26,41.42 47.71,41.42 v1(48.68,42.38) 49.74,43.44 PD704.2 ; PR831.1 14.73,34.32 14.44,34.61 v2(13.68,34.61) PD817.3
  IN2 w0.508: v2(13.68,34.61) 13.77,34.52 17.33,34.52 18.42,35.61 18.42,36.88 19.56,38.03 26.18,38.03 26.46,38.31 29.83,38.31 31.96,36.19 34.76,36.19 34.86,36.28 38.64,36.28 42.51,40.15 43.37,40.15 43.74,40.52 v2(44.1,40.52)
  vias: v2(44.1,41.15) v2(44.73,41.15) v2(44.73,40.52)
+DCIN:
  vias: v1(39.63,44.06) v2(40.21,43.98)
+DCIN_JACK:
  vias: v2(79,112.45) v3(79.56,116.77) v3(80.43,115.24) v3(81.77,116.63)
+DCPRRTC: length 36.2
  TOP w0.102: v2(160.48,83.58) v1(160.48,82.98)
  IN3 w0.254: v2(160.48,83.58) 160.48,83.86 160.14,84.2 156.72,84.2 155.17,82.65 148.12,82.65 146.7,81.23 146.7,79.01 146.09,78.39 145.69,78.39 145.29,77.99 145.29,77.78 144.95,77.44 139.85,77.44 139.68,77.27 135.55,77.27 135.06,76.78 v2(135.06,76.78)
  BOTTOM w0.254: CC52.1 159.79,79.33 159.79,82.81 160.48,83.5 v2(160.48,83.58) ; v2(135.06,76.78) 134.88,76.61 UC1.AE7
+DIMM1_VREF_DQ: length 8.4
  TOP w0.127: v1(56.15,31.18) 56.53,31.56 CD5.1
  TOP w0.508: CD5.1 CD1.1 56.53,33.17 57.05,33.69 v2(57.05,33.84) 56.03,33.84 55.62,34.26 RD4.2 RD5.1 55.63,35.44 RD6.1
  BOTTOM w0.356: JDIMM1.1 57.15,32.14 57.15,33.74 v2(57.05,33.84)
+DIMM2_VREF_DQ: length 8.7
  TOP w0.508: v2(131.99,33.46) 131.97,33.46 131.47,32.96 CD34.1 CD33.1 131.47,31.04 131.14,30.71 v1(130.77,30.71) 129.77,30.71 RD22.2 RD24.1 RD23.1
  BOTTOM w0.356: JDIMM2.1 133.15,32.93 132.96,33.12 132.32,33.12 v2(131.99,33.46)
+DOCK_PWR_BAR: length 259.6
  TOP w0.508: v2(15.01,36.35) 15.48,36.82 PR832.2 ; v2(45.57,42.82) 45.94,43.18 v1(47.17,43.18) 47.65,43.18 48.01,43.54 PD705.2
  IN1 w0.508: v2(15.01,36.35) 14.99,36.33 14.99,30.79 13.81,29.61 13.81,25.8 12.45,24.44 12.45,17.71 13.05,17.11 16.13,17.11 17.4,15.84 17.86,15.84 20.26,13.44 20.26,12.97 22.2,11.04 58.87,11.04 59.27,11.45 85.95,11.45 86.5,11.99 143.01,11.99 143.32,12.31 152.29,12.31 153.16,11.43 174.51,11.43 179.34,16.26 196.57,16.26 200.05,19.74 v2(200.05,22.06)
  IN2 w0.508: v2(15.01,36.35) 16.41,36.35 18.73,38.66 24.73,38.66 26.8,40.73 28.65,40.73 31.65,37.74 33.82,37.74 34.64,36.91 36.1,36.91 36.77,37.58 36.77,38.19 37.16,38.59 38.68,38.59 39.93,39.84 39.93,41.49 40.34,41.9 41.17,41.9 41.64,41.43 42.6,41.43 43.99,42.82 v2(45.57,42.82)
  vias: v2(140.78,136.03) v2(141.23,136.46) v2(143.75,138.55) v2(200.04,24.59) v2(200.06,23.96) v2(200.03,23.31) v2(200.05,22.71) v2(200.65,24.6) v2(200.67,23.97) v2(200.64,23.32) v2(200.65,22.73) v2(200.66,22.08) v2(201.31,24.6) v2(201.33,23.97) v2(201.3,23.32) v2(201.32,22.73) v2(201.32,22.08) v2(201.35,21.45) v2(201.93,22.08) v2(201.96,21.43) v2(224.98,35.78) v2(224.98,35.09) v2(225.64,35.78) v2(225.64,35.09) v2(226.25,35.78) v2(226.25,35.09) v2(226.93,35.78) v2(226.93,35.08) v2(227.59,35.78) v2(227.59,35.08) v2(228.2,35.78) v2(228.2,35.08) v2(231.76,92.04) v2(231.76,88.83) v2(232.12,91.39) v2(232.36,89.45) v2(232.46,92.04) v2(232.45,88.83) v2(232.63,90.76) v2(232.65,90.12) v2(232.82,91.39) v2(233.05,89.45) v2(233.33,90.76) v2(233.34,90.12)
+LCDVDD: length 19.7
  IN4 w1.524: 77.9,123.92 77.9,118.57 80.19,116.28 91.35,116.28
  vias: v2(76.46,125.01) v2(77.04,125.01) v2(77.62,125.01) v2(90.97,115.12) v2(91.56,115.12) v2(92.14,115.12) v3(77.09,124.39)
+LOM_VCT: length 14.3
  TOP w0.508: v2(172.48,135.41) 172.48,134.22 173.68,133.02 v1(173.68,130.64) 173.68,126.99 173.21,126.53 v2(172.87,126.53)
  BOTTOM w0.254: JDOCK1.118 172.75,135.68 v2(172.48,135.41) 172.25,135.64 JDOCK1.116
  BOTTOM w0.508: v2(172.87,126.53) 172.87,125.87 172.71,125.71 C316.1
+MIC1_VREF_OUT: length 12.3
  TOP w0.203: DA5.2 217.38,70.43 217.38,68.93 v1(217.12,68.67) 216.33,68.67 215.99,69.02 214.21,69.02 212.94,70.29 211.07,70.29 210.78,70.57 UA1.30
  TOP w0.254: DA4.2 216.75,71.07 DA5.2
+NBDOCK_DC_IN_SS: length 352.6
  TOP w0.508: PD817.2 12.5,33.31 v2(12.07,33.75) ; PR863.2 24.78,41.51 v2(25.36,40.92) 28.27,40.92 v1(29.43,39.77) 29.83,39.36 29.83,38.15 31.97,36.02 31.97,32.2 32.17,32 v2(32.17,28.98)
  IN1 w0.508: v2(170.02,15.87) 174.21,15.87 179.01,20.66 179.01,24.5 177.74,25.77 177.74,32.63 178.12,33.01 178.12,36.02 163.29,50.85 152.94,50.85 v2(150.62,53.17)
  IN2 w0.508: v2(150.62,53.17) 155.48,58.03 155.48,69.78 157.1,71.4 157.1,73.6 157.94,74.44 157.94,75.75 160.01,77.82 160.01,80.84 158.69,82.16 158.69,90.06 163.71,95.08 163.71,97.53 163.44,97.8 163.44,98.64 163.68,98.88 163.68,100.7 165.53,102.55 165.53,109.26 166.33,110.06 166.33,121.25 162.31,125.28 162.31,128.71 158.14,132.87 v2(156.61,132.87) ; v2(32.17,28.98) 32.66,29.47 36.81,29.47 37.99,28.29 42.34,28.29 43.11,27.51 50.13,27.51 56.25,21.39 71.63,21.39 71.97,21.05 73.92,21.05 74.45,21.58 78.37,21.58 79.08,20.87 81.04,20.87 83.45,18.46 83.45,15.34 84.29,14.51 94.72,14.51 95.19,14.98 105.79,14.98 107.12,16.31 112.83,16.31 114.81,14.33 121.03,14.33 126.67,8.69 147.32,8.69 152.96,14.33 165.48,14.33 167.02,15.87 v2(170.02,15.87) ; v2(25.36,40.92) 25.21,41.08 15.45,41.08 13.02,38.65 12.54,38.65 12.07,38.18 v2(12.07,33.75)
  BOTTOM w0.254: v2(156.61,132.87) 154.61,130.88 152.14,130.88 151.75,130.49 JDOCK1.41
+PBATT: length 188.7
  TOP w0.102: v3(42.48,30.47) 42.79,30.17 42.79,29.87 v2(42.78,29.86)
  TOP w0.508: v2(17.39,39.83) 16.75,39.2 PR838.2 ; PD702.2 43.59,47.17 43.26,47.5 41.56,47.5 39.66,45.61 32.79,45.61 31.71,44.52 31.71,43.79 31,43.08 31,41 31.37,40.63 v2(31.83,40.63) 31.9,40.55 PR723.2
  IN2 w0.508: v2(42.78,29.86) 42.79,29.85 42.79,29.81 43.54,29.06 45.66,29.06 46.09,29.49 47.88,29.49 48.25,29.12 51.38,29.12 56.72,23.79 97.54,23.79 99.07,22.26 103,22.26 107.4,17.86 120.01,17.86 121.79,16.08 162.31,16.08 v2(162.33,16.11)
  IN4 w0.508: v2(42.78,29.86) 42.78,29.85 42.38,29.45 38.74,29.45 38.53,29.66 37.86,29.66 37.34,29.14 34.42,29.14 32.68,27.4 30.27,27.4 27.88,25.01 22.48,25.01 21.28,26.22 18.42,26.22 17.91,26.72 17.91,39.31 v2(17.39,39.83)
  vias: v2(11.76,50.49) v2(12.32,50.07) v2(12.58,50.85) v2(12.79,49.61) v2(13.02,50.23) v2(13.06,48.96) v2(13.43,50.88) v2(13.49,49.61) v2(13.69,48.96) v2(13.69,48.33) v2(13.85,50.23) v2(14.16,49.62) v2(14.3,50.77) v2(14.33,48.96) v2(14.33,48.33) v2(14.62,50.18) v2(14.81,49.57) v2(14.96,48.96) v4(183.75,12.65) v4(183.75,11.95) v4(183.75,11.32) v4(184.44,12.65) v4(184.44,11.95) v4(184.44,11.32) v4(185.14,12.65) v4(185.14,11.95) v4(185.14,11.32) v4(185.84,12.65) v4(185.84,11.95) v4(185.84,11.32) v4(186.48,12.65) v4(186.48,11.95) v4(186.48,11.32)
+PCH_ASATA3PLL: length 23
  TOP w0.089: RC17.2 130,95.25 v1(129.5,94.76)
  TOP w0.508: v2(133.48,93.08) 133.1,93.08 132.53,93.65 132.53,94.89 131.92,95.49 131.24,95.49 RC17.2
  BOTTOM w0.203: v2(133.48,93.08) 132.44,93.08 132.04,92.68 132.04,91.44 131.73,91.13 131.73,90.29 UC1.A12
  BOTTOM w0.254: UC1.B11 132.3,89.81 132.63,89.81 132.91,90.08 132.91,90.71 133.86,91.65 133.86,92.7 v2(133.48,93.08)
  BOTTOM w0.381: CC56.1 CC55.1 ; CC55.1 134.8,97.43 134.61,97.24 134.61,94.34 134.18,93.91 134.18,93.77 v2(133.48,93.08) ; CC55.1 135.26,97.79 135.33,97.87 LC2.2
+PCH_AUSB3PLL: length 26.3
  TOP w0.254: v2(122.86,91.34) 128.24,91.34 v2(128.29,91.29)
  BOTTOM w0.102: UC1.B27 122.66,89.93 122.66,90.61
  BOTTOM w0.254: v2(128.29,91.29) 127.76,90.77 127.76,90.15 127.94,89.97 UC1.B18
  BOTTOM w0.305: RC149.1 121.91,95.48 123.18,94.21 123.18,91.66 v2(122.86,91.34) 122.66,91.14 122.66,90.61
  BOTTOM w0.381: v2(128.29,91.29) 128.72,91.72 128.72,94.22 v1(129.6,95.1) 130.62,96.13 CC47.1 CC51.1 130.62,98.54 130.3,98.86 130.3,99.46 130.96,100.11 130.96,100.74 131.43,101.21 LC1.2
+PCH_RTC_VCCSUS3_3: length 22.8
  TOP w0.089: v2(132.44,58.35) v1(133.11,58.35)
  TOP w0.508: v2(132.44,58.35) 131.82,57.72 CC73.1 RC213.2 130.62,58.61 RC212.2
  IN2 w0.508: v2(132.44,58.35) 132.32,58.22 131.64,58.22 131.13,58.73 131.13,67.97 131.43,68.28 131.43,69.8 131.05,70.19 131.05,74.12 131.41,74.48 v2(131.93,74.48)
  BOTTOM w0.254: v2(131.93,74.48) 132.04,74.48 UC1.AH11
+PCH_VCC1P05: length 19.6
  TOP w0.508: CC78.1 128.6,95.95 v2(128.34,95.69)
  IN2 w0.508: v2(128.34,95.69) 128.34,95.05 128.08,94.8 127.32,94.8 127,94.48 127,91.68 128.15,90.54 128.15,89.02
  BOTTOM w0.254: UC1.J18 128.27,85.37 v2(128.2,85.37) 128.12,85.29 UC1.K19
  BOTTOM w0.508: LC4.2 130.39,101.84 130.39,100.35 129.16,99.12 CC77.1 129.16,98.17 128.18,97.2 v1(128.18,96.66) 128.18,95.84 v2(128.34,95.69)
+PCH_VCCACLKPLL: length 31.7
  IN3 w0.381: v2(124.59,96.19) 124.59,96.83 125.71,97.95 128.11,97.95 129.33,99.16 129.33,100.28 130.33,101.29 134.09,101.29 135.48,102.67 v2(135.48,103.88)
  BOTTOM w0.254: UC1.A20 127.29,91.17
  BOTTOM w0.381: LC5.2 135.83,104.23 v2(135.48,103.88) ; v2(124.59,96.19) 124.22,95.82 RC69.2 ; v2(124.59,96.19) 123.74,96.19 v1(123.21,96.72) 122.85,97.08 CC81.1 ; v2(124.59,96.19) 125.48,96.19 126,95.67 CC82.1 126.76,94.8 128.02,94.8 128.25,94.56 128.25,92.13 127.29,91.17
+PCH_VCCDSW: length 19
  TOP w0.508: v2(133.58,72.52) 133.23,72.52 132.93,72.81 CC97.2 ; 126.88,67.4 v1(126.88,64.62) 126.88,60.45 126.56,60.14 RC211.2
  IN1 w0.508: v2(127.88,75.1) 128.49,75.71 132.35,75.71 132.9,75.16 132.9,72.93 133.3,72.52 v2(133.58,72.52)
  BOTTOM w0.254: UC1.AG20 127.51,75.47 v2(127.88,75.1) 128.25,75.47 UC1.AG19
+PCH_VCCDSW3_3: length 180.3
  TOP w0.254: RPC5.3 156.29,75.49 v2(156.77,75.97) 156.75,76 156.35,76 156.34,75.99 RPC5.4 ; RPC5.1 156.32,74.49 v2(156.58,74.75) 156.34,74.99 RPC5.2
  TOP w0.305: JAPS1.3 v2(219.8,99.2) ; JAPS1.7 220.18,101.2 v2(219.81,101.57)
  TOP w0.508: RC216.2 129.75,58.61 RC217.2 129.3,57.72 128.94,57.37 128.94,56.09 v1(129.39,55.64) 129.8,55.24 v2(134.31,55.24) ; CC80.1 142.42,75.26 141.59,74.44 138.52,74.44 ; RC92.1 155.51,73.41 RC153.2 157.2,73.5 v2(157.2,74.87)
  IN2 w0.508: v2(133.7,74.41) 133.22,74.41 132.88,74.07 132.88,68.44 131.86,67.42 131.86,66 133.09,64.77 133.09,56.07 133.92,55.24 v2(134.31,55.24)
  IN3 w0.508: 155.2,74.25 156.08,74.25 v2(156.58,74.75) ; 155.2,74.25 155.2,69.33 156.3,68.23 163.55,68.23 164.15,68.82 164.15,73.9 165.49,75.24 165.49,76.23 168.31,79.05 181.92,79.05 183.39,80.52 199.08,80.52 199.84,81.28 203.66,81.28 206.39,78.55 209.15,78.55 211.11,80.52 211.11,82.52 211.58,82.99 216.35,82.99 v2(217.05,82.29) ; 155.2,74.25 150.71,74.25 147.39,70.92 147.39,70.18 145.01,67.81 144.15,67.81 143.64,68.32 137.04,68.32 136.53,67.81 133.48,67.81 132.87,68.42 132.87,74.12 133.16,74.41 v2(133.7,74.41)
  BOTTOM w0.254: v2(133.7,74.41) 133.44,74.41 133.16,74.68 UC1.AH10
  BOTTOM w0.508: v2(219.81,101.57) 219.8,101.55 v2(219.8,99.2) 219.29,98.7 219.28,98.7 217.43,96.84 217.43,87.52 216.55,86.64 216.55,86 216.09,85.54 216.09,84.75 217.05,83.8 v2(217.05,82.29)
+PCH_VCCDSW_R: length 2.9
  TOP w0.089: RC211.1 126.54,59.6 126.66,59.6 127.45,60.39 v1(127.45,60.52)
  TOP w0.381: RC211.1 CC65.1
+PWR_SRC: length 180.9
  TOP w0.508: 90.34,112.68 89.88,113.13 CV11.1 RV4.1
  IN3 w2.032: 200.28,27.74 200.75,27.74 203.39,25.1 203.39,18.85 200.35,15.8 200.35,14.28 199.08,13.01 196.54,13.01 194.72,11.19 190.38,11.19 187.39,14.18 180.62,14.18 177.63,11.19 171.81,11.19 171.38,10.76 151.16,10.76 149.72,12.19 144.27,12.19 143.05,10.98 97.86,10.98 97.09,11.74 94.74,11.74
  IN4 w1.524: 89.19,111.04 86.01,111.04 84.37,109.4 84.37,107.18 83.63,106.44 82.04,106.44 78.96,103.36
  IN4 w2.032: 196.38,65.88 196.38,58.26 195.53,57.41 195.53,52.86 197.39,51.01 197.39,38.01 198.88,36.52 198.88,31.11
  vias: v2(33.57,12.23) v2(33.59,13.58) v2(33.58,12.89) v2(34.23,13.58) v2(34.22,12.89) v2(34.19,12.23) v2(34.83,12.87) v2(34.81,12.18) v2(35.46,12.87) v2(35.45,12.18) v2(87.66,10.21) v2(88.32,10.21) v2(88.97,10.21) v2(89.59,10.21) v2(90.32,10.23) v2(90.38,111.5) v2(91.01,111.5) v2(90.99,10.23) v2(91.65,111.48) v2(91.63,10.23) v2(92.04,112.65) v2(92.06,112.04) v2(92.26,10.23) v2(196.41,69.46) v2(196.41,68.82) v2(196.41,68.19) v2(196.41,67.55) v2(196.98,69.21) v2(196.98,68.57) v2(198.41,29.14) v2(198.68,29.68) v2(199.08,29.14) v2(199.34,29.68) v3(26.67,49.97) v4(19.7,51.01) v4(19.7,50.37) v4(20.34,51.01) v4(20.34,50.37) v4(20.97,51.01) v4(20.97,50.37) v4(21.61,51.01) v4(21.61,50.37) v4(22.24,51.01) v4(22.24,50.37) v4(22.95,50.94) v4(22.95,50.31) v4(23.59,50.94) v4(23.59,50.31) v4(25.91,58.16) v4(25.91,57.52) v4(26.55,58.16) v4(26.55,57.52) v4(27.18,58.16) v4(27.18,57.52) v4(27.82,58.16) v4(27.82,57.52) v4(28.45,58.16) v4(28.45,57.52) v4(77.65,99.14) v4(77.65,98.5) v4(78.3,99.14) v4(78.3,98.5) v4(78.93,99.14) v4(78.97,98.49) v4(79.61,99.11)
+PWR_SRC_AC: length 222.1
  TOP w0.508: PR860.2 v2(26.43,35.77)
  IN1 w2.032: 209.87,17.28 209.87,11.57 205.43,7.14 171.77,7.14 171.52,6.89 149.58,6.89 149.33,7.14 76.85,7.14 76.53,6.82 60.47,6.82 60.19,7.1 19.26,7.1 17.39,8.97
  IN2 w0.508: v2(26.43,35.77) 26.01,35.77 23.51,33.26 12.58,33.26 11.12,31.8 9.27,31.8 v2(8.89,32.19)
  vias: v2(44.05,54.59) v2(44.05,53.95) v2(44.05,53.32) v2(44.05,52.68) v2(44.68,54.59) v2(44.68,53.95) v2(44.68,53.32) v2(44.68,52.68) v2(45.32,54.59) v2(45.32,53.95) v2(45.32,53.32) v2(45.32,52.68) v2(209.55,21.2) v2(209.55,20.58) v2(209.57,19.93) v2(209.55,19.28) v2(210.21,21.17) v2(210.21,20.55) v2(210.23,19.9) v2(210.21,19.26) v2(210.87,19.31) v2(210.89,19.96) v3(200.98,14.34) v4(6.7,60.62) v4(6.7,59.99) v4(6.72,59.27) v4(7.31,60.26) v4(7.31,59.63) v4(7.91,60.65) v4(7.91,60.01) v4(8.58,60.82) v4(8.58,60.19) v4(9.15,60.51) v4(9.77,60.35) v4(10.53,60.35)
+RSVD_VCC3P3_1: length 2.6
  TOP w0.203: RL6.2 v1(205.93,110.94) 206.15,111.15 UL1.1
+RTC_CELL: length 196.7
  TOP w0.381: RC9.1 RC10.1 164.59,62.73 v2(164.79,62.54) ; RC8.1 164.22,65.38 v2(164.68,64.92) ; RA21.1 215.78,77.79 214.95,78.62 214.95,79.26 214.12,80.09 214.12,80.9 v2(214.82,81.6) 215.45,81.6 RE31.1 ; v2(139.55,62.84) 139.55,59.5 141.75,57.31 156.24,57.31 157.75,58.81 157.96,58.81 v1(158.3,59.15) 160.89,59.15 v2(161.04,58.99) ; v2(211.2,85.54) 211.05,85.39 RE32.1 211.05,83.86 RE62.1 ; CC48.1 CC50.1 RC1.1 162.62,53.95 v2(162.51,53.83)
  TOP w0.508: CC49.1 133.16,75.71 v2(133.66,75.22)
  IN1 w0.381: v2(133.66,75.22) 134.28,74.6 134.28,74.11 134.69,73.7 134.69,70.2 134.48,70 134.48,66.96 136.18,65.27 137.13,65.27 v2(139.55,62.84)
  IN2 w0.381: v2(226.04,86.85) 226.04,86.83 228.37,84.5 228.37,81.31 229.59,80.09 229.59,63.13 221.76,55.3 218.58,55.3 216.35,53.06 215.12,53.06 213.92,51.87 v2(213.55,51.87) ; v2(164.68,64.92) 164.68,64.65 165.42,63.91 165.42,63.17 v2(164.79,62.54) 164.79,61.4 163.01,59.62 162.17,59.62 161.55,58.99 v2(161.04,58.99)
  IN3 w0.381: v2(162.51,53.83) 164.6,53.83 168.06,50.37 186.21,50.37 188.22,48.36 199.21,48.36 200.41,49.56 210.23,49.56 211.27,50.6 212.28,50.6 v2(213.55,51.87) ; v2(226.04,86.85) 225.67,86.48 222.56,86.48 221.59,87.44 217.32,87.44 216.25,86.36 v2(215.7,86.36) 214.23,86.36 213.2,85.34 211.4,85.34 v2(211.2,85.54)
  BOTTOM w0.254: UC1.AG10 133.17,75.47 133.42,75.22 v2(133.66,75.22)
  BOTTOM w0.381: v2(161.04,58.99) 161.04,56.63 162.51,55.17 v2(162.51,53.83) ; v2(214.82,81.6) 214.82,85.49 v2(215.7,86.36) ; v2(213.55,51.87) PD3.1 215.04,51.87 PC1.1
  BOTTOM w0.508: v2(139.55,62.84) 140.1,62.3 RC78.2
+RTC_CELL_VBAT: length 6.9
  TOP w0.254: v2(208.98,85.17) 209.2,84.95 209.92,84.95 RE32.2 210.14,83.87 CE11.1 ; v2(207.62,88.19) UE2.B64
  BOTTOM w0.254: v2(207.62,88.19) 207.62,87.39 208.09,86.92 208.09,85.58 208.5,85.17 v2(208.98,85.17)
+SD_IO_LDO: length 5.2
  TOP w0.203: UR1.25 20.09,15.43 19.9,15.24 19.45,15.24 19.18,14.96
  TOP w0.508: CR14.2 16.33,13.02 CR15.2 17.43,13.21 v1(18.13,13.92) 19.18,14.96
+SDC_IN: length 45.2
  TOP w0.508: PC700.1 52.54,43.32 v3(51.81,44.06) v2(51.15,44.06) ; PR847.1 22.19,28.79 v2(22.2,28.78)
  IN1 w0.508: v2(40.6,41.27) 40.22,41.27 39.96,41 39.96,39.54 40.45,39.04 40.45,38.09 38.39,36.02 32.9,36.02 29.66,32.78 25.46,32.78 22.2,29.53 v2(22.2,28.78)
  IN2 w0.508: v2(51.15,44.06) 47.75,44.06 45.85,42.15 44.22,42.15 42.87,40.8 41.38,40.8 40.91,41.27 v2(40.6,41.27)
  BOTTOM w0.203: v2(40.6,41.27) 40.59,41.28 40.59,41.37 40.46,41.49 PU700.3
  BOTTOM w0.457: PR710.2 41.25,41.04 41.02,41.27 v2(40.6,41.27)
  BOTTOM w0.508: v2(51.15,44.06) 50.95,44.25 PQ700.3
+SIM_PWR: length 207.7
  TOP w0.127: v1(70.82,18.77) 70.39,18.34 v2(70.39,18.09)
  IN3 w1.016: 70.04,16.32 70.04,11.11 71.66,9.49 76.46,9.49 77.17,8.78 148.65,8.78 149.66,7.78 171.78,7.78 172.8,8.79 209.64,8.79 215.66,14.81 215.66,38.48 219.74,42.57
  IN4 w1.016: 219.64,43.82 219.64,43.95 218.72,44.86 218.13,44.86 217.39,45.6 217.39,46.5 218.27,47.38 218.27,55.22 215.33,58.16 215.33,60.56 213.98,61.9 213.98,62.61
  vias: v2(70.39,17.5) v2(212.99,63.15) v2(213.02,62.56) v2(220.08,43.01) v2(220.47,43.44)
+SM_VREF_CA: length 64.9
  TOP w0.508: RD19.2 71.96,24.31 CD36.1 73.54,24.43 74.45,25.34 74.45,35.75 v1(98.73,60.03) 108.62,69.92 v2(108.62,71.1)
  BOTTOM w0.254: v2(108.62,71.1) 108.76,71.1 UC1.AP49
+SM_VREF_CA_DIMM: length 122.2
  TOP w0.127: v2(97.2,22.39) v1(97.2,21.76)
  TOP w0.508: v2(68.39,25.64) 68.39,24.58 RD18.2 68.66,24.31 RD19.1 69.52,24.82 RD20.1 ; v2(97.2,22.39) 96.59,23 CD23.1 CD22.1 ; CD56.1 CD55.1 173.51,23.47 172.94,22.9 v2(172.94,22.48)
  IN1 w0.508: v2(172.94,22.48) 172.94,21.49 171.57,20.12 167.09,20.12 166.48,19.51 145.16,19.51 144.64,20.03 122.04,20.03 118.9,23.17 99.13,23.17 98.35,22.39 v2(97.2,22.39) 97.08,22.51 97.08,24.1 96.51,24.67 69.37,24.67 v2(68.39,25.64)
  BOTTOM w0.356: v2(172.94,22.48) 173.05,22.59 JDIMM2.126 ; v2(97.2,22.39) 97.05,22.54 JDIMM1.126
+SM_VREF_DQ0: length 72.5
  TOP w0.508: v2(107.67,70.42) 107.67,70.14 105.65,68.13 104.26,68.13 103.25,67.12 103.25,66.54 94.81,58.09 v1(91.89,58.09) 85.76,58.09 85.05,57.38 85.05,55.21 77.54,47.69 77.54,40.82 73.01,36.3 CD21.1 56.58,35.47 RD5.2
  BOTTOM w0.254: v2(107.67,70.42) 107.73,70.42 UC1.AR51
+SM_VREF_DQ1: length 107.9
  TOP w0.508: v2(127.04,32.85) 127.18,32.71 CD54.1 RD23.2 ; v2(107.67,71.07) 107.38,71.07 105.65,69.35 103.38,69.35 v1(94.1,60.06) 93.33,59.3 86.07,59.3 84.42,57.65 84.42,55.47 76.81,47.87 v2(76.81,45.93)
  BOTTOM w0.254: v2(107.67,71.07) 107.99,71.4 UC1.AP51
  BOTTOM w0.508: v2(76.81,45.93) 124.79,45.93 127.04,43.68 v2(127.04,32.85)
+USB_RIGHT_PWR: length 2.3
  TOP w0.102: JUSB2.1 232.55,126.77 v3(231.08,125.3)
+VCHGR:
  vias: v2(15.46,56.57) v2(15.46,55.93) v2(15.46,55.3) v2(15.46,54.66) v2(16.09,57.22) v2(16.09,56.57) v2(16.09,55.93) v2(16.09,55.3) v2(16.09,54.66) v2(16.73,57.22) v2(16.73,56.57) v2(16.73,55.93) v2(16.73,55.3) v2(16.73,54.66) v3(15.56,59.24)
+VDISPLAY_VCC: length 2.4
  TOP w0.127: UV501.3 250.59,125.52 v1(249.24,124.17)
  vias: v2(251.5,126.59) v2(252.08,126.59)
+VHDMI_VCC: length 1.1
  BOTTOM w0.127: RV7.2 v1(91.68,125.92)
+VLDOIN_1.35V: length 2.2
  TOP w0.127: v2(79.99,16.13) v1(79.12,16.13)
  BOTTOM w0.254: v2(79.99,16.13) 79.46,16.66 PU200.19
+VR_CAP: length 9.7
  TOP w0.254: UE2.B12 209.87,93.5 209.76,93.62 209.15,93.62 v2(208.66,94.1) ; CE31.1 212.36,98.42 v1(212.02,98.07) 211.03,97.08 v2(210.42,97.08)
  IN1 w0.254: v2(208.66,94.1) 208.32,94.44 208.32,94.95 209.07,95.7 209.07,96.76 209.39,97.08 v2(210.42,97.08)
+VREFOUT: length 11.9
  TOP w0.127: v2(213.62,68.88) 213.93,68.88 214.09,68.72 215.67,68.72 v1(215.84,68.56)
  TOP w0.203: 210.11,66.31 209.64,66.78 208.79,66.78 208.28,67.29 UA1.23
  TOP w0.254: CA26.1 210.11,66.91 v2(210.15,66.95) ; RA6.2 RA5.2 v2(213.62,68.88)
  IN2 w0.254: v2(210.15,66.95) 211.29,66.95 213.22,68.88 v2(213.62,68.88)
+Z4012: length 2.3
  BOTTOM w0.127: v1(211.62,49.2) 212.36,49.94 PR1.2
  BOTTOM w0.508: PD3.2 212.36,51.18 PR1.2
-DCIN_JACK:
  vias: v2(74.51,106.18) v2(74.89,106.62) v2(75.24,107.1) v2(76.74,106.29) v2(77.29,106.73) v2(77.8,107.19) v2(78.2,107.74) v2(78.58,109.79) v2(79.3,109.79) v2(79.97,109.79) v2(80.85,109.32) v2(81.57,109.32) v2(82.25,109.32) v3(80.74,106.71)
/BATPRES: length 253.5
  TOP w0.254: PR728.2 34.66,38.64 v2(34.79,38.76)
  IN1 w0.254: v2(13.29,39.86) 10.16,39.86 8.54,38.23 8.54,35.5 9.77,34.27 9.77,22.56 9.17,21.97 9.17,17.09 11.47,14.8 13.48,14.8 15.08,13.2 15.62,13.2 20.07,8.75 59.81,8.75 60.22,9.16 86.95,9.16 87.32,8.79 148.91,8.79 149.6,9.48 151.89,9.48 152.24,9.12 176.01,9.12 180.31,13.43 203.42,13.43 v2(203.56,13.29)
  IN3 w0.254: v2(13.29,39.86) 13.91,39.23 26.1,39.23 26.9,40.03 28.62,40.03 28.84,39.81 33.74,39.81 v2(34.79,38.76)
  BOTTOM w0.203: PU700.15 35.67,39.27 35.15,38.76 v2(34.79,38.76)
  BOTTOM w0.254: PR816.2 v2(203.56,13.29)
A_ON: length 106.3
  TOP w0.102: v2(206.94,103.87) 206.94,102.96 206.76,102.78 206.19,102.78 205.87,103.11 RPE10.3 ; UE2.A4 211.48,89.75 211.65,89.59 212.5,89.59 212.65,89.44 v2(212.65,89.14) ; v2(197.81,62.09) 197.41,61.7 197.41,58.35 196.56,57.5 196.56,52.86 198.57,50.85 198.57,42.67 v3(204.48,36.76) 204.48,36.12 203.34,34.98 202.69,34.98 202.65,34.93 UZ8.5
  IN1 w0.084: v2(197.81,62.09) 196.42,63.48 189.02,63.48 v2(188.01,62.47)
  BOTTOM w0.102: v2(206.94,103.87) 206.94,103.64 207.2,103.37 207.97,103.37 208.97,102.37 208.97,102.1 209.37,101.69 209.37,99.59 211.19,97.78 211.19,89.73 211.77,89.14 v2(212.65,89.14) 212.83,88.96 212.83,87.08 214.39,85.53 214.39,81.26 214.48,81.17 214.78,81.17 215.17,80.79 215.17,80.39 214.86,80.08 210.1,80.08 208.52,78.49 206.61,78.49 203.78,75.66 203.78,67.89 202.42,66.53 201.6,66.53 197.81,62.73 v2(197.81,62.09) ; RZ42.1 v2(188.01,62.47)
AC_DIS: length 474.1
  TOP w0.102: UE2.A10 212.15,92.75 212.67,92.23 213.49,92.23 213.92,92.66 v2(218.06,92.66)
  TOP w0.254: PR828.1 6.51,32.57 v2(6.93,32.15) ; PQ6.5 73.32,97.02 v1(73.57,96.77) 73.98,96.36 v2(74.23,96.36) ; PQ712.2 v2(3.77,21.65)
  IN1 w0.084: v2(218.06,92.66) 219.15,92.66 219.29,92.52 227.7,92.52 v2(228.04,92.18)
  IN2 w0.254: v2(61.27,65.69) 60.57,64.98 60.57,59.54 57.5,56.47 57.5,53.7 51.81,48.01 44.43,48.01 42.74,46.32 42.74,44.38 42.36,44.01 41.91,44.01 40.69,42.79 39.97,42.79 39.64,42.46 39.1,42.46 38.8,42.75 35.67,42.75 35.29,43.13 33.88,43.13 32.86,42.12 31.78,42.12 31.36,42.54 22.75,42.54 22.13,43.16 20.26,43.16 19.75,42.65 14.95,42.65 11.07,38.77 11.07,34.41 9.63,32.97 7.75,32.97 v2(6.93,32.15)
  IN3 w0.122: v2(61.27,65.69) 62.17,66.58 62.17,68.44 64.79,71.06 65.34,71.06 77.66,83.38 77.66,84.31 79.12,85.77 79.12,93.12 75.89,96.36 v2(74.23,96.36)
  IN3 w0.254: v2(228.04,92.18) 230.48,89.74 230.48,46.07 220.03,35.61 220.03,7.92 218.41,6.3 173.8,6.3 172.81,5.31 148.63,5.31 147.68,6.26 19.35,6.26 14.79,10.82 8.05,10.82 3.77,15.11 v2(3.77,21.65) 3.33,22.09 3.33,30.56 4.92,32.15 v2(6.93,32.15)
AC_PRESENT: length 104.5
  TOP w0.102: RPC5.6 153.84,75.49 153.4,75.05 148.66,75.05 v1(148.19,74.59) 145.22,71.62 141.53,71.62 140.17,72.98 137.24,72.98 136.58,73.65 136.16,73.65 136.06,73.55 134.72,73.55 134.37,73.9 133.66,73.9 v2(133.57,73.81) ; v2(204.66,85.82) 204.37,86.12 UE2.A54
  IN3 w0.122: v2(204.66,85.82) 204.27,85.82 203.58,86.51 202.02,86.51 201.36,85.84 201.08,85.84 199.3,84.06 197.63,84.06 197.31,84.38 192.55,84.38 191,82.83 184.52,82.83 183.75,83.59 182.36,83.59 182.09,83.32 173.16,83.32 172.22,82.39 160.76,82.39 160.22,81.85 156.44,81.85 156.09,81.49 149.98,81.49 146.93,78.44 146.93,77.86 146.59,77.51 146.34,77.51 144.49,75.66 141.02,75.66 140.35,75 138.65,75 138.08,75.57 136.77,75.57 136.57,75.37 134.47,75.37 134.22,75.11 134.22,74.35 133.69,73.81 v2(133.57,73.81)
  BOTTOM w0.076: UC1.AJ8 134.23,74.23 133.81,73.81 v2(133.57,73.81)
ACAV_DOCK_SRC#: length 243
  TOP w0.102: PR846.2 21.21,28.08 20.55,28.08 v1(20.17,27.7)
  TOP w0.254: PR846.2 21.25,28.59 v2(20.93,28.91) 20.93,29.34 PR842.1
  IN1 w0.254: v2(54.61,65.01) 53.77,65.01 49.61,60.86 34.35,60.86 30.93,57.44 30.93,52.66 32.59,51 32.59,44.23 31.68,43.32 31.68,42.07 31.09,41.49 31.09,35.68 28.84,33.43 24.77,33.43 24.51,33.16 23.12,33.16 22.61,32.66 22.61,30.97 20.93,29.29 v2(20.93,28.91)
  IN3 w0.122: v2(54.61,65.01) 54.61,67.02 66.09,78.5 68.13,78.5 70.8,81.17 70.8,100.89 68.97,102.73 68.97,109.14 61.62,116.5 61.62,122.99 64.49,125.87 92.54,125.87 95.07,128.39 108.36,128.39 112.81,123.94 118.77,123.94 119.04,123.67 119.87,123.67 121.78,125.57 123.77,125.57 126.77,128.58 132.38,128.58 133.6,127.36 140.27,127.36 142.39,129.48 149.26,129.48 152.04,132.26 v2(153.29,132.26)
  BOTTOM w0.102: v2(153.29,132.26) 152.47,132.26 151.45,133.28 151.45,134.97 151.72,135.23 151.72,135.83 151.75,135.87 151.75,136.66 151.75,136.66 JDOCK1.42
ACAV_IN: length 298.5
  TOP w0.102: v2(213.79,85.06) 213.6,85.25 212.54,85.25 211.57,86.22 211.07,86.22 210.82,86.46 209.98,86.46 209.62,86.1 209.49,86.1 209.37,86.22 UE2.A64
  TOP w0.254: v2(8.17,21.35) 7.81,21 PQ712.1 ; PQ817.5 12.04,23.85 13.24,22.66 v2(14.42,22.66) ; v2(39.78,33.06) v3(40.2,33.49) 40.41,33.7 40.41,36.87 40.22,37.06 40.22,38.34 PR715.1 40.97,38.66 41.02,38.61 PR713.2 41.49,39.67 PR714.1 ; PR851.1 23.26,29.23 v2(22.88,28.85)
  IN2 w0.254: v2(33.62,33.2) 34.51,34.09 37.85,34.09 38.88,33.06 v2(39.78,33.06) 41.79,33.06 43.71,31.14 47.94,31.14 50.18,33.39 51.56,33.39 53.19,35.02 71.9,35.02 76.19,39.31 192.81,39.31 197.27,43.78 197.27,46.13 200.79,49.65 202.5,49.65 211.13,58.28 221.57,58.28 227.27,63.98 227.27,69.53 228.76,71.01 228.76,78.45 227.63,79.58 227.63,83.69 v2(225.85,85.47)
  IN3 w0.122: v2(213.79,85.06) 214.59,85.85 217.52,85.85 217.96,86.29 217.96,86.63 218.39,87.06 221.44,87.06 222.4,86.1 225.22,86.1 v2(225.85,85.47)
  IN3 w0.254: v2(14.42,22.66) 10.14,22.66 8.83,21.35 v2(8.17,21.35)
  IN4 w0.254: v2(22.88,28.85) 22.88,29.05 26.69,32.86 33.28,32.86 v2(33.62,33.2)
  BOTTOM w0.254: v2(22.88,28.85) 22.3,29.42 18.16,29.42 15.48,26.74 15.48,23.73 v2(14.42,22.66)
ACAV_IN#: length 21.3
  TOP w0.254: PQ817.3 14.05,24.5 14.44,24.9 v2(14.44,26.03) ; PU806.2 10.33,23.88 9.97,24.23 9.97,25.64 v1(10.66,26.33) v2(11.47,26.33) ; PR864.2 24.54,28.12 v2(24.83,28.41)
  IN3 w0.254: v2(11.47,26.33) 11.72,26.33 12.03,26.03 v2(14.44,26.03) 15.55,26.03 17.31,27.78 20.37,27.78 20.51,27.92 24.34,27.92 v2(24.83,28.41)
ACAV_IN_NB: length 249.2
  TOP w0.102: v2(208.56,95.94) 208.62,95.99 UE2.B20 ; v1(47.5,37.91) 47.11,37.91 46.68,38.34 v2(45.68,38.34)
  TOP w0.254: v2(20.78,42.15) PR848.2
  IN2 w0.122: v2(45.68,38.34) 46.08,37.93 47.02,37.93 48.36,36.59 53.24,36.59 54.03,37.39 56.3,37.39 57.08,36.61 71.43,36.61 79.86,45.03 135.82,45.03 139.95,49.16 155.71,49.16 159.59,45.28 186.31,45.28 189.83,48.8 196.77,48.8 199.11,51.14 199.11,54.56 203.43,58.87 203.43,61.38 202.26,62.56 202.26,66.29 202.67,66.7 202.67,71.33 201.75,72.24 201.75,73.55 202.54,74.33 202.54,77.13 204.65,79.24 205.2,79.24 206.49,80.54 206.49,83.93 206.76,84.2 207.39,84.2 208.02,84.83 208.02,85.95 210.16,88.1 210.16,94.92 209.6,95.48 209.02,95.48 v2(208.56,95.94)
  IN2 w0.254: v2(34.88,38.09) 34.48,38.09 34.17,38.41 31.84,38.41 28.6,41.65 21.29,41.65 v2(20.78,42.15)
  IN3 w0.254: v2(34.88,38.09) 35.33,38.09 35.77,38.52 36.15,38.52 37.16,37.51 37.16,37.48 39.65,37.48 40.58,38.41 42.87,38.41 43.5,39.04 44.97,39.04 v2(45.68,38.34)
  BOTTOM w0.254: v2(34.88,38.09) PR743.2
ACAVDK_SRC: length 2.5
  TOP w0.254: PU800.4 20.41,31.38 21.14,30.65 PR842.2
ACAVIN: length 2.5
  TOP w0.254: PR851.2 23.26,30.93 22.41,31.78 PU800.8
ALW_PWRGD_3V_5V: length 276.4
  TOP w0.102: v2(180.1,84.81) 179.64,84.36 179.64,81.36 180.25,80.75 180.25,79.7 178.98,78.43 172.56,78.43 171.39,77.26 RZ51.1 ; RE283.2 216.34,85.54 213.17,85.54 v2(212.58,86.13) ; v1(39.98,28.27) 40.87,28.27
  TOP w0.254: 40.87,28.27 PR108.1 41.73,28.01 v2(42.1,27.64)
  IN2 w0.122: v2(212.58,86.13) 212.17,85.73 212.17,85.19 211.41,84.43 211.41,80.58 210.88,80.04 210.88,77.97 208.9,76 204.98,76 204.79,75.81 204.79,74.34 204.22,73.77 204.22,65.73 205.7,64.24 205.7,62.92 206.45,62.17 206.45,58.4 205.93,57.87 205.93,56.4 197.58,48.06 190.14,48.06 186.62,44.53 156.75,44.53 152.7,48.58 140.42,48.58 136.3,44.47 80.14,44.47 71.76,36.08 56.3,36.08 55.57,36.82 54.4,36.82 v2(53.71,36.12)
  IN3 w0.122: v2(212.58,86.13) 211.4,87.31 204.39,87.31 204.05,87.64 200.89,87.64 200.74,87.79 199.72,87.79 198.79,86.86 192.33,86.86 190.25,84.79 188,84.79 186.58,86.21 181.5,86.21 180.15,84.86 180.15,84.86 v2(180.1,84.81) ; v2(42.1,27.64) 42.74,28.27 47.46,28.27 51.31,32.12 51.31,35.58 51.85,36.12 v2(53.71,36.12)
ALW_PWRGD_3V_5V_EC: length 6.5
  TOP w0.102: UE2.A1 211.28,88.25 211.74,87.8 213.01,87.8 213.13,87.93 215.78,87.93 216.11,87.6 216.11,87.12 RE283.1
ALWON: length 205
  TOP w0.102: PR113.1 v1(53.51,29.14) ; UE2.A60 207.37,86.03 v2(207.61,85.79)
  TOP w0.254: v2(52.52,30.55) PR113.1
  IN1 w0.084: v2(53.06,37.01) 52.52,36.47 v2(52.52,30.55)
  IN2 w0.122: v2(207.61,85.79) 205.05,83.23 205.05,81.21 204.76,80.93 204.76,79.71 202.29,77.23 202.29,74.43 201.51,73.65 201.51,72.14 201.71,71.94 201.71,66.57 202.01,66.27 202.01,62.46 203.18,61.28 203.18,58.98 198.85,54.64 198.85,51.23 196.67,49.05 189.73,49.05 186.21,45.53 159.7,45.53 155.82,49.41 139.84,49.41 135.72,45.28 79.75,45.28 71.46,36.99 57.05,36.99 56.4,37.64 53.69,37.64 v2(53.06,37.01)
ANTCTL0: length 183.1
  TOP w0.102: v1(218.71,54.89) 219.2,55.39 v2(219.2,55.87)
  IN3 w0.122: v2(127.4,120.78) 130.37,120.78 130.9,121.31 138.21,121.31 141.07,124.17 151.86,124.17 153.34,122.69 168.76,122.69 170.57,120.88 182.57,120.88 188.11,115.34 192.56,115.34 193.97,116.74 203.52,116.74 204.4,117.62 212.54,117.62 212.98,117.18 214.55,117.18 216.87,119.5 221.36,119.5 221.56,119.31 222.85,119.31 223.44,119.9 225.83,119.9 228.36,117.37 228.36,115.58 227.12,114.33 227.12,91.62 228.98,89.76 228.98,80.66 229.29,80.35 229.29,67.9 225.35,63.96 225.35,62.36 224.6,61.61 221.74,61.61 221.23,61.1 221.23,58.47 219.65,56.89 219.65,56.32 v2(219.2,55.87)
  BOTTOM w0.102: JANT1.3 128.02,120.15 v2(127.4,120.78) ; JNGFF2.51 218.7,57.11 218.77,57.04 218.77,56.3 v2(219.2,55.87)
ANTCTL1: length 165.3
  TOP w0.102: v1(219,58.16) 219,57.25 v2(219.2,57.05)
  IN3 w0.122: v2(129.14,119.07) 129.7,119.63 132.86,119.63 133.6,120.36 138.5,120.36 141.43,123.29 151.49,123.29 153.06,121.72 160.91,121.72 163.95,118.68 163.95,115.29 164.2,115.04 164.2,114.3 165.4,113.1 173.92,113.1 176.54,110.48 179.1,110.48 180.51,109.07 187.59,109.07 188.07,108.6 191,108.6 193.65,105.95 198.5,105.95 200.35,107.81 206.01,107.81 206.79,108.59 215.48,108.59 216.41,107.66 216.41,106.5 218.35,104.55 218.35,102.43 222.05,98.72 222.05,95.95 228.43,89.57 228.43,86.99 227.93,86.49 227.93,79.91 228.72,79.12 228.72,70.64 228.03,69.95 228.03,67.16 225.1,64.24 225.1,62.46 224.5,61.86 221.64,61.86 220.98,61.2 220.98,58.57 219.46,57.05 v2(219.2,57.05)
  BOTTOM w0.102: v2(129.14,119.07) 128.82,119.38 JANT1.4 ; JNGFF2.53 v2(219.2,57.05)
ANTCTL2: length 167
  TOP w0.102: v1(220,56.12) 219.66,56.47 v2(219.2,56.47)
  IN3 w0.122: v2(128.97,117.72) 134.56,117.72 135.13,118.29 138.81,118.29 141.99,121.47 160.81,121.47 163.71,118.57 163.71,115.18 163.95,114.94 163.95,114.2 164.19,113.96 165.3,112.85 173.82,112.85 176.44,110.23 178.92,110.23 180.32,108.82 187.49,108.82 187.96,108.35 190.9,108.35 193.55,105.7 198.6,105.7 200.46,107.56 206.11,107.56 206.89,108.34 215.37,108.34 216.16,107.56 216.16,106.39 218.1,104.45 218.1,102.32 221.8,98.62 221.8,95.85 228.19,89.47 228.19,87.1 227.68,86.59 227.68,79.81 228.47,79.02 228.47,70.74 227.78,70.05 227.78,67.27 224.85,64.34 224.85,62.56 224.39,62.11 221.54,62.11 220.73,61.3 220.73,59.18 218.78,57.23 218.78,56.71 219.03,56.47 v2(219.2,56.47)
  BOTTOM w0.102: JNGFF2.55 219.7,56.96 v2(219.2,56.47) ; v2(128.97,117.72) 128.97,117.87 129.62,118.53 JANT1.5
ANTCTL3: length 179.3
  TOP w0.102: v2(130.14,121.47) 130.32,121.47 v1(130.69,121.1)
  IN3 w0.122: v2(130.14,121.47) 130.24,121.56 138.1,121.56 141.56,125.02 151.36,125.02 152.07,124.31 167.49,124.31 170.67,121.13 182.67,121.13 188.22,115.59 192.46,115.59 193.86,116.99 203.36,116.99 204.24,117.87 212.64,117.87 213.08,117.43 214.44,117.43 216.77,119.75 221.46,119.75 221.66,119.56 222.75,119.56 223.34,120.15 225.94,120.15 228.61,117.48 228.61,115.47 227.37,114.23 227.37,91.73 229.23,89.86 229.23,80.78 229.54,80.46 229.54,67.73 225.63,63.82 225.63,62.28 224.7,61.36 221.95,61.36 221.48,60.89 221.48,58.03 v2(220.09,56.64)
  BOTTOM w0.102: v2(130.14,121.47) 130.61,121 130.61,120.56 130.42,120.38 JANT1.6 ; v2(220.09,56.64) 220.2,56.75 JNGFF2.57
AUD_HP_NB_SENSE: length 96.5
  TOP w0.102: v2(197.91,64.76) v1(197.91,64.2) 197.91,63.87 198.19,63.59 199.2,63.59 CA41.1 199.97,63.12 QA1.2 ; JIO1.20 220.1,68.7 v2(219.9,68.51) ; UE1.A41 188.17,101.84 v2(188.69,102.36)
  IN1 w0.084: v2(197.91,64.76) 198.56,64.76 199.67,65.87 199.67,68.89 195.95,72.61 195.06,72.61 194.58,73.08 190.38,73.08 187.87,75.59 177.76,75.59 v2(177.66,75.49)
  IN2 w0.122: v2(188.69,102.36) 187.79,101.45 187.79,94 186.78,92.99 186.78,92.1 186.43,91.74 186.43,89.95 185.01,88.54 185.01,79.3 181.41,75.69 177.86,75.69 v2(177.66,75.49)
  IN3 w0.122: v2(219.9,68.51) 219.81,68.42 218.13,68.42 217.24,67.53 217.24,65.73 216.16,64.65 216.16,64.65 215.57,64.06 215.57,64.06 213.24,61.73 209.64,61.73 209.27,62.11 206.76,62.11 204.1,64.76 v2(197.91,64.76)
AUD_HP_OUT_L: length 32.9
  TOP w0.305: JIO1.30 220.7,73.7 220.7,74.24 220.64,74.3 v2(220.64,74.41)
  TOP w0.381: v2(208.08,63.3) 207.29,63.3 206.34,64.25 CA43.2 ; v2(213.97,72.67) 213.39,72.09 RA24.1 RA7.2
  IN1 w0.381: v2(208.08,63.3) 209.67,63.3 211.55,65.18 214.33,65.18 215.46,66.31 215.46,68.33 216.33,69.21 217.92,69.21 221.35,72.63 221.35,73.76 220.7,74.41 v2(220.64,74.41) 220.38,74.15 219.69,74.15 218.34,72.8 214.1,72.8 v2(213.97,72.67)
AUD_HP_OUT_R: length 22.1
  TOP w0.305: JIO1.22 220.12,69.7 219.79,70.03 v1(219.37,70.03) 218.57,70.03 v2(218.11,70.49)
  TOP w0.381: CA44.2 207.56,64.3 v2(207.91,63.95) ; v2(213.93,70.48) 213.39,71.02 RA25.1 RA8.2
  IN1 w0.381: v2(207.91,63.95) 207.91,64.42 209.78,66.28 214.19,66.28 214.7,66.79 214.7,68.95 213.93,69.71 v2(213.93,70.48) 215.2,70.48 215.55,70.13 217.72,70.13 218.07,70.49 v2(218.11,70.49)
AUD_NB_MUTE#: length 78
  TOP w0.102: v1(214.05,78.44) 214.4,78.79 v2(214.4,79) ; UE1.A39 188.4,100.84 188.43,100.8 188.97,100.8 v2(189.33,101.17) ; UA1.48 204.28,74.21 204.21,74.29 204.07,74.29 202.8,75.56 201.74,75.56 201.45,75.85 201.2,75.85 CA31.1 200.42,76.24 RA18.2 v2(198.29,78.38) ; QA2.2 v2(218.59,75.07)
  IN2 w0.122: v2(184.38,77.73) 185.26,78.61 185.26,88.43 186.68,89.85 186.68,91.64 187.03,91.99 187.03,92.89 188.04,93.9 188.04,100.29 188.5,100.75 188.92,100.75 v2(189.33,101.17)
  IN3 w0.122: v2(184.38,77.73) 185.22,78.56 189.9,78.56 190.64,79.3 197.11,79.3 198.03,78.38 v2(198.29,78.38) 198.57,78.38 200.78,80.58 203.33,80.58 206.7,77.21 209.1,77.21 210.3,78.41 214.2,78.41 214.4,78.62 v2(214.4,79)
  IN4 w0.084: v2(214.4,79) 216.07,77.33 218.01,77.33 218.59,76.75 v2(218.59,75.07)
AUD_OUT_L: length 2.2
  TOP w0.203: RA7.1 211.43,71.77 UA1.33
AUD_OUT_R: length 2.2
  TOP w0.203: UA1.32 v1(210.71,71.37) 211.4,71.37 RA8.1
AUD_PC_BEEP: length 3.5
  TOP w0.102: CA28.2 CA27.2 202.61,67.34 203.43,68.16 UA1.12
AUD_SENSE_A: length 5.3
  TOP w0.102: UA1.13 204.28,67.3 204.16,67.17 203.18,67.17 v1(202.71,66.71) 202.45,66.45 202.45,65.84 202.39,65.78 201.23,65.78 201.12,65.66 QA1.1
AUD_SENSE_B: length 21.7
  TOP w0.203: 204.47,66.92 204.68,67.13 UA1.14
  TOP w0.254: 204.47,66.92 204.41,66.86 203.44,66.86 202.76,66.17 202.76,65.71 202.44,65.4 202.44,63.17 202.83,62.77 v1(202.83,62.17) 202.83,61.28 202.69,61.14 ; 202.69,61.14 v2(202.69,61.18) ; 202.69,61.14 202.69,60.58 203.13,60.15 RA38.1 204.27,60.15 RA28.1 ; v2(210.02,59.62) 210.31,59.62 210.49,59.79 210.49,61.55 210.05,61.99 RA27.1
  IN3 w0.254: v2(202.69,61.18) 203.62,60.25 208.35,60.25 208.98,59.62 v2(210.02,59.62)
AUX_EN_WOWL: length 120.6
  TOP w0.102: UZ2.3 191.8,43.7 191.76,43.65 191.76,43.14 191.87,43.02 RZ38.2 190.11,42.64 v1(188.7,44.05) 188.15,44.59 188.15,45.47 v2(188.46,45.77) ; v2(179.07,105.4) 179.07,105.72 178.94,105.85 UE1.B67 ; UZ11.1 175.59,111.12 174.73,110.25 v2(174.73,109.58)
  IN2 w0.122: v2(179.07,105.4) 179.72,105.4 184.6,100.51 184.6,98.97 184.45,98.82 184.45,96.2 185.43,95.23 185.43,93.79 183.54,91.91 183.54,89.89 182.21,88.57 182.21,79.77 181.03,78.59 173.3,78.59 170.36,75.65 170.36,74.21 167.29,71.13 167.29,70.34 165.95,69.01 165.95,67.47 164.96,66.48 164.14,66.48 163.46,65.8 163.46,62.48 161.94,60.96 161.94,60.52 160.62,59.2 160.62,52.16 162.9,49.88 v2(162.9,49.77)
  IN3 w0.122: v2(188.46,45.77) 188.46,47.59 186.3,49.74 162.94,49.74 v2(162.9,49.77) ; v2(179.07,105.4) 179.07,105.97 178.12,106.91 177.07,106.91 174.73,109.25 v2(174.73,109.58)
B-RAMP: length 4
  TOP w0.102: v2(91.89,100.83) 91.99,100.83 v1(92.47,100.35)
  TOP w0.203: v2(91.89,100.83) PR507.2
  BOTTOM w0.203: PR502.1 92.46,101.4 v2(91.89,100.83) 91.76,100.7 PU500.11
B_DE0: length 4.7
  TOP w0.102: UI7.3 222.07,81.96 221.06,82.97 v1(221.06,83.7) 220.57,84.19 RI18.2 RI22.1
B_DE1: length 3.6
  TOP w0.102: UI7.6 222.07,80.46 221.35,79.74 v1(221.12,79.74) RI23.1 RI19.2
B_EQ0: length 6.6
  TOP w0.102: UI7.2 222.05,82.46 221.39,83.12 221.39,84.46 220.69,85.16 220.69,85.45 RI16.2 RI20.1 v1(220.17,87.79)
B_EQ1: length 3.7
  TOP w0.102: RI25.2 RI24.1 220.96,82.41 v1(221.11,82.26) 221.91,81.46 UI7.4
BAT1_LED#: length 60.4
  TOP w0.102: v2(201.08,119.46) 199.56,120.98 199.56,121.92 199.09,122.39 199.09,122.95 198.35,123.69 196.38,123.69 195.52,122.83 189.56,122.83 v1(189.41,122.67) 189.17,122.43 RZ44.1 189.58,121.66 189.8,121.43 189.8,120.39 190.06,120.13 QZ5.1 ; UE2.B1 210.53,88 211.22,87.32 v2(212.42,87.32)
  BOTTOM w0.102: v2(201.08,119.46) 201.08,118.52 202.48,117.12 202.48,111.85 203.46,110.87 203.46,103.8 203.8,103.46 206.33,103.46 206.67,103.11 207.91,103.11 208.73,102.29 208.73,102.01 209.15,101.59 209.15,99.5 210.96,97.69 210.96,88.29 211.38,87.86 211.88,87.86 v2(212.42,87.32)
BAT1_LED#_Q: length 2.2
  TOP w0.102: v1(192.53,122.3) RZ28.1 192.53,121.33 QZ5.6
BAT2_LED#: length 46.8
  TOP w0.102: RZ43.1 190.88,117.72 192,118.83 QZ5.4 192.88,118.83 193.11,118.61 193.11,118.42 v2(193.26,118.26) ; v2(204.66,85.14) 205.12,85.61 205.12,85.94 204.87,86.2 UE2.A55
  BOTTOM w0.102: v2(193.26,118.26) v1(195.89,118.26) 197.96,118.26 199.78,116.44 199.78,108.87 199.76,108.85 199.76,103.11 199.95,102.93 199.95,98.64 200.37,98.22 200.37,92.59 201.44,91.52 202.46,91.52 203.04,90.94 203.04,89.55 203.25,89.34 203.25,87.91 204.21,86.96 204.21,85.6 v2(204.66,85.14)
BAT2_LED#_Q: length 3.3
  TOP w0.102: QZ5.3 190.09,118.83 189.87,119.05 189.87,119.75 RZ25.1 v1(188.36,120.32)
BATDRV#: length 41.4
  TOP w0.254: PQ800.4 10.48,55.62 v1(8.72,53.86) 8.07,53.2 v2(8.07,51.43) ; PR722.2 32.62,41.62 32.21,41.62 v2(31.84,41.25)
  IN3 w0.254: v2(31.84,41.25) 31.49,41.61 25.35,41.61 24.48,40.73 19.02,40.73 18.34,41.41 18.34,41.41 15.98,43.77 15.98,50.36 13.95,52.39 9.03,52.39 v2(8.07,51.43)
BATT_WHITE#: length 86.1
  TOP w0.102: LED7.1 263.28,130.34 255.92,122.98 v1(255.92,122.41) 255.92,121.85 v2(255.59,121.52) ; v2(187.87,119.88) 188.34,119.41 RZ25.2
  IN3 w0.122: v2(255.59,121.52) 251.34,121.52 250.88,121.97 242.72,121.97 241.39,120.65 219.92,120.65 219.52,120.25 216.54,120.25 214.58,118.28 212.93,118.28 212.82,118.4 203.65,118.4 203.04,117.78 201.97,117.78 201.66,118.09 194.45,118.09 193.86,118.68 189.08,118.68 v2(187.87,119.88)
BATT_WHITE_LED#: length 100.2
  TOP w0.102: RZ43.2 188.72,117.02 188.53,116.83 185.87,116.83 184.6,118.1 182.12,118.1 181.49,118.74 v1(179.95,118.74) 175.52,118.74 173.68,116.89 v2(173.68,111.12)
  IN3 w0.122: v2(173.68,111.12) 172.19,112.6 165.2,112.6 163.7,114.09 163.7,114.83 163.46,115.08 163.46,118.47 160.71,121.22 142.09,121.22 138.18,117.3 128.53,117.3 126.28,115.05 119.27,115.05 115.6,118.71 113.75,118.71 v2(113.34,119.13)
  BOTTOM w0.102: JLED1.2 116.81,119.35 115.91,120.25 114.34,120.25 113.34,119.24 v2(113.34,119.13)
BATT_YELLOW#: length 78.8
  TOP w0.102: v2(194.41,121.81) 193.93,121.34 RZ28.2 ; LED7.3 263.62,131.04 254.64,122.06 254.22,122.06 v2(254.15,122.13)
  IN3 w0.122: v2(254.15,122.13) 253.91,121.89 251.32,121.89 250.98,122.22 242.51,122.22 241.18,120.89 219.82,120.89 219.42,120.5 216.44,120.5 214.48,118.53 213.69,118.53 213.33,118.89 197.33,118.89 v2(194.41,121.81)
BATT_YELLOW_LED#: length 100.9
  TOP w0.102: RZ44.2 186.49,119.89 176.1,119.89 v1(175.84,119.63) 173.04,116.83 v2(173.04,111.12)
  IN3 w0.122: v2(173.04,111.12) 171.81,112.35 165.09,112.35 163.45,113.99 163.45,114.73 163.21,114.98 163.21,118.37 160.6,120.97 142.2,120.97 138.28,117.05 128.64,117.05 126.38,114.8 119.17,114.8 115.5,118.46 113.38,118.46 112.75,119.09 v2(112.75,119.13)
  BOTTOM w0.102: JLED1.3 117.61,119.45 116.59,120.48 114.1,120.48 v2(112.75,119.13)
BBS_BIT: length 1.3
  TOP w0.089: v2(134.47,84.57) 134.5,84.55 T109.1
  BOTTOM w0.076: UC1.L8 134.47,84.17 v2(134.47,84.57)
BC_CLK_ECE1117: length 69.5
  TOP w0.102: v2(199.65,53.14) 201.3,53.14 201.92,53.76 201.92,54.49 201.85,54.55 JKBTP1.10 ; UE2.A20 207.87,97.99 v2(207.71,98.15)
  IN4 w0.084: v2(199.65,53.14) 198.78,54 198.78,54.38 198.63,54.54 198.63,56.1 198.31,56.42 198.31,57.03 198.45,57.17 198.45,57.93 198.36,58.02 198.36,62.09 198.78,62.51 198.78,67.41 197.98,68.22 197.98,70.23 197.38,70.84 197.38,74.66 196.4,75.64 196.4,77 191.65,81.75 191.65,83.61 194.27,86.23 194.27,91 195.43,92.15 195.43,93.5 196.22,94.29 199.05,94.29 199.17,94.17 200.03,94.17 200.54,94.67 200.54,96.07 201.49,97.02 206.58,97.02 v2(207.71,98.15)
  BOTTOM w0.102: v2(199.65,53.14) 199.84,53.14 200.85,54.16 200.85,54.27 202.34,55.76 v1(202.54,55.76)
BC_CLK_ECE5048: length 22.9
  TOP w0.102: v2(199.42,90.56) 199.61,90.75 UE2.A43 ; UE1.A30 185.19,95.33 184.76,94.91 v2(184.76,94.91)
  IN1 w0.084: v2(199.42,90.56) 199.37,90.52 198.41,90.52 198.05,90.15 195.33,90.15 194.84,89.67 192.05,89.67 190.62,91.1 187.2,91.1 185.94,89.84 185.63,89.84 185.3,90.17 185.3,93.7 185.11,93.89 185.11,94.56 184.76,94.91 v2(184.76,94.91)
BC_DAT_ECE1117: length 135.8
  TOP w0.102: v2(213.24,87.32) 213.47,87.08 RPE5.2 ; v2(207.59,95.35) 207.59,95.35 207.99,95.75 207.99,96.14 208.12,96.26 UE2.B21 ; v2(199.75,53.73) 200.58,53.73 200.85,54 JKBTP1.8
  IN3 w0.122: v2(213.24,87.32) 214.71,87.32 215.76,88.37 217.12,88.37 217.52,88.76 224,88.76 224.91,87.85 225.87,87.85 226.64,87.08 226.64,79.44 227.47,78.6 227.47,76.2 226.87,75.6 226.87,70.25 226.87,70.24 226.87,67.96 224.19,65.28 220.22,65.28 219.31,64.37 219.31,62.78 217.37,60.84 217.37,59.3 215.62,57.56 206.68,57.56 203.92,54.8 200.82,54.8 v2(199.75,53.73)
  IN4 w0.084: v2(207.59,95.35) 207.2,95.35 207.1,95.45 207.1,96.07 206.49,96.68 201.63,96.68 200.87,95.93 200.87,94.53 199.62,93.27 198.76,93.27 198.16,93.87 197.66,93.87 194.61,90.82 194.61,86.09 192.01,83.5 192.01,81.86 196.73,77.14 196.73,75.78 197.71,74.8 197.71,70.98 198.32,70.37 198.32,68.35 199.12,67.55 199.12,62.37 198.7,61.95 198.7,58.16 198.79,58.07 198.79,57.03 198.65,56.89 198.65,56.56 198.97,56.24 198.97,54.68 199.12,54.52 199.12,54.14 199.53,53.73 v2(199.75,53.73)
  BOTTOM w0.102: v1(200.69,55.85) 200.69,54.67 v2(199.75,53.73)
BC_DAT_ECE5048: length 25.6
  TOP w0.102: RE36.2 184.93,94.05 185.28,94.4 v2(185.84,94.4) 186.01,94.4 v1(186.38,94.77) ; v2(201.69,90.84) 201.45,90.84 201.28,91 UE2.B45 ; UE1.B31 184.94,97.65 v2(184.91,97.68)
  IN1 w0.084: v2(185.84,94.4) 187.79,94.4 191.65,90.54 195.84,90.54 196.91,91.61 200.91,91.61 v2(201.69,90.84)
  IN2 w0.122: v2(184.91,97.68) 184.91,96.1 185.84,95.17 v2(185.84,94.4)
BC_INT#_ECE1117: length 56.7
  TOP w0.102: UE2.A19 208.37,98.14 v2(208.39,98.16) ; v1(200.12,56.16) 200.12,56.01 200.35,55.77 JKBTP1.7 200.35,54.67 199.99,54.31 v2(199.6,54.31)
  IN2 w0.122: v2(208.39,98.16) 208.39,97.69 210.41,95.67 210.41,87.85 209.62,87.06 209.62,86.67 210.09,86.19 210.09,84.64 209.37,83.92 209.37,78.36 208.26,77.24 203.41,77.24 202.78,76.62 202.78,73.84 202.92,73.71 202.92,66.6 202.5,66.19 202.5,62.66 203.72,61.44 203.72,58.73 201.5,56.51 201.5,56.21 v2(199.6,54.31)
BC_INT#_ECE5048: length 26.6
  TOP w0.102: UE1.A29 184.69,95.41 183.71,94.43 v2(183.71,94.1) ; v2(199.33,91.15) 199.43,91.25 UE2.A42
  IN2 w0.122: v2(183.71,94.1) 181.66,92.05 v2(181.66,91.27)
  IN3 w0.122: v2(181.66,91.27) 181.79,91.14 181.79,91.03 183.16,89.65 185.93,89.65 187.59,91.31 190.31,91.31 191.01,90.61 198.78,90.61 v2(199.33,91.15)
BCM5882_ALERT#: length 133.8
  TOP w0.102: v2(181.41,105.48) 181.44,105.51 UE1.B62 ; v2(209.48,42.92) v1(209.48,42.05) ; v2(218.77,43.16) 219.3,43.68 JUSH1.14
  IN1 w0.084: v2(209.48,42.92) 209.54,42.98 213.04,42.98 213.31,42.71 218.33,42.71 v2(218.77,43.16)
  IN2 w0.122: v2(223.41,92.99) 224.06,92.35 224.06,89.84 225.54,88.36 225.54,86.48 227.94,84.08 227.94,79.71 229.07,78.58 229.07,70.88 227.59,69.4 227.59,63.8 221.75,57.96 211.26,57.96 209.11,55.81 209.11,43.28 v2(209.48,42.92)
  IN3 w0.122: v2(223.41,92.99) 223.41,93.51 221.31,95.62 221.31,98.39 217.57,102.12 217.57,104.27 214,107.84 207.1,107.84 206.23,106.98 200.58,106.98 198.81,105.21 193.24,105.21 192.48,105.97 189.49,105.97 188.72,106.73 182.67,106.73 v2(181.41,105.48)
BEEP: length 42.1
  TOP w0.102: v2(202.25,66.93) 202.19,66.87 202.19,66.16 202.03,66.01 201.14,66.01 200.78,65.65 199.27,65.65 198.88,66.03 RA13.2 198.44,66.47 v1(197.98,66.02) ; v2(208.83,94.76) 208.83,95.57 209.12,95.86 UE2.B19
  BOTTOM w0.102: v2(202.25,66.93) 203.55,68.24 203.55,75.75 206.52,78.72 208.42,78.72 209.02,79.31 209.02,83.61 209.68,84.27 209.68,86.23 208.03,87.88 208.03,90.22 206.86,91.39 206.86,92.66 207.8,93.6 207.8,94 208.56,94.76 v2(208.83,94.76)
BIA_PWM: length 3.7
  TOP w0.102: DV1.1 100.22,118.88 v1(100.22,118.49) RV1.1 100.21,117.4 LV1.2
BIA_PWM_EC: length 133.3
  TOP w0.102: UE2.B25 206.12,95.86 v2(205.62,95.35) ; v2(103.62,123.25) v1(102.76,122.39) 101.9,121.53 DV1.2
  IN3 w0.122: v2(195.42,121.83) 194.68,122.56 190.88,122.56 190.72,122.4 171.67,122.4 168.74,125.32 163.99,125.32 163.45,125.86 157.42,125.86 157.09,126.19 156.21,126.19 155.96,126.44 151.47,126.44 150.49,127.42 142.58,127.42 140.12,124.97 133.97,124.97 133.1,124.1 128.61,124.1 124.72,120.21 108.98,120.21 108.17,121.02 105.85,121.02 v2(103.62,123.25)
  BOTTOM w0.102: v2(195.42,121.83) 195.42,121.56 200.85,116.13 200.85,107.81 201.86,106.81 201.86,103.04 203.31,101.59 203.31,99.93 204.27,98.97 204.27,98.23 205.02,97.48 205.02,95.95 v2(205.62,95.35)
BLUE_DOCK: length 23.3
  TOP w0.102: RV78.1 152.35,127.94 v2(152.86,127.44)
  IN2 w0.122: v2(152.86,127.44) 152.44,127.85 152.05,127.85 151.58,127.38 151.58,126.54 151.26,126.23 151.26,119.27 149.29,117.3 149.29,116.77 148.47,115.94 148.47,113.63 v2(146.92,112.08)
  BOTTOM w0.102: JDOCK1.45 152.75,127.54 v2(152.86,127.44) ; UV8.M8 147.88,112.71 147.25,112.08 v2(146.92,112.08)
BOARD_ID: length 12.6
  TOP w0.102: v2(215.05,96.89) 215.36,96.89 215.71,96.54 CE40.1 RE79.2 v1(216.6,97.13) ; UE2.B10 209.94,92.5 209.8,92.65 209.16,92.65 208.93,92.88 v2(208.93,93.1)
  IN1 w0.084: v2(208.93,93.1) 209.28,93.45 210.75,93.45 211.39,94.1 212.47,94.1 213.24,94.86 213.24,95.06 213.54,95.37 213.87,95.37 214.51,96 214.51,96.35 v2(215.05,96.89)
BOOT_1.35V:
  vias: v1(80,16.82)
BQ24770_REGN: length 30.2
  TOP w0.102: v2(37.32,44.07) 37.32,44.21 v1(36.97,44.55)
  TOP w0.254: PR725.1 32.71,39.51 v2(32.49,39.3)
  TOP w0.508: v2(40.73,37.38) 41.05,37.7 PR713.1
  IN1 w0.508: v2(40.73,37.38) 40.88,37.38 42.23,38.73 42.23,40.06 42.83,40.66 42.83,45.43 42.34,45.91 38.48,45.91 37.32,44.75 v2(37.32,44.07) 37.32,43.57 36.93,43.18 34.36,43.18 32.84,41.67 32.84,39.65 v2(32.49,39.3)
  BOTTOM w0.254: PR799.2 33.15,39.96 v2(32.49,39.3)
