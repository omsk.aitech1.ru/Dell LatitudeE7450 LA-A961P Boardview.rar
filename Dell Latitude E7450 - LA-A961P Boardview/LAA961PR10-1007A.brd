# Allegro board LAA961PR10-1007A.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
USB3RN4: length 143.6
  IN1 w0.091: v2(130.56,109.78) 130.97,110.19 131.82,110.19 136.09,114.47 147.69,114.47 149.35,116.13 155.31,116.13 156.03,115.41 158.14,115.41 159.68,116.94 177.34,116.94 178.02,117.62 180.77,117.62 181.82,116.57 202.44,116.57 203.11,117.25 217.39,117.25 219.09,118.94 224.09,118.94 224.92,118.11 224.92,117.26 v2(224.61,116.94)
  IN4 w0.084: v2(130.1,87.32) 129.87,87.09 129.79,87.09 129.69,87.18 129.69,88.25 128.86,89.08 127.57,89.08 125.39,91.26 125.39,94.53 125.04,94.89 124.1,94.89 123.18,95.81
  IN4 w0.091: v2(130.56,109.78) 130.43,109.91 130.24,109.91 130.11,109.78 130.11,108.32 130.79,107.64 130.79,105.25 129.03,103.5 126,103.5 124.79,104.7 122.11,104.7 121.67,104.26 121.67,97.32 123.18,95.81
  BOTTOM w0.089: v2(130.1,87.32) 130.43,87 UC1.F15
  BOTTOM w0.102: v2(224.61,116.94) 224.98,117.31 224.98,117.65 224.44,118.19 224.44,118.93 224.32,119.05 223.89,119.05 223.8,119.14 LI9.1
USB3RN4_D-: length 10.3
  BOTTOM w0.102: JUSB2.5 225.77,128.54 225.96,128.35 225.96,127.92 226.46,127.43 226.46,126.39 226.23,126.17 224.6,126.17 224.12,125.69 224.12,124.68 223.98,124.54 DI6.1 DI6.9 223.98,122.75 224.12,122.61 224.12,122.01 223.8,121.69 LI9.2
USB3RP1: length 53.7
  TOP w0.102: UI4.4 128.93,128.37 129.03,128.28 129.03,127.79 v2(128.85,127.62)
  IN4 w0.091: v2(128.85,127.62) 128.85,126.98 128.51,126.63 128.51,120.15 127.9,119.54 127.9,117.71 128.51,117.11 128.51,113.8 129.38,112.92 129.38,112.26 129.66,111.99 129.66,110.49 128.51,109.34 126.68,109.34 125.63,108.28 123.33,108.28 120.86,105.81 120.86,96.94 122.96,94.84 122.96,92.96 126.17,89.75 126.17,86.69 126.68,86.17 127.09,86.17 v2(127.25,86.02)
  BOTTOM w0.076: v2(127.25,86.02) 127.57,85.69 UC1.H20
USB3RP1_D+: length 10.9
  TOP w0.102: JUSB1.6 63.39,128.54 63.26,128.41 63.26,128.02 63.87,127.41 63.87,126.53 65.53,124.87 v4(65.53,124.37) 65.53,123.71 65.66,123.59 DI1.8 DI1.2 65.66,122.16 65.22,121.72 65.22,120.58 65.51,120.28 LI1.2
USB3RP2: length 116.6
  TOP w0.102: CI32.1 224.29,86.79 224.29,86.93 v2(224.46,87.1)
  IN1 w0.084: 128.76,88.79 128.76,88.77 128.76,88.77 128.76,88.72 128.76,88.72 128.76,87.03 128.61,86.88 128.41,86.88 v2(128.2,86.67)
  IN1 w0.091: 128.76,88.79 128.76,90.52 129.07,90.83 129.07,93.29 131.22,95.44 131.71,95.44 132.73,96.46 136.95,96.46 137.23,96.19 139.65,96.19 140.08,95.77 147.33,95.77 148.46,96.9 157.04,96.9 157.9,96.04 170.33,96.04 175,91.37 175.65,91.37 176.01,91.01 177.96,91.01 180.33,88.64 183.13,88.64 187.97,83.8 190.55,83.8 192.04,82.3 197.76,82.3 198.45,82.99 199.68,82.99 200.98,81.69 203.3,81.69 205.5,83.89 208.7,83.89 209.8,82.78 210.22,82.78 210.59,82.42 213.44,82.42 214.24,83.22 221.11,83.22 224.27,86.38 224.27,86.91 v2(224.46,87.1)
  BOTTOM w0.076: v2(128.2,86.67) 128.52,87 UC1.F18
USB3RP2_IO: length 17.3
  TOP w0.102: UI7.9 224.4,78.61 v4(224.79,78.22) 225.1,77.91 225.34,77.91 225.68,77.56 225.68,77.29 225.69,77.28 225.69,76.75 225.68,76.74 225.68,69.26 222.62,66.2 220.7,66.2 JIO1.15
USB3RP2_RP: length 2
  TOP w0.102: UI7.22 224.4,84.35 224.25,84.49 224.25,85.14 CI32.2
USB3RP4: length 143.6
  IN1 w0.091: v2(130.56,110.36) 131.74,110.36 136.02,114.64 147.62,114.64 149.28,116.3 155.38,116.3 156.11,115.58 158.07,115.58 159.61,117.12 177.27,117.12 177.94,117.79 180.85,117.79 181.89,116.75 202.37,116.75 203.04,117.42 217.32,117.42 219.01,119.12 224.16,119.12 225.1,118.18 225.1,117.04 v2(225.19,116.94)
  IN4 w0.084: 122.93,95.81 124.03,94.72 124.97,94.72 125.22,94.47 125.22,91.19 127.5,88.92 128.79,88.92 129.53,88.18 129.53,87.11 129.72,86.92 129.85,86.92 v2(130.1,86.67)
  IN4 w0.091: v2(130.56,110.36) 130.28,110.08 130.17,110.08 129.94,109.85 129.94,108.25 130.61,107.57 130.61,105.33 128.95,103.67 126.07,103.67 124.86,104.87 122.04,104.87 121.5,104.33 121.5,97.24 122.93,95.81
  BOTTOM w0.089: UC1.G15 130.43,86.35 v2(130.1,86.67)
  BOTTOM w0.102: LI9.4 224.65,118.28 225.19,117.74 v2(225.19,116.94)
USB3RP4_D+: length 10.3
  BOTTOM w0.102: JUSB2.6 226.35,128.54 226.19,128.38 226.19,128.02 226.68,127.52 226.68,126.29 226.33,125.94 224.69,125.94 224.35,125.59 v4(224.35,125.15) 224.35,124.73 224.48,124.59 DI6.2 DI6.8 224.48,122.74 224.35,122.61 224.35,122.04 224.65,121.73 LI9.3
USB3TN1: length 51.1
  TOP w0.102: v2(128.24,127.62) 128.07,127.79 128.07,128.45 128.13,128.52 UI4.2
  IN4 w0.091: v2(128.24,127.62) 128.24,127.03 128.03,126.83 128.03,120.44 127.41,119.82 127.41,117.49 128.03,116.87 128.03,113.6 128.37,113.26 128.37,111.22 127.62,110.47 121.34,110.47 118.16,107.29 118.16,95.68 117.05,94.57 117.05,94.27 117.18,94.14 117.3,94.14 v2(117.5,94.35)
  BOTTOM w0.076: UC1.C33 118.82,89.24 118.82,89.41 118.8,89.43 118.8,90.22 118.03,90.99 118.03,92.82 118.28,93.07 118.28,94.14 118.07,94.35 v2(117.5,94.35)
USB3TN1_C: length 1.8
  TOP w0.102: LI2.4 66.44,117.76 66.69,117.52 66.69,117.1 CI4.1
USB3TN1_D-: length 10.8
  TOP w0.102: JUSB1.8 68.89,128.54 69.04,128.39 69.04,128.09 68.33,127.38 68.33,125.63 v4(67.38,124.68) 66.81,124.11 66.81,123.8 66.66,123.65 DI1.7 DI1.4 66.66,122.19 66.83,122.01 66.83,120.65 66.44,120.26 LI2.3
USB3TN2: length 174.7
  TOP w0.102: v2(222.01,64.28) 221.82,64.09 221.39,64.09 221.29,64.2 220.7,64.2 JIO1.11
  IN1 w0.091: v2(222.01,64.28) 222.19,64.09 223.39,65.29 224.46,65.29 225.83,66.66 225.83,74.01 226.35,74.53 226.35,77.35 227.96,78.97 227.96,90.68 228.48,91.2 228.48,97.8 213.68,112.6 197.75,112.6 196.86,113.49 183.5,113.49 183.06,113.06 183.06,112.8 181.03,110.78 175.06,110.78 169.58,105.29 165.33,105.29 163.98,103.94 161.55,103.94 161.21,104.28 145.68,104.28 144.16,102.75 140.52,102.75 140.04,103.23 140.04,104.06 138.38,105.72 136.6,105.72 135.52,106.8 133.28,106.8 129.41,102.93 125.93,102.93 125.62,103.24 124.97,103.24 123.57,101.84 123.57,98.27 120.34,95.03 120.34,92.93 120,92.59 119.66,92.59 v2(119.19,92.13)
  BOTTOM w0.076: UC1.B33 119.09,89.85 119.38,90.14 119.38,90.59 118.69,91.28 118.69,92.14 118.86,92.31 119.02,92.31 v2(119.19,92.13)
USB3TN4: length 136.3
  IN1 w0.091: v2(129.19,110.68) 129.35,110.85 129.78,110.85 131.72,112.78 133.5,112.78 136.23,115.52 146.9,115.52 148.35,116.97 155.52,116.97 155.87,116.61 158.14,116.61 159.12,117.59 176.9,117.59 177.7,118.39 181.09,118.39 182.26,117.22 197.12,117.22 197.92,118.02 201.24,118.02 201.55,117.72 202.63,117.72 202.93,118.02 216.92,118.02 218.54,119.65 226.04,119.65 227.05,118.64 227.05,116.68 v2(226.84,116.47)
  IN4 w0.091: v2(129.19,110.68) 129.05,110.82 128.88,110.82 127.86,109.81 126.24,109.81 125.44,109.01 123.21,109.01 120.38,106.19 120.38,96.72 121.69,95.41 121.69,94.49 121.5,94.3 121.28,94.3 v2(121.08,94.09)
  BOTTOM w0.089: v2(121.08,94.09) 120.89,94.28 120.61,94.28 120.35,94.01 120.35,92.94 120.23,92.83 120.23,91.12 120.79,90.56 120.79,89.94 UC1.B31
  BOTTOM w0.102: v2(226.84,116.47) 226.99,116.62 226.99,116.89 CI28.2
USB3TN4_C: length 2.9
  BOTTOM w0.102: CI28.1 226.98,118.51 226.98,118.6 226.9,118.67 225.95,118.67 225.71,118.91 225.71,119.12 225.4,119.43 LI8.1
USB3TN4_D-: length 13.7
  IN1 w0.091: v2(225.57,125.38) 225.76,125.58 225.76,125.95 225.97,126.17 230.83,126.17 231.41,126.75 231.41,127.32 231.99,127.89 231.99,128.33 231.78,128.54 JUSB2.8
  BOTTOM w0.102: v2(225.57,125.38) 225.7,125.25 225.7,124.61 225.48,124.39 DI6.4 DI6.7 225.48,122.83 225.63,122.69 225.63,121.97 225.4,121.74 LI8.2
USB3TP1: length 51
  TOP w0.102: v2(127.65,127.62) 127.85,127.82 127.85,128.36 127.73,128.48 UI4.1
  IN4 w0.091: v2(117.5,93.76) 117.29,93.97 117.11,93.97 116.88,94.2 116.88,94.64 117.99,95.75 117.99,107.36 121.27,110.65 127.55,110.65 128.2,111.3 128.2,113.19 127.86,113.53 127.86,116.8 127.24,117.42 127.24,119.89 127.86,120.51 127.86,126.9 128.07,127.1 128.07,127.21 v2(127.65,127.62)
  BOTTOM w0.076: UC1.B34 118.61,89.37 118.61,90.14 117.84,90.91 117.84,92.9 118.09,93.15 118.09,94.06 117.99,94.15 117.9,94.15 v2(117.5,93.76)
USB3TP1_C: length 1.7
  TOP w0.102: LI2.1 67.29,117.8 66.91,117.41 66.91,116.87 CI5.1
USB3TP1_D+: length 10.7
  TOP w0.102: LI2.2 67.29,120.39 67.06,120.62 v4(67.06,121.29) 67.06,122.09 67.16,122.19 DI1.5 DI1.6 67.16,123.68 67.03,123.8 67.03,124.01 68.56,125.54 68.56,127.29 69.27,128 69.27,128.43 69.38,128.54 JUSB1.9
USB3TP2: length 174.7
  TOP w0.102: JIO1.10 221.2,63.7 221.38,63.88 221.82,63.88 v2(222.01,63.69)
  IN1 w0.091: v2(222.01,63.69) 222.22,63.91 222.26,63.91 223.46,65.12 224.53,65.12 226,66.59 226,73.93 226.52,74.46 226.52,77.28 228.13,78.9 228.13,90.61 228.65,91.13 228.65,97.87 213.75,112.77 197.82,112.77 196.93,113.66 183.42,113.66 182.89,113.13 182.89,112.87 180.96,110.95 174.99,110.95 169.51,105.46 165.25,105.46 163.9,104.11 161.62,104.11 161.28,104.45 145.61,104.45 144.09,102.92 140.59,102.92 140.21,103.31 140.21,104.13 138.45,105.89 136.67,105.89 135.59,106.97 133.21,106.97 129.34,103.1 126,103.1 125.69,103.41 124.9,103.41 123.4,101.92 123.4,98.34 120.16,95.1 120.16,93 119.93,92.77 v2(119.19,92.77)
  BOTTOM w0.076: v2(119.19,92.77) 118.92,92.5 118.78,92.5 118.5,92.22 118.5,91.2 119.19,90.51 119.19,90.37 UC1.A33
USB3TP4: length 136.3
  IN1 w0.091: v2(227.43,116.47) 227.22,116.68 227.22,118.71 226.11,119.82 218.47,119.82 216.85,118.2 202.86,118.2 202.56,117.89 201.62,117.89 201.32,118.2 197.85,118.2 197.05,117.39 182.33,117.39 181.17,118.56 177.62,118.56 176.82,117.76 159.04,117.76 158.07,116.79 155.94,116.79 155.59,117.14 148.27,117.14 146.83,115.69 136.16,115.69 133.43,112.96 131.65,112.96 129.71,111.02 129.43,111.02 v2(129.19,111.27)
  IN4 w0.091: v2(129.19,111.27) 128.92,111 128.81,111 127.79,109.98 126.17,109.98 125.37,109.18 123.13,109.18 120.21,106.26 120.21,96.64 121.52,95.33 121.52,94.56 121.43,94.47 121.28,94.47 v2(121.08,94.68)
  BOTTOM w0.089: UC1.A31 120.5,90.26 120.59,90.35 120.59,90.48 120.03,91.04 120.03,92.91 120.14,93.03 120.14,94.09 120.53,94.48 120.88,94.48 v2(121.08,94.68)
  BOTTOM w0.102: v2(227.43,116.47) 227.21,116.69 227.21,116.87 CI27.2
USB3TP4_C: length 2.9
  BOTTOM w0.102: LI8.4 226.25,119.45 225.92,119.12 225.92,119 226.04,118.89 226.99,118.89 227.19,118.69 227.19,118.56 CI27.1
USB3TP4_D+: length 13.8
  IN1 w0.091: JUSB2.9 232.34,128.54 232.16,128.36 232.16,127.82 231.59,127.24 231.59,126.68 230.9,125.99 226.05,125.99 225.94,125.88 225.94,125.59 226.15,125.38 v2(226.15,125.38)
  BOTTOM w0.102: v2(226.15,125.38) 225.93,125.16 225.93,124.51 225.98,124.45 DI6.5 DI6.6 225.98,122.73 225.86,122.61 225.86,122.06 226.25,121.67 LI8.3
USB_DB_DET#: length 1.1
  TOP w0.102: UE1.A2 175.87,104.84 T98.1
USB_OC0#: length 160.9
  TOP w0.089: 146.46,74.19 145.74,73.46 142.12,73.46 141.5,72.84 v2(141.5,72.59)
  TOP w0.102: v2(58.61,126.17) v1(58.61,125.64) 58.61,124.49 57.76,123.64 57.76,121.29 58.05,121 UI3.13 ; 146.46,74.19 148.02,75.74 150.82,75.74 151.13,76.06 151.13,76.19 151.49,76.55 RPC19.3
  IN2 w0.089: 145.06,78.63 145.06,74.06 144.29,73.28 142.15,73.28 141.5,72.63 v2(141.5,72.59)
  IN2 w0.122: v2(58.61,126.17) 58.99,126.55 61.28,126.55 61.67,126.15 69.23,126.15 70.93,124.45 82.2,124.45 85.69,127.94 93.23,127.94 93.96,128.67 98.43,128.67 98.9,129.15 101.54,129.15 v2(101.6,129.09) ; v2(110.02,119.08) 110.89,119.95 115.64,119.95 120.5,115.08 130.71,115.08 134.85,110.94 134.85,106.53 136.62,104.75 136.62,99.01 136.86,98.77 136.86,96.66 138.53,94.99 140.81,94.99 141.19,94.61 141.19,93.4 145.35,89.24 145.35,87.11 145.69,86.77 145.69,79.26 145.06,78.63
  BOTTOM w0.076: UC1.AL3 137.77,73.01 138.37,73.01 138.49,73.13 138.49,73.47 138.61,73.59 139.65,73.59 140.02,73.23 140.66,72.59 v2(141.5,72.59)
  BOTTOM w0.102: v2(110.02,119.08) 110.02,121.24 107.57,123.69 104.37,123.69 101.6,126.46 v2(101.6,129.09)
USB_OC1#: length 120.9
  TOP w0.102: v2(220.08,53.06) 220.08,55.42 220.5,55.84 220.5,57.09 222.82,59.42 222.82,61.14 221.77,62.2 220.7,62.2 JIO1.7 ; v2(161.48,75.38) 161.17,75.38 v1(160.9,75.11) 160.9,74.46 161.19,74.17 161.19,73.8 161.66,73.33 161.66,73.24 161.9,73.01 RPC7.7
  IN1 w0.084: v2(161.48,75.38) 161.8,75.7 163.32,75.7 163.76,75.26 163.76,74.5 164.3,73.96 164.3,67.35 165.94,65.7 165.94,65.2 167.16,63.98 167.16,63.77 168.65,62.28 171.57,62.28 173.41,60.44 183.52,60.44 184.81,59.15 188.24,59.15 188.45,58.94 198.27,58.94 199.58,57.63 205.13,57.63 207.9,54.86 207.9,53.53 210.63,50.81 215.97,50.81 217.28,52.12 219.14,52.12 v2(220.08,53.06)
  IN4 w0.084: v2(161.48,75.38) 160.31,74.21 158.92,74.21 156.9,72.19 156.9,71.58 156.39,71.07 156.15,71.07 155.03,69.95 155.03,67.97 152.63,65.57 146.3,65.57 143.69,68.18 142.3,68.18 v2(141.47,69.01)
  BOTTOM w0.076: 139.41,70.27 139.57,70.27 140.21,69.63 140.84,69.63 v2(141.47,69.01)
  BOTTOM w0.089: UC1.AT1 139.41,70.27
USB_OC2#: length 173.2
  TOP w0.102: RPC19.1 151.22,77.55 v2(150.94,77.27)
  IN2 w0.122: v2(150.94,77.27) 150.94,77.94 151.51,78.51 153.97,78.51 156.98,81.52 156.98,91.05 162.94,97.02 162.94,97.32 159.61,100.65 159.61,103.75 158.88,104.47 158.88,112.29 158.68,112.5 158.68,115 158.18,115.5 157.16,115.5 155.7,116.95 155.7,118.76 159.01,122.07 159.01,123.49 160.78,125.26 v2(160.78,127.18)
  IN4 w0.084: v2(247.44,121.53) 247.36,121.45 241.94,121.45 241.19,120.7 215.92,120.7 215.61,121.01 210.5,121.01 210.19,120.7 207.86,120.7 207.19,121.37 200.18,121.37 198.12,123.44 187.65,123.44 187.05,124.03 179.38,124.03 178.01,125.4 165.36,125.4 164.4,126.36 161.61,126.36 v2(160.78,127.18)
  BOTTOM w0.076: 146.32,75.78 145.67,75.78 144.56,74.67 143.66,74.67 142.93,75.39 139.87,75.39 139.61,75.13 139.13,75.13 139.01,75.26 138.63,75.26 138.62,75.25 138.61,75.25 UC1.AH2
  BOTTOM w0.102: v2(247.44,121.53) 247.44,123.65 247.36,123.73 245.47,123.73 245.35,123.61 UI2.5 ; v2(150.94,77.27) 150.43,77.78 148.32,77.78 v1(147.67,77.13) 147.67,76.86 146.6,75.78 146.32,75.78
USB_OC3#: length 30.3
  TOP w0.102: RPC1.8 v1(160.76,66.65) 159.86,66.65 159.05,65.84 157.23,65.84 156.4,65.01 156.4,63.95 154.88,62.44 148.68,62.44 143.75,67.37 143.75,67.78 143.52,68 143.1,68 v2(142.71,67.61)
  BOTTOM w0.076: UC1.AV3 137.62,68.96 137.95,68.63 138.67,68.63 138.68,68.62 138.98,68.62 139.58,68.02 142.3,68.02 v2(142.71,67.61)
USB_PWR_EN1#: length 88.1
  TOP w0.102: UE1.B44 186.5,102.09 v2(186.18,101.78) ; RPE9.2 194.07,103.2 v2(193.42,103.85) 193.42,104.16 v1(193.21,104.37) ; JIO1.8 220.3,62.7 219.97,63.03 219.97,63.35 v2(219.89,63.43)
  IN3 w0.122: v2(186.18,101.78) 187.59,101.78 187.74,101.63 189.79,101.63 191.19,103.03 192.6,103.03 v2(193.42,103.85) 194.63,102.64 197.47,102.64 198.13,103.31 204.03,103.31 204.33,103.6 206.26,103.6 206.69,103.17 209.06,103.17 211.72,100.51 214.49,100.51 214.86,100.87 217.88,100.87 218.89,99.86 218.89,94.57 221.32,92.13 224.46,92.13 227.43,89.16 227.43,87.58 226.89,87.04 226.89,79.54 227.72,78.71 227.72,76.1 227.12,75.5 227.12,67.83 224.32,65.03 221.78,65.03 220.18,63.43 v2(219.89,63.43)
USB_PWR_EN2#: length 76.9
  TOP w0.102: UE1.A33 188.57,97.84 v2(188.64,97.78) ; v2(218.26,99.9) 218.63,100.27 218.63,105.74 221.81,108.92 221.81,110.93 223.34,112.46 224.44,112.46 228.22,116.25 228.22,120.2 v2(232.22,124.21) ; v2(193.9,102.7) RPE9.3
  IN3 w0.122: v2(188.64,97.78) 189.08,98.23 189.47,98.23 190.55,99.3 191.96,99.3 193.17,100.52 193.17,101.97 v2(193.9,102.7) 194.21,102.39 197.57,102.39 198.24,103.06 204.13,103.06 204.43,103.35 206.16,103.35 206.59,102.92 208.11,102.92 208.37,102.67 208.37,102.65 209.43,101.59 210.21,101.59 211.54,100.26 214.6,100.26 214.96,100.62 217.54,100.62 v2(218.26,99.9)
  BOTTOM w0.102: UI2.4 239.38,123.61 239.33,123.56 239.33,123.35 239,123.02 238.48,123.02 238.32,123.18 238.32,124.43 238.09,124.65 v1(235.02,124.65) 232.67,124.65 v2(232.22,124.21)
USB_PWR_SHR_EN#: length 174.6
  TOP w0.102: RPE9.4 193.63,102.2 v1(193.15,102.68) 192.84,102.99 192.84,104.61 192.31,105.15 v2(192.31,105.55) ; UE2.B38 201.44,94.5 v2(201.72,94.23) ; UI3.6 62.79,120 62.97,119.83 62.97,119.43 63.08,119.32 63.54,119.32 v2(63.76,119.1)
  IN1 w0.084: v2(201.72,94.23) 196,94.23 195.6,93.82 194.21,93.82 194,94.03 193.03,94.03 v2(192.81,93.82)
  IN2 w0.122: v2(192.31,105.55) 192.31,105.24 192.65,104.89 192.65,101.23 193.33,100.54 193.33,94.34 192.81,93.82 v2(192.81,93.82)
  IN3 w0.122: v2(192.31,105.55) 192.22,105.46 187.15,105.46 186.67,105.95 182.86,105.95 181.61,104.7 176.42,104.7 175.17,105.95 173.23,105.95 171.74,107.43 171.74,108.27 169.99,110.03 165.01,110.03 161.87,113.17 161.87,114.74 162.46,115.34 162.46,116.49 159.61,119.34 152.37,119.34 151.73,118.7 147.8,118.7 147.51,118.99 144.35,118.99 141.02,115.66 128.3,115.66 126.69,114.05 118.52,114.05 116.03,116.55 109.02,116.55 106,119.56 98.55,119.56 97,121.11 66.58,121.11 64.57,119.1 v2(63.76,119.1)
USB_PWR_SHR_VBUS_EN: length 155
  TOP w0.102: UI3.5 62.46,119.5 63.07,118.89 v2(63.17,118.89) 63.79,118.27 v1(63.79,117.68) ; v2(194.03,103.86) 194.19,103.7 RPE9.1 ; v2(186.38,105.49) 186.77,105.09 UE1.B50
  IN3 w0.122: v2(194.03,103.86) 193.37,104.52 190.77,104.52 190.03,103.78 190.03,103.45 189.8,103.23 187.98,103.23 187.65,103.56 187.65,104.22 v2(186.38,105.49) 186.23,105.49 185.95,105.21 185.95,104.6 185.73,104.38 173.09,104.38 171.49,105.97 171.49,108.17 169.88,109.78 164.91,109.78 161.62,113.07 161.62,114.85 162.21,115.44 162.21,116.39 159.51,119.09 152.47,119.09 151.83,118.45 147.7,118.45 147.41,118.74 144.61,118.74 141.28,115.41 128.4,115.41 126.79,113.8 118.42,113.8 115.93,116.3 108.91,116.3 106.08,119.13 83.95,119.13 82.22,120.86 66.95,120.86 64.73,118.65 63.41,118.65 v2(63.17,118.89)
USBP0+: length 63.5
  TOP w0.102: UI4.6 129.73,128.45 130.05,128.13 130.05,127.65 v2(130.02,127.62)
  IN4 w0.091: v2(130.02,127.62) 130.43,127.21 130.43,127.05 129.65,126.26 129.65,125.81 131.41,124.05 131.41,114.84 132.87,113.38 132.87,103.58 133.43,103.02 133.43,101.09 133.2,100.86 133.2,98.96 132.52,98.29 132.52,96.75 131.25,95.48 131.25,92.25 133.87,89.63 133.87,88.22 133.34,87.69 133.34,84.89 133.82,84.41 133.82,81.12 133.54,80.83 133.54,78.39 133.84,78.09 133.84,76.19 133.73,76.09 133.73,75.71 134.08,75.36 134.08,74.1 134.54,73.65 134.54,72.05 134.4,71.91 134.24,71.91 134.12,72.03 v2(134.12,72.19)
  BOTTOM w0.076: UC1.AM8 134.51,72.34 134.37,72.19 v2(134.12,72.19)
USBP0-: length 63.5
  TOP w0.102: UI4.7 130.13,128.36 130.27,128.22 130.27,127.96 v2(130.61,127.62)
  IN4 w0.091: v2(134.12,71.54) 134.32,71.74 134.47,71.74 134.71,71.98 134.71,73.72 134.26,74.17 134.26,75.43 133.91,75.78 133.91,76.02 134.01,76.12 134.01,78.17 133.71,78.46 133.71,80.76 134,81.05 134,84.48 133.51,84.97 133.51,87.62 134.04,88.15 134.04,89.71 131.43,92.32 131.43,95.41 132.7,96.68 132.7,98.22 133.37,98.89 133.37,100.78 133.61,101.02 133.61,103.09 133.04,103.65 133.04,113.45 131.58,114.91 131.58,124.12 129.82,125.88 129.82,126.19 130.61,126.98 v2(130.61,127.62)
  BOTTOM w0.076: UC1.AN8 134.31,71.86 134.12,71.67 v2(134.12,71.54)
USBP0_R_D+: length 11.3
  TOP w0.102: LI3.2 63.96,124.11 64.04,124.19 64.04,124.54 64.11,124.6 64.19,124.6 64.32,124.48 64.32,123.44 64.2,123.32 v2(64.05,123.32)
  BOTTOM w0.102: v2(64.05,123.32) 64.33,123.04 64.73,123.04 64.84,123.14 64.84,123.79 DI2.3 65.38,123.83 65.38,123.26 65.46,123.18 65.61,123.18 66.7,124.27 66.7,125.2 66.12,125.78 66.12,126.93 66.01,127.04 JUSB1.3
USBP0_R_D-: length 11.3
  TOP w0.102: v2(64.05,122.74) 64.53,123.22 64.53,124.57 64.28,124.82 64.09,124.82 63.95,124.96 LI3.3
  BOTTOM w0.102: v2(64.05,122.74) 64.14,122.83 64.73,122.83 64.87,122.69 64.87,122.41 DI2.2 65.2,122.15 65.39,122.34 65.39,122.66 66.92,124.18 66.92,125.29 66.33,125.87 66.33,126.67 66.7,127.04 JUSB1.2
USBP1+: length 113.8
  TOP w0.102: JIO1.12 220.24,64.7 220.1,64.84 219.73,64.84 219.41,64.52 219.41,62.61 217.77,60.98 217.77,56.63 217.78,56.62 217.78,56.09 217.77,56.07 217.77,50.77 215.32,48.31 212.54,48.31 v2(212.35,48.12)
  IN1 w0.091: v2(212.35,48.12) 212.1,48.36 209.41,48.36 205.22,52.55 202.74,52.55 202.59,52.4 200.96,52.4 200.45,51.89 196.12,51.89 195.62,52.4 193,52.4 192.2,51.6 189.53,51.6 188.73,52.4 184.05,52.4 183.55,51.9 169.21,51.9 166.67,54.44 165.24,54.44 163.85,55.82 146.66,55.82 140.86,61.63 140.86,64.12 137.49,67.49 136.33,67.49 135.81,68.01 135.81,70.55 135.73,70.63 135.54,70.63 v2(135.47,70.56)
  BOTTOM w0.076: v2(135.47,70.56) 135.15,70.24 UC1.AT7
USBP1-: length 113.9
  TOP w0.102: v2(212.35,48.71) 212.52,48.53 215.23,48.53 217.55,50.85 v4(217.55,56.35) 217.55,61.07 219.19,62.7 219.19,64.61 219.64,65.06 220.09,65.06 220.23,65.2 JIO1.13
  IN1 w0.091: v2(212.35,48.71) 212.18,48.54 209.48,48.54 205.3,52.72 202.67,52.72 202.52,52.57 200.89,52.57 200.38,52.06 196.2,52.06 195.69,52.57 192.93,52.57 192.13,51.77 189.6,51.77 188.8,52.57 183.98,52.57 183.48,52.07 169.29,52.07 166.75,54.61 165.31,54.61 163.92,56 146.73,56 141.03,61.7 141.03,64.2 137.56,67.66 136.4,67.66 135.98,68.08 135.98,70.71 v2(135.47,71.21)
  BOTTOM w0.076: v2(135.47,71.21) 135.15,70.89 UC1.AR7
USBP2+: length 49.5
  IN4 w0.091: v2(170.75,83.07) 171.01,82.81 171.01,82.66 170.88,82.53 165.79,82.53 164.75,81.49 164.6,81.49 162.9,79.79 162.53,79.79 162.28,79.54 161.22,79.54 157.13,75.45 156.1,75.45 154.34,73.68 139.7,73.68 138.22,72.2 138.22,70.52 135.89,68.19 134.88,68.19 134.48,68.59 134.48,69.9 134.69,70.1 134.69,70.43 134.5,70.62 134.39,70.62 v2(134.12,70.89)
  BOTTOM w0.076: v2(134.12,70.89) 134.44,71.21 UC1.AP8
  BOTTOM w0.102: JNGFF1.3 170.8,82.1 171,82.29 171,82.83 v2(170.75,83.07)
USBP2-: length 49.6
  IN4 w0.091: v2(134.08,70.33) 134.19,70.44 134.43,70.44 134.51,70.36 134.51,70.18 134.31,69.97 134.31,68.52 134.8,68.02 135.96,68.02 138.39,70.45 138.39,72.13 139.77,73.51 154.41,73.51 156.18,75.27 157.2,75.27 161.3,79.37 162.35,79.37 162.6,79.62 162.97,79.62 164.67,81.32 164.83,81.32 165.86,82.36 170.95,82.36 171.19,82.59 171.19,82.92 v2(171.34,83.07)
  BOTTOM w0.076: v2(134.08,70.33) 134.31,70.56 UC1.AR8
  BOTTOM w0.102: v2(171.34,83.07) 171.21,82.95 171.21,82.19 171.3,82.1 JNGFF1.5
USBP3+: length 62.3
  IN4 w0.091: v2(129.35,122.14) 129.49,122 129.49,121.73 129.56,121.66 129.56,114.5 131.03,113.03 131.03,108.09 131.27,107.85 131.27,105.08 129.62,103.42 129.62,101.54 129.24,101.15 129.24,95.04 129.35,94.94 129.35,90.97 130,90.32 130.45,90.32 132.38,88.39 132.38,84.83 133.42,83.78 133.42,81.42 133.08,81.07 133.08,78.3 133.42,77.95 133.42,76.4 133.01,75.99 133.01,71.94 132.82,71.75 132.82,70.11 133.01,69.93 133.54,69.93 v2(133.55,69.91)
  BOTTOM w0.076: v2(133.55,69.91) 133.23,70.24 UC1.AT10
  BOTTOM w0.102: UI5.8 128.17,124.99 128.06,124.88 127.84,124.88 127.36,124.4 127.36,123.73 128.35,122.74 129.04,122.74 129.35,122.42 v2(129.35,122.14)
USBP3-: length 62.3
  IN4 w0.091: v2(129.94,122.14) 129.66,121.86 129.66,121.8 129.73,121.73 129.73,114.57 131.2,113.1 131.2,108.16 131.45,107.92 131.45,105 129.8,103.35 129.8,101.46 129.42,101.08 129.42,95.11 129.52,95.01 129.52,91.04 130.07,90.49 130.52,90.49 132.55,88.46 132.55,84.9 133.6,83.85 133.6,81.34 133.25,81 133.25,78.37 133.6,78.02 133.6,76.33 133.18,75.91 133.18,71.86 133,71.68 133,70.19 133.08,70.1 133.21,70.1 133.55,70.45 v2(133.55,70.56)
  BOTTOM w0.076: v2(133.55,70.56) 133.51,70.51 133.31,70.51 133.16,70.67 UC1.AR10
  BOTTOM w0.102: UI5.7 128.31,124.49 128.13,124.67 127.93,124.67 127.57,124.31 127.57,123.82 128.44,122.95 129.13,122.95 v2(129.94,122.14)
USBP3_D+: length 18.5
  BOTTOM w0.102: JUSB2.3 228.89,127.04 229.08,126.85 229.08,125.8 v4(230.45,124.43) 231.84,123.04 235.82,123.04 236.92,121.94 236.92,121.59 236.76,121.43 DI3.3 236.06,120.56 236.2,120.42 236.78,120.42 236.92,120.29 236.92,119.97 237.18,119.71 238.43,119.71 238.64,119.5 238.64,119.12 238.53,119.02 238.41,119.02 238.14,119.28 LI4.2
USBP3_D-: length 18.6
  BOTTOM w0.102: JUSB2.2 229.5,127.04 229.3,126.84 229.3,125.89 230.4,124.78 230.42,124.78 230.8,124.4 230.8,124.39 231.93,123.26 235.91,123.26 237.14,122.02 237.14,121.59 237.3,121.43 DI3.2 237.99,120.62 237.85,120.48 237.29,120.48 237.14,120.32 237.14,120.06 237.26,119.93 238.52,119.93 238.86,119.59 v4(238.86,119.35) 238.86,119.04 238.62,118.8 238.41,118.8 238.04,118.43 LI4.3
USBP4+: length 56.8
  TOP w0.102: v2(122.49,103.43) 122.33,103.6 122.02,103.6 121.58,104.04 121.58,108.3 119.1,110.77 v4(117.4,110.77) 116.18,110.77 113.18,113.77 113.18,115.21 113,115.39 112.75,115.39 112.65,115.29 112.65,114.86 112.55,114.75 LV27.2
  IN4 w0.091: v2(130.02,72.79) 130.28,72.53 130.45,72.53 130.7,72.78 130.7,73.82 130.49,74.02 130.49,75.79 129.98,76.3 129.98,82.59 129.53,83.04 129.53,84.14 130.49,85.1 130.49,88.16 125.68,92.97 125.68,94.64 125.2,95.11 124.69,95.11 122.71,97.09 122.71,102.8 122.92,103.01 122.92,103.53 122.84,103.61 122.67,103.61 v2(122.49,103.43)
  BOTTOM w0.076: UC1.AL15 130.3,72.79 v2(130.02,72.79)
USBP4-: length 56.9
  TOP w0.102: LV27.3 113.09,115.6 113.4,115.3 113.4,113.86 116.27,110.99 117.12,110.99 117.14,111 117.67,111 117.68,110.99 119.19,110.99 121.8,108.39 121.8,104.13 122.11,103.81 122.29,103.81 v2(122.49,104.02)
  IN4 w0.091: v2(130.02,72.14) 130.25,72.36 130.53,72.36 130.87,72.71 130.87,73.89 130.66,74.1 130.66,75.86 130.16,76.37 130.16,82.66 129.7,83.11 129.7,84.06 130.66,85.03 130.66,88.23 125.85,93.04 125.85,94.71 125.27,95.29 124.76,95.29 122.88,97.16 122.88,102.73 123.09,102.94 123.09,103.6 122.91,103.78 122.73,103.78 v2(122.49,104.02)
  BOTTOM w0.076: UC1.AM15 130.4,72.51 v2(130.02,72.14)
USBP4_D+: length 7.8
  TOP w0.102: LV27.1 109.63,114.75 109.53,114.86 109.53,115.16 109.44,115.25 109.22,115.25 108.82,114.86 107.77,114.86 107.36,115.27 107.36,115.74 107.22,115.88 106.57,115.88 DV4.3 106.35,116.39 105.82,116.92 v2(105.82,117.24)
  BOTTOM w0.102: v2(105.82,117.24) 105.47,116.88 JEDP1.3
USBP4_D-: length 7.8
  TOP w0.102: LV27.4 109.56,115.6 109.42,115.47 109.13,115.47 108.73,115.07 107.86,115.07 107.57,115.36 107.57,115.74 107.71,115.88 108.07,115.88 DV4.2 107.14,117.24 v2(106.4,117.24)
  BOTTOM w0.102: JEDP1.2 105.97,116.75 106.4,117.19 v2(106.4,117.24)
USBP5+: length 60
  IN4 w0.091: v2(131.67,72.42) 131.91,72.66 132.5,72.66 132.81,72.98 132.81,75.44 131.74,76.51 131.74,82.16 132.08,82.5 132.08,82.99 132.57,83.47 132.57,84.06 131.61,85.03 131.61,88.65 130.64,89.61 130.12,89.61 128.89,90.85 128.89,94.11 127.96,95.03 126.46,95.03 125.26,96.23 125.26,96.33 123.54,98.05 123.54,102.32 123.8,102.58 123.8,103.51 123.88,103.58 124.07,103.58 v2(124.26,103.39)
  BOTTOM w0.076: v2(131.67,72.42) 131.47,72.42 UC1.AN13
  BOTTOM w0.102: LZ1.1 110.68,113.27 111,113.59 113.49,113.59 114.13,114.23 116.73,114.23 118.61,112.35 118.61,111.2 121.01,108.8 121.01,106.24 123.64,103.61 124.04,103.61 v2(124.26,103.39)
USBP5-: length 60
  IN4 w0.091: v2(131.68,73.07) 131.91,72.83 132.43,72.83 132.64,73.05 132.64,75.36 131.57,76.44 131.57,82.23 131.91,82.57 131.91,83.06 132.4,83.55 132.4,83.99 131.43,84.96 131.43,88.58 130.57,89.44 130.05,89.44 128.71,90.77 128.71,94.04 127.89,94.86 126.39,94.86 125.09,96.16 125.09,96.26 123.37,97.98 123.37,102.39 123.63,102.65 123.63,103.58 123.81,103.76 124.04,103.76 124.26,103.98 v2(124.26,103.98)
  BOTTOM w0.076: UC1.AM13 131.47,73.07 v2(131.68,73.07)
  BOTTOM w0.102: v2(124.26,103.98) 124.11,103.83 123.73,103.83 121.22,106.33 121.22,108.89 118.82,111.29 118.82,112.44 116.82,114.44 114.04,114.44 113.4,113.81 111,113.81 110.68,114.12 LZ1.4
USBP5_D+: length 9.8
  BOTTOM w0.102: LZ1.2 107.78,113.27 107.75,113.3 107.47,113.3 107.46,113.29 106.92,113.29 106.91,113.3 105.74,113.3 105.64,113.4 104.21,113.4 104.07,113.54 v4(103.25,113.54) 102.55,113.54 101.93,114.16 101.41,114.16 100.69,114.88 100.69,115.25 100.47,115.48 JEDP1.13
USBP5_D-: length 9.8
  BOTTOM w0.102: LZ1.3 107.84,114.12 107.71,114 107.71,113.62 107.61,113.52 107.19,113.52 v4(107.19,113.51) 105.83,113.51 105.73,113.62 104.3,113.62 104.16,113.76 103.53,113.76 103.52,113.77 102.99,113.77 102.98,113.76 102.64,113.76 102.02,114.38 101.5,114.38 100.91,114.97 100.91,115.47 100.97,115.53 JEDP1.12
USBP6+: length 101
  TOP w0.102: v2(214.47,47.15) 214.65,46.97 215.92,46.97 215.93,46.98 216.54,46.98 217.16,46.36 217.16,45.84 217.3,45.69 JUSH1.18
  IN1 w0.084: v2(132.2,71.54) 132.72,71.54 133.18,71.08 133.18,67.77 136.08,64.87 136.69,64.87 140.11,61.44
  IN1 w0.091: v2(214.47,47.15) 214.26,46.94 210.17,46.94 205.08,52.03 202.89,52.03 202.79,51.93 201.17,51.93 199.42,50.18 193.86,50.18 193.1,50.94 186.1,50.94 185.62,51.42 167.44,51.42 163.52,55.34 146.21,55.34 140.11,61.44
  BOTTOM w0.076: UC1.AN11 132.27,71.54 v2(132.2,71.54)
USBP6-: length 101
  TOP w0.102: JUSH1.19 216.8,45.69 216.94,45.84 216.94,46.27 216.46,46.75 v4(216.19,46.75) 214.65,46.75 v2(214.47,46.57)
  IN1 w0.084: 136.61,64.7 140.11,61.2
  IN1 w0.091: v2(214.47,46.57) 214.27,46.76 210.1,46.76 205.01,51.86 202.96,51.86 202.86,51.75 201.24,51.75 199.5,50.01 193.79,50.01 193.03,50.77 186.03,50.77 185.55,51.25 167.37,51.25 163.45,55.17 146.14,55.17 140.11,61.2 ; v2(132.2,70.89) 132.39,70.89 132.49,70.98 132.49,71.28 132.58,71.36 132.65,71.36 133.01,71.01 133.01,67.7 136,64.7 136.61,64.7
  BOTTOM w0.076: v2(132.2,70.89) 132.53,71.21 UC1.AP11
USBP7+: length 95.5
  IN1 w0.091: v2(204.65,50.78) 204.85,50.98 204.85,51.1 204.74,51.21 203.58,51.21 202.08,49.7 200.2,49.7 199.78,49.29 193.46,49.29 192.64,50.11 185.67,50.11 185.18,50.6 167.08,50.6 163.16,54.53 145.87,54.53 136.34,64.06 135.87,64.06 132.12,67.81 131.96,67.81 130.97,68.8 130.97,71.42 131.16,71.61 131.38,71.61 v2(131.64,71.86)
  BOTTOM w0.076: UC1.AP13 131.31,71.54 v2(131.64,71.86)
  BOTTOM w0.102: JNGFF2.7 205.7,57.33 205.84,57.19 205.84,56.86 204.41,55.42 204.41,53.84 204.4,53.82 204.4,53.29 204.41,53.28 204.41,51.97 204.83,51.55 204.83,50.96 v2(204.65,50.78)
USBP7-: length 95.6
  IN1 w0.091: v2(131.64,71.21) 131.42,71.43 131.23,71.43 131.14,71.35 131.14,68.87 132.03,67.98 132.2,67.98 135.94,64.23 136.41,64.23 145.94,54.7 163.23,54.7 167.15,50.78 185.25,50.78 185.74,50.28 192.71,50.28 193.54,49.46 199.71,49.46 200.13,49.88 202,49.88 203.51,51.38 204.81,51.38 205.03,51.17 205.03,50.98 v2(205.23,50.78)
  BOTTOM w0.076: v2(131.64,71.21) 131.6,71.25 131.21,71.25 131.11,71.15 131.11,71.02 UC1.AR13
  BOTTOM w0.102: JNGFF2.9 206.2,57.41 206.06,57.27 206.06,56.77 204.62,55.33 v4(204.62,53.56) 204.62,52.06 205.04,51.64 205.04,50.97 v2(205.23,50.78)
USBRBIAS: length 3.5
  TOP w0.102: RC152.1 131.51,74.81 131.51,74.34 131.71,74.14 v2(131.71,73.67)
  BOTTOM w0.102: v2(131.71,73.67) 132.18,74.14 UC1.AJ11 UC1.AJ10
USH_DET#: length 140.5
  TOP w0.089: v2(137.82,87.16) 137.82,87.5 141.24,90.92 141.24,91.92
  TOP w0.102: v2(221.15,42.61) 221.25,42.61 221.43,42.43 224.59,42.43 225.8,43.64 JUSH1.1 ; v2(209.53,54.25) 209.72,54.25 v1(210.22,53.75) 211.05,52.92 211.05,48.39 211.55,47.9 v2(211.55,42.59) ; RPC15.2 143.77,97.7 143.55,97.48 141.46,97.48 141.24,97.26 141.24,91.92
  IN1 w0.084: v2(137.82,87.16) 139.03,88.37 144.36,88.37 149.16,83.58 153,83.58 156.87,87.45 161.04,87.45 162.8,85.69 163.53,85.69 164.02,86.18 166.12,86.18 168.24,84.06 169.2,84.06 170.59,82.68 171.65,82.68 174.81,79.51 177.22,79.51 178.88,77.84 179.16,77.84 179.86,77.14 179.86,76.78 180.11,76.52 188.69,76.52 189.89,75.33 193.23,75.33 195.32,73.24 196.25,73.24 197.68,71.81 198.72,71.81 200.17,70.35 200.3,70.23 200.3,61.73 203.05,58.98 205.61,58.98 205.7,58.89 206.95,57.64 208.32,57.64 209.53,56.44 v2(209.53,54.25) ; v2(211.55,42.59) 211.63,42.5 220.53,42.5 220.64,42.61 v2(221.15,42.61)
  BOTTOM w0.089: UC1.E3 137.52,87.46 v2(137.82,87.16)
USH_PWR_STATE#: length 100.9
  TOP w0.102: UE1.A34 188.77,98.34 189.33,97.78 v2(189.4,97.78) ; JUSH1.5 223.8,45.65 v2(224.46,46.31) 224.68,46.31 225.26,46.89 RZ10.2
  IN2 w0.122: v2(224.46,46.31) 223.93,46.84 223.93,50.31 222.49,51.74 222.49,55.49 229.97,62.97 229.97,80.25 228.75,81.47 228.75,84.93 227.36,86.33 227.36,88.23 v2(226.91,88.67)
  IN3 w0.122: v2(226.91,88.67) 226.91,89.33 224.36,91.89 221.22,91.89 218.64,94.47 218.64,98.84 217.11,100.37 215.06,100.37 214.7,100.01 210.93,100.01 210.34,100.6 209.52,100.6 208.04,102.08 207.08,102.08 206.05,103.11 204.53,103.11 204.23,102.81 198.34,102.81 197.68,102.14 195.15,102.14 192.06,99.06 190.67,99.06 v2(189.4,97.78)
USH_SMBCLK: length 65.9
  TOP w0.102: RZ8.2 218.43,46.59 218.43,46.24 v2(218.27,46.08) 218.45,45.9 218.45,45.74 218.3,45.59 JUSH1.16 ; v2(202.3,85.84) 202.37,85.91 UE2.A50
  IN4 w0.084: v2(203.92,46.58) 203.72,46.78 203.72,48.19 203.44,48.47 203.44,52.23 204.17,52.96 204.17,55.16 204.07,55.26 204.07,57.38 204.17,57.49 204.17,61.3 202.49,62.99 202.49,65.12 202.96,65.59 202.96,76.07 204.76,77.87 204.76,78.38 203.9,79.24 203.9,82.46 204.16,82.72 204.16,83.68 203.35,84.48 202.47,84.48 201.8,85.16 201.8,86.59 201.93,86.72 202.07,86.72 202.3,86.49 v2(202.3,85.84)
  BOTTOM w0.102: v2(218.27,46.08) 218.46,46.27 218.46,46.95 217.51,47.9 213.01,47.9 211.53,46.42 210.9,46.42 210.88,46.4 210.31,46.4 210.29,46.42 v4(208.82,46.42) 204.83,46.42 204.19,47.07 203.92,47.07 203.77,46.92 203.77,46.73 v2(203.92,46.58)
USH_SMBDAT: length 67.7
  TOP w0.102: JUSH1.15 218.8,45.57 218.65,45.72 218.65,45.88 v2(218.85,46.08) 218.63,46.3 218.63,46.61 RZ9.2 ; v2(202.25,88.31) 202.12,88.17 UE2.B53
  IN4 w0.084: v2(203.34,46.58) 203.54,46.78 203.54,48.11 203.25,48.39 203.25,52.3 203.99,53.03 203.99,55.08 203.88,55.18 203.88,57.46 203.99,57.56 203.99,61.23 202.3,62.91 202.3,65.19 202.77,65.67 202.77,76.14 204.58,77.95 204.58,78.3 203.72,79.16 203.72,82.54 203.97,82.79 203.97,83.6 203.27,84.3 202.4,84.3 201.62,85.08 201.62,86.67 201.86,86.91 202.07,86.91 202.25,87.09 v2(202.25,88.31)
  BOTTOM w0.102: v2(218.85,46.08) 218.66,46.27 218.66,47.03 217.6,48.1 212.92,48.1 211.45,46.63 v4(210.59,46.63) 209.12,46.63 209.1,46.65 208.53,46.65 208.51,46.63 204.92,46.63 204.27,47.27 203.84,47.27 203.57,47.01 203.57,46.81 v2(203.34,46.58)
VCI_IN2#: length 10.1
  TOP w0.102: UE2.B63 207.12,87.82 207.16,87.87 207.16,88.34 v2(206.73,88.77) ; RPE5.4 213.22,86.08 212.75,86.56 v1(212.16,86.56) 212.16,86.56 211.05,86.56 210.72,86.88 v2(210.04,86.88)
  IN4 w0.084: v2(210.04,86.88) 208.17,86.88 207.18,87.87 207.18,88.33 v2(206.73,88.77)
VCT_LAN_R1: length 2.4
  TOP w0.102: RL3.2 208.73,110.84 208.15,111.42 UL1.6
VFB: length 14.1
  TOP w0.152: v2(86.78,97.21) 87.35,97.21 88.06,96.5 90.43,96.5 91.43,95.49 v1(93.06,95.49) 93.41,95.49 95.18,97.26 96.99,97.26 PR531.2
  BOTTOM w0.152: v2(86.78,97.21) 87,97.21 87.35,97.57 PU500.24
VGA_ID: length 12
  TOP w0.102: v2(182.99,105.47) 182.94,105.52 UE1.B59 ; v1(180.56,112) RE87.1 RE85.1 182.63,112 v2(183.49,112.87)
  BOTTOM w0.102: v2(182.99,105.47) 182.51,105.95 182.51,111.89 v2(183.49,112.87)
VIDALERT_N: length 33.6
  IN4 w0.084: v2(91.42,83.52) 91.36,83.46 86.34,83.46 82.49,87.31 82.49,91.61 84.24,93.36 84.24,99.66 84.93,100.35 85.97,100.35 86.39,100.77 86.39,101.57 v2(85.92,102.04)
  BOTTOM w0.102: PU500.32 86.45,101.5 v2(85.92,102.04) 85.33,102.62 84.52,102.62 PR528.2 ; RC204.2 v1(90.78,83.25) 91.15,83.25 v2(91.42,83.52) 91.52,83.62 RC207.2
VIDSCLK: length 43.4
  IN4 w0.084: v2(93.26,82.6) 92.95,82.92 86.12,82.92 81.95,87.09 81.95,91.84 83.67,93.56 83.67,100.71 83.9,100.94 85.4,100.94 v2(85.54,100.8)
  BOTTOM w0.089: UC1.N63 100.08,83.19 99.32,83.19 99.18,83.05 95.29,83.05
  BOTTOM w0.102: 95.29,83.05 93.44,83.05 93.26,82.88 v2(93.26,82.6) ; PR527.2 84.33,101.92 84.33,101.66 84.23,101.56 83.92,101.56 83.82,101.46 83.82,101.28 84.16,100.94 84.61,100.94 84.72,101.06 84.72,101.93 84.82,102.04 85.07,102.04 85.17,101.93 85.17,100.9 85.27,100.8 v2(85.54,100.8) 85.94,101.21 86.17,101.21 86.28,101.1 PU500.31
VIDSOUT: length 54.6
  IN4 w0.084: v2(86.64,102.23) 86.65,102.23 87.15,101.73 87.15,100.66 86.25,99.76 85.21,99.76 84.84,99.39 84.84,97.57 84.92,97.48 85.75,97.48 85.83,97.4 85.83,97.23 85.75,97.15 84.92,97.15 84.84,97.06 84.84,96.9 84.92,96.81 85.75,96.81 85.83,96.73 85.83,96.56 85.75,96.48 84.92,96.48 84.84,96.39 84.84,93.19 83.03,91.39 83.03,87.54 86.57,84 91.11,84 v2(91.44,84.33)
  BOTTOM w0.076: UC1.L63 99.94,83.83 99.56,84.21 96.18,84.21 96.18,84.22
  BOTTOM w0.102: PU500.1 87.35,102.44 87.25,102.54 86.97,102.54 86.65,102.23 v2(86.64,102.23) 86.48,102.39 86.48,102.63 85.87,103.24 85.18,103.24 85.08,103.34 85.08,104.21 84.98,104.31 84.79,104.31 84.69,104.21 84.69,103.48 84.58,103.38 84.17,103.38 84.06,103.48 84.06,103.69 PR529.2 ; 96.18,84.22 94,84.22 93.88,84.33 v2(91.44,84.33) 91.4,84.33 90.92,83.85 90.64,83.85 90.48,84.01 90.48,84.23 90.98,84.74 91.82,84.74 92.01,84.93 92.01,85.36 91.8,85.58 91.31,85.58 v1(90.82,85.09) 89.73,84 89.03,84 88.82,83.79 RC208.2
VMM2320_AUX: length 15.7
  TOP w0.102: RV608.2 142.27,111.2 v2(142.27,111.46) 142.02,111.71 UV600.28
  IN4 w0.091: v2(146.57,103.65) 146.57,104.83 143.2,108.2 143.2,109.15 142.27,110.08 v2(142.27,111.46)
  BOTTOM w0.102: CV110.1 149.04,103.55 149.04,103.18 148.71,102.85 146.79,102.85 146.57,103.06 v2(146.57,103.65)
VMM2320_AUX#: length 15.6
  TOP w0.102: RV604.2 142.55,111.15 v2(142.85,111.46) 142.42,111.89 UV600.29
  IN4 w0.091: v2(147.16,103.65) 146.75,104.06 146.75,104.9 143.37,108.28 143.37,109.22 142.44,110.15 142.44,111.04 v2(142.85,111.46)
  BOTTOM w0.102: CV111.1 148.53,103.8 148.82,103.51 148.82,103.27 148.62,103.06 146.88,103.06 146.79,103.15 146.79,103.28 v2(147.16,103.65)
VMM2320_AUX#_C: length 5.5
  BOTTOM w0.102: UV8.H2 150.84,108.48 150.84,108.05 149.95,107.16 v4(149.95,106.58) 149.95,106.27 149.6,105.92 149.11,105.92 148.63,105.44 148.63,104.94 CV111.2
VMM2320_AUX_C: length 5.4
  BOTTOM w0.102: CV110.2 149.08,104.5 148.94,104.5 148.86,104.58 148.86,105.34 149.21,105.69 149.7,105.69 150.18,106.18 150.18,106.32 150.18,106.32 150.18,106.96 150.18,107.06 151.07,107.95 151.07,108.06 UV8.H1
VMM2320_HPD: length 15.4
  TOP w0.102: v2(145.42,116.09) 145.24,115.91 UV600.38 ; v2(149.51,107.21) v1(149.51,106.67)
  IN4 w0.084: v2(149.51,107.21) 147.34,109.38 147.34,115.61 147.07,115.88 145.63,115.88 v2(145.42,116.09)
  BOTTOM w0.102: v2(149.51,107.21) 150.46,108.16 UV8.J1
VMM2320_N0: length 20.8
  TOP w0.102: v2(144.97,116.56) 144.57,116.16 144.2,116.16 144.04,116.31 UV600.39
  IN4 w0.091: v2(150.33,102.99) 150.47,102.85 150.47,102.68 150.38,102.58 150.02,102.58 149.62,102.97 149.62,103.15 144.03,108.74 144.03,111.73 143.55,112.22 143.55,114.97 144.77,116.19 144.77,116.36 v2(144.97,116.56)
  BOTTOM w0.102: v2(150.33,102.99) 150.45,103.11 150.45,103.53 CV103.1
VMM2320_N0_C: length 4.8
  BOTTOM w0.102: CV103.2 150.42,104.96 150.42,105.39 150.85,105.82 150.85,107.34 151.48,107.97 151.48,108.46 UV8.G2
VMM2320_N1: length 18.8
  TOP w0.102: UV600.36 v2(144.37,115.11)
  IN4 w0.091: v2(144.37,115.11) 144.79,114.7 144.79,113.85 145.69,112.95 145.69,109.02 150.35,104.36 151.94,104.36 152.52,103.78 152.52,103.4 v2(152.11,102.99)
  BOTTOM w0.102: CV105.1 152.25,103.8 152.39,103.66 152.39,103.27 v2(152.11,102.99)
VMM2320_N1_C: length 4.4
  BOTTOM w0.102: CV105.2 152.2,104.96 152.2,105.49 152.12,105.58 152.12,105.95 152.1,105.96 152.1,106.49 152.12,106.5 152.12,108.45 UV8.F2
VMM2320_N2: length 20.8
  TOP w0.102: UV600.34 144.13,114.31 144.25,114.44 145.45,114.44 v2(146.13,115.11)
  IN4 w0.091: v2(146.13,115.11) 146.13,113.85 146.51,113.46 146.51,109.54 150.73,105.32 152.92,105.32 154.47,103.76 v2(154.47,102.99)
  BOTTOM w0.102: v2(154.47,102.99) 154.37,103.09 154.37,103.55 CV107.1
VMM2320_N2_C: length 4.9
  BOTTOM w0.102: CV107.2 154.27,105.07 154.27,105.44 v4(153.85,105.86) 153.16,106.54 153.16,107.76 153.42,108.02 153.42,108.52 UV8.E2
VMM2320_N3: length 21.7
  TOP w0.102: v2(144.44,112.77) 144.54,112.87 144.54,113.1 144.43,113.21 144.26,113.21 144.17,113.11 UV600.31
  IN4 w0.091: v2(144.44,112.77) 144.53,112.68 144.53,109.09 150.03,103.59 151.17,103.59 151.44,103.31 151.44,102.6 151.81,102.23 155.71,102.23 156.05,102.57 156.05,102.78 v2(156.25,102.99)
  BOTTOM w0.102: CV109.1 156.07,103.46 156.07,103.17 v2(156.25,102.99)
VMM2320_N3_C: length 5.5
  BOTTOM w0.102: CV109.2 156.16,104.96 156.16,105.29 155.58,105.87 155.01,105.87 154.08,106.8 154.08,108.5 UV8.D2
VMM2320_P0: length 20.8
  TOP w0.102: UV600.40 144.24,116.71 v2(144.39,116.56)
  IN4 w0.091: v2(150.92,102.99) 150.65,102.72 150.65,102.6 150.45,102.4 149.95,102.4 149.45,102.9 149.45,103.08 143.86,108.67 143.86,111.66 143.37,112.14 143.37,115.04 144.59,116.26 144.59,116.36 v2(144.39,116.56)
  BOTTOM w0.102: CV102.1 150.67,103.4 150.67,103.24 v2(150.92,102.99)
VMM2320_P0_C: length 4.6
  BOTTOM w0.102: UV8.G1 151.69,108.03 151.69,107.88 151.07,107.25 151.07,105.73 150.64,105.3 150.64,104.59 150.73,104.5 150.85,104.5 CV102.2
VMM2320_P1: length 18.9
  TOP w0.102: UV600.37 144.1,115.51 144.15,115.56 144.51,115.56 v2(144.96,115.11)
  IN4 w0.091: v2(144.96,115.11) 144.96,113.92 145.86,113.02 145.86,109.1 150.43,104.53 152.01,104.53 152.69,103.85 v2(152.69,102.99)
  BOTTOM w0.102: CV104.1 152.61,103.56 152.61,103.08 v2(152.69,102.99)
VMM2320_P1_C: length 4.4
  BOTTOM w0.102: CV104.2 152.62,104.49 152.5,104.49 152.42,104.58 152.42,105.58 152.33,105.67 v4(152.33,106.23) 152.33,107.77 152.4,107.85 152.5,107.85 152.58,107.93 152.58,108.05 UV8.F1
VMM2320_P2: length 20.8
  TOP w0.102: UV600.35 144.13,114.71 144.2,114.65 145.33,114.65 145.54,114.86 v2(145.54,115.11)
  IN4 w0.091: v2(153.89,102.99) 154.3,103.4 154.3,103.69 152.84,105.15 150.66,105.15 146.34,109.46 146.34,113.39 145.95,113.78 145.95,114.7 v2(145.54,115.11)
  BOTTOM w0.102: v2(153.89,102.99) 154.16,103.25 154.16,103.47 153.82,103.8 CV106.1
VMM2320_P2_C: length 5
  BOTTOM w0.102: CV106.2 154.05,105.03 154.05,105.35 153.89,105.51 153.88,105.51 153.5,105.88 153.5,105.9 152.95,106.45 152.95,107.89 152.82,108.02 152.82,108.37 152.91,108.46 153.09,108.46 153.19,108.36 153.19,108.23 UV8.E1
VMM2320_P3: length 21.6
  TOP w0.102: v2(145.02,112.77) 144.76,113.03 144.76,113.19 144.52,113.42 144.26,113.42 144.17,113.51 UV600.32
  IN4 w0.091: v2(145.02,112.77) 144.7,112.44 144.7,109.16 150.11,103.76 151.24,103.76 151.61,103.38 151.61,102.68 151.88,102.4 155.64,102.4 155.87,102.64 155.87,102.78 v2(155.67,102.99)
  BOTTOM w0.102: CV108.1 155.85,103.46 155.85,103.17 v2(155.67,102.99)
VMM2320_P3_C: length 5.6
  BOTTOM w0.102: CV108.2 155.7,104.52 155.86,104.52 155.95,104.61 155.95,105.2 155.49,105.65 154.92,105.65 153.86,106.71 153.86,107.74 153.78,107.82 153.68,107.82 153.62,107.88 153.62,108.08 153.7,108.16 UV8.D1
VMM2320_VGA_DET: length 4.3
  BOTTOM w0.102: UV8.M3 148.49,109.46 148.03,109.01 148.03,108.4 147.85,108.21 v1(146.18,108.21) 145.43,108.21 RV88.2
VMM2320_VGA_IREF: length 4.5
  BOTTOM w0.102: UV8.M5 148.4,110.76 148.24,110.59 147.84,110.59 147.5,110.25 146.92,110.25 146.75,110.42 RV89.1 v1(145.3,111.4)
VMM2320_VGA_NC: length 2.8
  BOTTOM w0.102: UV8.L5 148.92,110.46 148.45,110.46 148.38,110.38 147.95,110.38 147.6,110.02 146.87,110.02 T108.1
VMM_DPB_CTRLCLK: length 14.8
  BOTTOM w0.102: UV11.12 140.34,122.47 140.66,122.79 140.66,123.08 140.76,123.18 141.42,123.18 v4(142.29,122.3) 142.64,121.96 142.64,121.21 143.04,120.81 143.04,120.79 143.41,120.42 143.43,120.42 144.05,119.8 144.05,119.17 144.33,118.88 RPV1.2 145.05,118.88 145.19,119.03 146.6,119.03 148.87,116.76 148.87,116.54 149.16,116.25 149.58,116.25 UV8.K13
VMM_DPB_CTRLDAT: length 14.8
  BOTTOM w0.102: UV11.9 140.35,124.42 140.66,124.11 140.66,123.56 140.82,123.4 141.51,123.4 142.25,122.65 142.27,122.65 142.64,122.28 142.64,122.26 142.85,122.05 142.85,121.3 v4(143.39,120.77) 144.26,119.89 144.26,119.48 144.36,119.38 RPV1.1 145.05,119.38 145.19,119.24 146.69,119.24 148.97,116.96 149.47,116.96 149.58,116.85 149.58,116.55 149.5,116.47 149.37,116.47 UV8.L14
VMM_DPC_CTRLCLK: length 31.5
  IN4 w0.091: v2(161.19,102.57) 161.67,102.57 161.86,102.76 161.86,103.31 157.5,107.67 157.5,108.29 155.58,110.22 155.58,115.7 157.29,117.41 157.29,117.68 v2(157.13,117.85)
  BOTTOM w0.102: UV8.B12 155.26,115.31 155.62,115.66 155.84,115.66 156.06,115.88 156.06,116.22 157.13,117.29 v2(157.13,117.85) 157.29,118.01 157.29,118.61 157.74,119.05 v4(159.43,119.05) 160.15,119.05 161.47,117.73 162.35,117.73 162.49,117.87 RPV2.4 ; v2(161.19,102.57) 161.19,102.25 161.09,102.15 UV12.12
VMM_DPC_CTRLDAT: length 31.1
  IN4 w0.091: v2(157.71,117.85) 157.48,117.62 157.48,117.36 155.75,115.62 155.75,110.29 157.67,108.36 157.67,107.74 162.3,103.11 162.55,103.11 v2(163.04,102.63)
  BOTTOM w0.102: UV8.A12 155.82,115.21 155.9,115.21 156.09,115.39 156.09,115.6 156.28,115.79 156.28,116.13 157.34,117.2 157.34,117.48 v2(157.71,117.85) 157.51,118.05 157.51,118.52 157.83,118.84 159.15,118.84 159.16,118.82 159.69,118.82 159.7,118.84 160.06,118.84 161.38,117.51 162.35,117.51 162.49,117.37 RPV2.3 ; v2(163.04,102.63) UV12.9
VMM_GPIO4: length 4.2
  BOTTOM w0.102: RV518.2 156.19,119.83 155.12,118.76 v1(155.12,118.75) 155.12,117.24 155.07,117.19 UV8.B14
VMM_GPIO5: length 5.3
  BOTTOM w0.102: RV519.2 156.75,118.94 v1(156.73,118.94) 156.1,118.94 155.45,118.29 155.45,117.22 155.41,117.18 155.41,116.3 UV8.B13
VMM_GPIO6: length 5
  BOTTOM w0.102: RV83.1 157.29,105.02 155.82,106.49 v1(155.43,106.49) 155.25,106.49 154.58,107.16 154.58,108.01 UV8.C1
VMM_GPIO7: length 5
  BOTTOM w0.102: RV15.1 144.63,115.79 v1(144.73,115.69) 144.83,115.59 148.3,115.59 UV8.M12
VMM_GPIO8: length 5.6
  BOTTOM w0.102: RV14.1 144.35,117.28 v1(146.37,117.28) 147.26,117.28 UV8.M13
VMM_GPIO9: length 5.1
  BOTTOM w0.102: UV8.L3 149.03,109.46 148.72,109.15 148.5,109.15 148.26,108.91 148.26,108.34 147.8,107.88 145.62,107.88 RV73.1
VMM_SPI_CLK: length 14.4
  TOP w0.102: v2(153.51,100.4) v1(153.51,101.07)
  IN2 w0.122: v2(153.51,100.4) 153.44,100.47 153.44,107.28 154.75,108.58 v5(154.75,109.14)
  BOTTOM w0.102: v2(153.51,100.4) 153.96,100.85 155.26,100.85 155.73,100.38 UV9.6 ; v5(154.75,109.14) 155.07,109.46 UV8.B3
VMM_SPI_CS#: length 21
  IN2 w0.122: v2(154.4,98.87) 157.22,101.7 157.22,102.46 156.94,102.74 156.94,105.49 157.36,105.91 157.36,108.58 v2(157.73,108.96)
  BOTTOM w0.102: v2(157.73,108.96) 157.07,108.96 156.5,109.53 156.31,109.53 UV8.A4 ; v2(154.4,98.87) 154.4,98.68 153.56,97.84 UV9.1 150.82,97.84 150.6,97.63 150.6,96.64 v1(150.76,96.47) 150.88,96.36 RV86.2
VMM_SPI_DIN: length 16.2
  TOP w0.102: v2(153.81,98.87) v1(153.81,98.19)
  IN2 w0.122: v5(155.4,109.79) 156.4,108.78 156.4,106.09 156.69,105.8 156.69,102.63 156.97,102.35 156.97,101.83 154.51,99.37 154.12,99.37 153.81,99.06 v2(153.81,98.87)
  BOTTOM w0.102: v2(153.81,98.87) 153.57,99.11 UV9.2 ; UV8.B4 v5(155.4,109.79)
VMM_SPI_DO: length 12.2
  TOP w0.102: v2(158.32,108.96) v1(158.32,109.53)
  IN2 w0.122: v2(158.32,108.96) 158.32,108.66 157.68,108.02 157.68,103.58 158.02,103.24 v2(158.02,103)
  BOTTOM w0.102: v2(158.32,108.96) 157.89,108.54 157.05,108.54 156.31,109.27 155.96,109.27 155.78,109.46 UV8.A3 ; UV9.5 157.7,101.65 158.02,101.97 v2(158.02,103)
VMM_SPI_HOLD: length 4
  BOTTOM w0.102: v1(158.45,101.01) 158.45,99.55 158.02,99.11 ; RV87.2 158.26,99.11 158.02,99.11 ; 158.02,99.11 UV9.7
VMM_SPI_WP#: length 16.7
  TOP w0.102: v2(158.12,106.47) 157.83,106.76 RV517.2 ; v2(154.12,100.4) v1(154.12,99.83)
  IN2 w0.122: v5(155.4,108.49) 154.89,107.98 154.89,101.17 v2(154.12,100.4)
  IN3 w0.122: v2(158.12,106.47) 158.12,106.48 156.11,108.49 v5(155.4,108.49)
  BOTTOM w0.102: UV9.3 152.94,100.38 153.33,99.99 153.71,99.99 v2(154.12,100.4) ; UV8.B1 v5(155.4,108.49)
VR_HOT#: length 4.8
  BOTTOM w0.203: PR534.2 82.51,101.2 82.83,100.88 83.37,100.88 v1(83.61,100.64) 83.91,100.33 85.91,100.33 86.27,100.7 PU500.30
VREF: length 26.5
  TOP w0.254: v2(85.54,99.34) 86.06,99.34 86.3,99.1 PC507.2 ; v2(94.43,99.08) 94.43,99.14 v1(94.09,99.47) 94.09,99.62 94.41,99.94 v2(94.41,101.69)
  IN1 w0.254: v2(85.54,99.34) 86.05,98.83 94.19,98.83 v2(94.43,99.08)
  BOTTOM w0.203: PU500.27 86.13,99.5 85.97,99.34 v2(85.54,99.34)
  BOTTOM w0.254: PR500.2 93.8,98.45 v2(94.43,99.08) ; v2(85.54,99.34) 85.04,99.34 PR521.2 ; PH500.1 98.93,107.2 94.9,103.18 PR504.2 PR503.2 PR502.2 94.19,101.4 94.41,101.63 v2(94.41,101.69)
VSET_5085: length 4.9
  TOP w0.102: UE2.A17 209.37,97.71 209.73,98.07 210.26,98.07 210.63,98.44 CE38.1 ; v1(209.67,99.91) 209.67,99.69 210.17,99.18 CE38.1 ; CE38.1 RE77.1
VSYNC_DOCK: length 34.3
  IN2 w0.122: v2(159.1,126.86) 158.42,126.18 157.78,126.18 157.51,126.45 157.51,127.81 155.41,129.91 153.22,129.91 150.74,127.43 150.33,127.43 148.15,125.25 148.15,121.59 146.88,120.32 146.88,119.43 148.66,117.66 148.66,116.77 148.21,116.32 148.21,114.65 v2(146.92,113.35)
  BOTTOM w0.102: UV8.L9 148.89,113.69 148.43,113.69 148.08,114.04 147.6,114.04 v2(146.92,113.35) ; v2(159.1,126.86) 159.25,127.02 JDOCK1.67
WIGIG_32KHZ: length 38.9
  TOP w0.102: v1(181.08,109.68) 181.32,109.92 181.32,110.16 v2(181.24,110.24) 181.24,110.44 180.95,110.73 RZ56.2 RZ57.2
  BOTTOM w0.102: v2(181.24,110.24) 181.24,110.14 180.84,109.73 178.13,109.73 177.88,109.99 174.31,109.99 171.97,107.65 171.97,104.05 172.75,103.28 172.75,96.33 175.78,93.3 178.89,93.3 182.55,89.64 JNGFF1.42
WIGIG_32KHZ_R: length 2.1
  TOP w0.102: v1(179.42,108.92) 179.11,109.22 RZ57.1 179.11,109.82 UZ11.4
WIGIG_AUX: length 57
  TOP w0.102: UV600.26 141.22,111.93 141.29,111.86 141.29,111.65 v2(141.1,111.46) 140.69,111.05 140.32,111.05 RV609.2 ; CV149.1 175.03,89.62 175.03,90.22 174.72,90.53 174.21,90.53 169.13,95.61 169.13,101.17 169.28,101.32 v4(169.28,103.69) 169.28,108.14 169.4,108.26 169.59,108.26 v2(169.79,108.05)
  IN1 w0.091: v2(141.1,111.46) 141.3,111.25 141.3,111.07 142.26,110.12 144.38,110.12 148.25,106.25 155.46,106.25 156.78,107.58 162.96,107.58 163.64,108.25 169.59,108.25 v2(169.79,108.05)
WIGIG_AUX#: length 56.7
  TOP w0.102: CV150.1 174.81,89.61 174.81,90.13 174.63,90.31 174.12,90.31 168.91,95.52 168.91,101.26 169.06,101.41 169.06,103.41 169.05,103.42 169.05,103.95 169.06,103.96 169.06,108.23 169.31,108.47 169.62,108.47 v2(169.79,108.64) ; RV605.2 141.24,111.05 141.29,111.05 141.68,111.44 v2(141.68,111.46) 141.52,111.62 141.52,111.86 141.62,111.96 UV600.27
  IN1 w0.091: v2(141.68,111.46) 141.48,111.25 141.48,111.14 142.33,110.29 144.46,110.29 148.32,106.42 155.39,106.42 156.71,107.75 162.89,107.75 163.57,108.42 169.57,108.42 v2(169.79,108.64)
WIGIG_AUX#_C: length 2.3
  TOP w0.102: CV150.2 174.82,87.96 174.82,87.7 v2(174.68,87.56)
  BOTTOM w0.102: JNGFF1.12 175.05,87.93 v2(174.68,87.56)
WIGIG_AUX_C: length 2.3
  TOP w0.102: v2(175.26,87.56) 175.03,87.79 175.03,87.98 CV149.2
  BOTTOM w0.102: v2(175.26,87.56) 175.55,87.84 JNGFF1.14
WIGIG_HPD: length 72.3
  TOP w0.102: v2(173.61,82.48) 173.61,84.37 172.52,85.46 169.04,85.46 164.77,89.74 164.77,96.73 163.68,97.81 163.68,101.5 165.72,103.55 165.72,109.71 164.98,110.46 164.98,112.7 v1(163.05,114.62) 163.05,117.23 v2(161.99,118.29) ; UV600.48 v2(144.78,119.91)
  IN3 w0.122: v2(144.78,119.91) 160.37,119.91 v2(161.99,118.29)
  BOTTOM w0.102: v2(173.61,82.48) 173.61,80 174.5,79.11 177.23,79.11 177.8,79.68 JNGFF1.23
